# Allegro board TS28247BC0_FM61_agilex_PCIe_DEVKIT_ADI_REVB1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_DIMM_CH0_A14: length 78.7
  L12_SIG4 w0.089: v1(125.31,76.43) 125.73,76.01 125.85,75.7 126.06,75.49 126.32,75.49 126.91,74.91 127.26,74.91 127.77,74.4 128.15,74.4 128.51,74.04 129.06,74.04 129.34,74.32 129.9,74.32 130.18,74.04 130.82,74.04 131.2,74.42 131.55,74.42 132.04,74.91 132.47,74.91 133,75.44 133.28,75.44 133.79,75.95 134.2,75.95 134.73,76.48 135.11,76.48 135.54,76.91 135.85,76.91 136.13,77.2 136.13,80.17 136.59,80.63 136.59,81.03 136.82,81.26 136.82,84.51 136.72,84.61 136.58,84.61 136.48,84.51 136.48,81.62 136.38,81.52 136.24,81.52 136.14,81.62 136.14,84.78 136.9,85.54 136.9,88.61 137.2,88.91 138.89,88.91 138.99,89.01 138.99,89.15 138.89,89.25 138.01,89.25 137.91,89.35 137.91,89.5 138.01,89.6 139.46,89.6 139.64,89.78 141.08,89.78 141.18,89.88 141.18,90.03 141.08,90.13 140.17,90.13 140.07,90.23 140.07,90.37 140.17,90.47 140.73,90.47 141.29,91.03 141.97,91.03 142.27,91.33 143.07,91.33 143.17,91.23 143.17,91.09 143.07,90.99 142.6,90.99 142.5,90.89 142.5,90.75 142.6,90.65 144.07,90.65 144.17,90.55 144.17,90.41 144.07,90.3 141.86,90.3 141.76,90.2 141.76,90.06 141.86,89.96 145.39,89.96 145.62,90.19 145.62,90.79 145.36,91.04 144.2,91.04 143.97,91.26 143.97,91.62 144.1,91.75 144.1,93.53 144.2,93.63 144.34,93.63 144.44,93.53 144.44,92.13 144.54,92.03 144.68,92.03 144.78,92.13 144.78,93.69 146.97,95.88 148.79,95.88 149.08,96.17 149.08,96.52 148.59,97.01 147.29,97.01 147.19,96.91 147.19,96.77 147.29,96.67 148.08,96.67 148.18,96.57 148.18,96.43 148.08,96.32 146.94,96.32 145.43,97.84 142.24,97.84 v1(141.84,97.44)
DDR4_DIMM_CH0_A15: length 79.6
  L12_SIG4 w0.089: v1(143.54,91.44) 143.54,93.79 143.75,94 144.58,94 145.65,95.07 145.65,96.8 145.43,97.02 141.7,97.02 141.43,97.29 141.43,98.34 141.72,98.64 155.71,98.64 155.89,98.82 155.89,99.29 155.71,99.47 150.12,99.47 148.99,100.6 148.32,100.6 148.12,100.4 147.29,100.4 146.99,100.69 146.45,100.69 145.57,101.56 137.52,101.56 135.78,99.82 134.12,99.82 133.82,99.52 132.98,99.52 132.62,99.16 132.62,90.4 131.81,89.59 131.81,80.4 130.57,79.16 130.57,78.6 130.09,78.12 130.09,77.85 129.76,77.52 129.4,77.52 128.9,77.03 128.36,77.03 128.08,77.31 127.74,77.31 127.48,77.04 126.28,77.04 v1(126.17,76.93)
DDR4_DIMM_CH0_A16: length 77.9
  L12_SIG4 w0.089: v1(140.14,91.44) 140.65,91.44 141.42,92.21 141.95,92.21 142.22,92.48 142.22,93.84 142.34,93.96 142.73,93.96 142.84,94.06 142.84,94.2 142.73,94.31 142.33,94.31 142.22,94.41 142.22,94.56 142.35,94.7 144.2,94.7 144.3,94.8 144.3,94.94 144.2,95.04 141.95,95.04 141.82,94.9 141.82,92.72 141.71,92.62 141.54,92.62 141.44,92.72 141.44,94.96 141.33,95.07 141.16,95.07 141.06,94.97 141.06,94.08 140.96,93.98 140.79,93.98 140.69,94.08 140.69,95 140.59,95.1 140.35,95.1 140.25,95 140.25,93.57 140.57,93.25 140.57,92.29 140.37,92.09 140.11,92.09 139.91,92.29 139.91,95.03 139.81,95.13 139.66,95.13 139.56,95.03 139.56,91.97 139.46,91.87 139.32,91.87 139.22,91.97 139.22,95.2 139.12,95.3 138.95,95.3 138.85,95.2 138.85,94.03 138.75,93.93 138.61,93.93 138.51,94.03 138.51,94.66 138.41,94.76 138.26,94.76 138.16,94.66 138.16,93.86 138.06,93.76 137.92,93.76 137.82,93.86 137.82,94.37 137.72,94.47 137.58,94.47 137.48,94.37 137.48,92.47 137.58,92.36 137.72,92.36 137.82,92.47 137.82,93.07 137.92,93.17 138.15,93.17 138.38,92.94 138.61,92.94 138.83,92.73 138.83,91.06 138.57,90.8 137.67,90.8 137.57,90.7 137.57,90.56 137.67,90.46 138.62,90.46 138.72,90.36 138.72,90.22 138.62,90.12 136.65,90.12 136.36,89.83 136.36,85.53 134.84,84.01 134.84,83.18 134.98,83.04 135.69,83.04 135.8,82.92 135.8,82.78 135.7,82.68 134.83,82.68 134.73,82.58 134.73,82.42 134.83,82.32 135.7,82.32 135.8,82.22 135.8,81.71 135.7,81.61 135.1,81.61 135,81.51 135,81.32 135.1,81.22 136.16,81.22 136.27,81.12 136.27,80.95 136.16,80.85 135.42,80.85 135.28,80.72 135.28,77.67 135.03,77.42 134.65,77.42 134.2,76.96 133.79,76.96 133.28,76.46 132.98,76.46 132.42,75.9 132.01,75.9 131.55,75.44 131.17,75.44 130.66,74.93 130.23,74.93 129.85,74.55 129.37,74.55 129.04,74.88 128.28,74.88 127.23,75.93 v1(126.17,75.93)
DDR4_DIMM_CH0_A17: length 77.2
  L12_SIG4 w0.089: v1(127.04,77.43) 127.49,77.43 127.58,77.52 128.08,77.52 128.36,77.81 128.98,77.81 130.2,79.02 130.2,79.32 130.94,80.07 130.94,82.15 131.39,82.6 131.39,89.83 132.23,90.67 132.23,99.59 132.59,99.95 133.67,99.95 133.89,100.16 135.63,100.16 137.4,101.93 145.69,101.93 146.16,101.47 146.72,101.47 147.37,100.82 147.89,100.82 148.16,101.09 148.99,101.09 149.39,100.69 156.87,100.69 156.97,100.59 156.97,100.37 156.87,100.27 153.86,100.27 153.76,100.17 153.76,99.98 153.86,99.88 156.43,99.88 156.75,99.56 156.75,98.64 156.37,98.26 153.98,98.26 153.88,98.16 153.88,97.91 153.98,97.81 156.93,97.81 157.03,97.71 157.03,97.45 156.93,97.35 153.94,97.35 153.45,96.87 152.41,96.87 151.44,97.85 147.35,97.85 v1(146.94,97.44)
DDR4_DIMM_CH0_ACT_N: length 82.8
  L14_SIG5 w0.081: v1(118.09,91.44) 117.07,91.44 116.65,91.03 115.84,91.03 115.74,90.93 115.74,90.79 115.84,90.69 116.6,90.69 116.7,90.59 116.7,90.45 116.6,90.36 114.94,90.36 114.7,90.11 114.7,89.29 114.6,89.19 114.46,89.19 114.36,89.29 114.36,90.24 114.26,90.34 114.12,90.34 114.03,90.24 114.03,88.47 113.93,88.37 113.79,88.37 113.69,88.47 113.69,90.46 113.59,90.56 113.45,90.56 113.35,90.46 113.35,88.91 113.26,88.81 113.12,88.81 113.02,88.91 113.02,90.97 112.92,91.07 112.78,91.07 112.68,90.97 112.68,88.85 112.59,88.75 112.45,88.75 112.35,88.85 112.35,91.21 112.59,91.45 112.59,91.64 112.48,91.75 111.87,91.75 111.77,91.65 111.77,91.51 112.01,91.26 112.01,88.88 111.92,88.78 111.78,88.78 111.68,88.88 111.68,91.01 111.58,91.11 111.44,91.11 111.34,91.01 111.34,89.54 111.24,89.44 111.11,89.44 111.01,89.54 111.01,91.08 110.91,91.18 110.77,91.18 110.67,91.08 110.67,87.08 110.77,86.98 110.91,86.98 111.01,87.08 111.01,88.98 111.11,89.08 111.24,89.08 111.34,88.98 111.34,88.21 111.85,87.7 111.85,87.15 111.68,86.97 111.53,86.97 111.38,86.82 111.38,86.68 111.52,86.54 112.09,86.54 112.19,86.64 112.19,87.94 112.29,88.03 112.42,88.03 112.52,87.94 112.52,86.67 112.62,86.57 112.76,86.57 112.86,86.67 112.86,87.95 112.96,88.05 113.09,88.05 113.19,87.95 113.19,86.92 113.29,86.83 113.43,86.83 113.53,86.92 113.53,87.86 113.63,87.96 113.77,87.96 113.86,87.86 113.86,86.53 113.57,86.24 113.57,84.43 113.67,84.33 114.43,84.33 114.53,84.43 114.53,84.57 114.43,84.67 114.06,84.67 113.97,84.76 113.97,84.9 114.06,85 114.47,85 114.57,85.1 114.57,85.24 114.47,85.34 114.02,85.34 113.93,85.43 113.93,85.83 114.2,86.1 114.2,87.75 114.3,87.84 114.44,87.84 114.53,87.75 114.53,86.25 114.74,86.05 115.15,86.05 115.52,86.43 115.96,86.43 116.44,85.95 116.44,85.81 116.34,85.72 116.05,85.72 115.81,85.96 115.63,85.96 115.29,85.62 115.29,85.48 115.39,85.38 116.18,85.38 116.28,85.28 116.28,85.14 116.18,85.04 115.16,85.04 115.06,84.95 115.06,84.81 115.16,84.71 116.16,84.71 116.26,84.61 116.26,84.47 116.16,84.37 115.39,84.37 115.29,84.28 115.29,84.14 115.39,84.04 116.47,84.04 117.96,82.54 117.96,78.19 118.22,77.93 118.4,77.93 118.8,77.54 118.8,76.85 v1(118.38,76.43)
DDR4_DIMM_CH0_ALERT_N: length 79.3
  L14_SIG5 w0.081: v1(127.04,74.43) 128.31,75.7 128.31,78.63 128.59,78.92 129.02,78.92 129.27,79.17 129.27,79.56 129.98,80.27 130.12,80.27 130.21,80.17 130.21,80.03 129.74,79.56 129.74,79.42 129.84,79.32 129.98,79.32 130.97,80.32 130.97,81.18 131.19,81.4 131.54,81.4 131.95,81.81 132.29,81.81 133.53,83.05 133.53,83.57 133.86,83.9 134.04,83.9 135.27,85.12 135.27,85.62 135.58,85.94 136.05,85.94 136.38,86.27 136.38,88.25 136.48,88.35 136.62,88.35 136.72,88.25 136.72,86.69 136.82,86.59 136.95,86.59 137.05,86.69 137.05,90.21 136.95,90.31 136.82,90.31 136.72,90.21 136.72,88.86 136.62,88.76 136.48,88.76 136.36,88.88 136.36,91.64 136.57,91.85 137.76,91.85 137.97,91.64 137.97,87.47 138.07,87.37 138.24,87.37 138.34,87.47 138.34,92.07 138.19,92.23 136.12,92.23 136.03,92.13 136.03,89.9 135.93,89.8 135.79,89.8 135.69,89.9 135.69,92.58 135.59,92.68 135.45,92.68 135.36,92.58 135.36,91.75 135.26,91.65 135.12,91.65 135.02,91.75 135.02,92.22 131.79,95.46 131.79,95.6 131.88,95.69 132.02,95.69 133.61,94.11 133.75,94.11 133.85,94.2 133.85,94.34 132.38,95.81 132.38,96.16 131.59,96.95 130.62,96.95 128.67,98.9 128.67,99.43 128.39,99.72 127.87,99.72 127.62,99.47 127.07,99.47 126.78,99.76 120.97,99.76 119.74,98.53 v1(119.74,97.44)
DDR4_DIMM_CH0_BA0: length 77.6
  L12_SIG4 w0.089: v1(139.29,91.44) 139.68,91.05 140.81,91.05 141.61,91.86 142.93,91.86 143.2,92.13 143.2,94.17 143.37,94.34 144.44,94.34 145.31,95.22 145.31,96.43 145.15,96.59 144.99,96.59 144.86,96.46 144.86,96.07 144.73,95.94 143.99,95.94 143.89,95.84 143.89,95.56 143.79,95.46 143.62,95.46 143.52,95.56 143.52,96.18 143.62,96.28 143.89,96.28 143.99,96.38 143.99,96.53 143.89,96.63 143.19,96.63 143.09,96.53 143.09,96.04 142.98,95.94 142.58,95.94 142.16,95.52 140.57,95.52 140.47,95.62 140.47,95.76 140.57,95.86 141.91,95.86 142.01,95.96 142.01,96.1 141.91,96.21 140.8,96.21 140.7,96.31 140.7,96.45 140.8,96.55 141.27,96.55 141.41,96.69 141.41,96.83 141.05,97.19 141.05,98.71 140.95,98.81 140.69,98.81 140.59,98.71 140.59,96.91 140.43,96.75 140.29,96.75 140.13,96.91 140.13,98.66 139.97,98.82 139.47,98.82 139.31,98.66 139.31,98.09 139.74,97.66 139.74,95.6 139.64,95.5 139.5,95.5 139.39,95.6 139.39,96.94 139.29,97.04 139.15,97.04 139.05,96.94 139.05,95.76 138.95,95.66 138.81,95.66 138.71,95.76 138.71,96.94 138.61,97.04 138.47,97.04 138.37,96.93 138.37,95.53 137.75,94.91 137.26,94.91 137.11,94.76 137.11,92.48 136.23,91.6 136.23,90.66 135.1,89.53 135.1,84.85 134.4,84.14 134.4,77.92 134.3,77.82 134.15,77.82 134.05,77.92 134.05,79.92 133.95,80.02 133.81,80.02 133.71,79.92 133.71,78.26 133.61,78.16 133.47,78.16 133.37,78.26 133.37,79.38 133.27,79.48 133.12,79.48 133.02,79.38 133.02,78.41 132.92,78.31 132.78,78.31 132.68,78.41 132.68,78.75 132.58,78.85 132.44,78.85 132.34,78.75 132.34,77.96 132.76,77.54 132.76,77.24 132.44,76.93 132.04,76.93 131.54,76.43 131.14,76.43 130.74,76.03 130.44,76.03 129.84,75.43 129.41,75.43 129.03,75.81 128.55,75.81 128.05,76.31 127.54,76.31 127.42,76.43 v1(127.04,76.43)
DDR4_DIMM_CH0_BA1: length 76.2
  L12_SIG4 w0.089: v1(138.44,97.44) 138.02,97.86 138.02,98.39 139.14,99.51 144.73,99.51 145.12,99.12 148.66,99.12 148.82,99.28 148.82,99.56 148.66,99.71 146.5,99.71 145.56,100.65 137.09,100.65 135.7,99.26 135.7,96.38 135.6,96.28 135.46,96.28 135.36,96.38 135.36,99.28 135.26,99.39 135.12,99.39 135.02,99.28 135.02,96.42 134.92,96.32 134.78,96.32 134.68,96.42 134.68,99.29 134.58,99.39 134.43,99.39 134.33,99.29 134.33,96.7 134.23,96.6 134.09,96.6 133.99,96.7 133.99,98.99 133.89,99.09 133.75,99.09 133.65,98.99 133.65,96.83 133.55,96.73 133.4,96.73 133.3,96.83 133.3,98.93 133.2,99.03 133.06,99.03 132.96,98.93 132.96,89.94 132.65,89.62 132.65,80.23 131.04,78.62 131.04,78.49 129.85,77.31 129.48,77.31 128.99,76.81 128.02,76.81 v1(127.9,76.93)
DDR4_DIMM_CH0_BG0: length 76.4
  L14_SIG5 w0.081: v1(118.89,91.44) 119.36,91.91 119.36,94.04 120.16,94.83 120.79,94.83 121.02,95.06 121.02,98.11 121.55,98.64 123.02,98.64 123.26,98.4 123.26,97.1 123.7,96.66 124.63,96.66 125.24,97.27 125.24,98.68 125.45,98.89 128.21,98.89 130.53,96.57 131.08,96.57 131.24,96.4 131.24,95.53 132.03,94.74 132.03,94.6 131.93,94.51 131.79,94.51 130.67,95.62 130.54,95.62 130.44,95.52 130.44,95.38 132.69,93.14 132.82,93.14 132.92,93.23 132.92,93.37 132.24,94.05 132.24,94.19 132.34,94.29 132.48,94.29 134.67,92.1 134.67,91.96 134.57,91.86 134.43,91.86 133.43,92.86 133.29,92.86 133.2,92.76 133.2,92.62 134.59,91.23 135.21,91.23 135.31,91.13 135.31,90.99 135.21,90.89 134.41,90.89 134.31,90.8 134.31,90.66 134.41,90.56 135.21,90.56 135.31,90.46 135.31,90.32 135.21,90.22 134.41,90.22 134.31,90.13 134.31,89.99 134.41,89.89 135.21,89.89 135.31,89.79 135.31,89.65 135.21,89.55 134.41,89.55 134.31,89.45 134.31,89.32 134.41,89.22 135.35,89.22 135.45,89.12 135.45,88.98 135.35,88.88 134.41,88.88 134.31,88.78 134.31,88.65 134.41,88.55 135.21,88.55 135.31,88.45 135.31,88.31 135.21,88.21 134.41,88.21 134.31,88.11 134.31,87.97 134.41,87.88 135.29,87.88 135.39,87.78 135.39,87.64 135.29,87.54 134.47,87.54 134.37,87.44 134.37,87.3 134.47,87.21 135.38,87.21 135.48,87.11 135.48,86.97 135.38,86.87 134.02,86.87 133.92,86.77 133.92,86.63 134.02,86.54 135.21,86.54 135.31,86.44 135.31,86.3 135.21,86.2 134.02,86.2 133.92,86.1 133.92,85.96 134.02,85.86 134.82,85.86 134.93,85.75 134.93,85.28 134.47,84.82 133.76,84.82 133.13,84.19 133.13,83.28 132.78,82.93 132.01,82.93 131.44,82.36 131.18,82.36 130.75,81.92 130.44,81.92 130.08,81.56 130.08,80.73 129.84,80.5 129.56,80.5 129,79.94 128.66,79.94 128.17,79.45 127.71,79.45 127.47,79.21 127.47,76.36 v1(127.9,75.93)
DDR4_DIMM_CH0_BG1: length 84.1
  L14_SIG5 w0.081: v1(118.89,97.44) 118.89,96.77 117.01,94.89 117.01,94.75 117.24,94.52 117.24,94.38 117.14,94.28 117,94.28 116.77,94.51 116.63,94.51 116.53,94.41 116.53,94.28 116.88,93.93 116.88,93.79 116.78,93.69 116.64,93.69 116.3,94.04 116.16,94.04 115.02,92.9 115.02,91.21 114.85,91.05 114.4,91.05 114.2,91.25 114.2,93.16 115.35,94.31 115.35,95.23 115.25,95.32 115.11,95.32 115.01,95.23 115.01,94.64 114.91,94.54 114.77,94.54 114.68,94.64 114.68,94.89 114.58,94.98 114.44,94.98 114.34,94.89 114.34,93.88 114.24,93.78 114.1,93.78 114,93.88 114,95.43 113.91,95.53 113.77,95.53 113.67,95.43 113.67,93.03 113.57,92.93 113.43,92.93 113.33,93.03 113.33,95 113.23,95.1 113.1,95.1 113,95 113,94.87 112.9,94.77 112.63,94.77 112.52,94.67 112.52,94.51 112.63,94.4 112.91,94.4 113,94.32 113,94.08 112.47,93.55 109.99,93.55 109.89,93.65 109.89,93.79 109.99,93.89 111.8,93.89 111.9,93.99 111.9,94.13 111.8,94.22 110.63,94.22 110.53,94.32 110.53,94.46 110.63,94.56 111.7,94.56 111.8,94.66 111.8,94.8 111.7,94.89 109.89,94.89 109.79,94.99 109.79,95.13 109.89,95.23 112.45,95.23 112.55,95.33 112.55,95.47 112.45,95.57 110.07,95.57 109.77,95.86 109.35,95.86 109.06,95.57 108.75,95.57 108.65,95.47 108.65,95.33 108.75,95.23 109.23,95.23 109.33,95.13 109.33,94.99 109.23,94.89 108.76,94.89 108.66,94.8 108.66,94.66 108.76,94.56 109.54,94.56 109.64,94.46 109.64,94.32 109.54,94.22 108.76,94.22 108.66,94.13 108.66,93.99 108.76,93.89 109.11,93.89 109.21,93.79 109.21,93.65 109.11,93.55 108.76,93.55 108.64,93.43 108.64,93.26 108.85,93.05 110.29,93.05 110.39,92.95 110.39,92.81 110.29,92.71 109.03,92.71 108.92,92.6 108.92,92.24 109.33,91.82 109.5,91.82 109.6,91.92 109.6,92.19 109.7,92.3 109.83,92.3 109.94,92.19 109.94,91.25 109.23,90.55 108.8,90.55 108.7,90.45 108.7,90.31 108.8,90.21 109.21,90.21 109.31,90.12 109.31,89.98 109.21,89.88 108.8,89.88 108.7,89.78 108.7,89.64 108.8,89.54 109.21,89.54 109.31,89.45 109.31,89.31 109.21,89.21 108.8,89.21 108.7,89.11 108.7,88.97 108.8,88.87 109.21,88.87 109.31,88.77 109.31,88.64 109.21,88.54 108.8,88.54 108.7,88.44 108.7,88.3 108.8,88.2 109.21,88.2 109.31,88.1 109.31,86.06 109.41,85.95 109.97,85.95 110.13,85.79 110.13,85.1 110.55,84.68 110.96,84.68 111.06,84.58 111.06,84.43 110.96,84.33 110.57,84.33 110.47,84.23 110.47,84.09 110.78,83.78 112.78,83.78 113.01,83.54 113.39,83.54 114.08,82.86 115.44,82.86 116.24,82.06 116.24,77.24 116.55,76.93 v1(117.51,76.93)
DDR4_DIMM_CH0_C2: length 82
  L12_SIG4 w0.089: v1(124.44,74.93) 124.87,74.49 124.87,74.28 125.15,74.01 125.31,74.01 125.6,73.71 125.68,73.52 125.68,73.07 125.85,72.67 126.1,72.42 126.35,72.42 126.83,71.94 127.29,71.94 127.79,71.43 128.12,71.43 128.58,71.88 128.99,71.88 129.45,71.43 129.72,71.43 130.21,71.91 130.72,71.91 131.2,71.43 131.55,71.43 132.11,71.99 132.49,71.99 132.93,72.42 133.28,72.42 133.81,72.95 134.17,72.95 134.65,73.43 135.01,73.43 135.52,73.94 135.92,73.94 136.43,74.45 136.76,74.45 137.29,74.98 137.7,74.98 138.16,75.44 138.46,75.44 138.73,75.71 138.73,80.67 139.07,81 139.07,81.63 138.73,81.96 138.73,82.9 140.24,84.41 140.24,84.55 140.14,84.65 140,84.65 139.09,83.74 138.95,83.74 138.84,83.84 138.84,83.98 140.93,86.07 141.07,86.07 141.17,85.97 141.17,85.83 140.55,85.2 140.55,85.06 140.65,84.96 140.79,84.96 141.99,86.16 141.99,87.77 142.5,88.29 145.45,88.29 147.42,90.26 147.42,91.57 148.18,92.34 148.18,92.86 148.46,93.14 149.86,93.14 150.08,93.35 151.92,93.35 152.69,92.58 154.21,92.58 154.31,92.48 154.31,92.15 154.41,92.04 154.55,92.04 154.65,92.15 154.65,92.48 154.75,92.58 154.89,92.58 154.99,92.48 154.99,92.15 155.09,92.04 155.24,92.04 155.34,92.15 155.34,92.48 155.44,92.58 155.96,92.58 156.33,92.95 156.33,94.58 156.57,94.83 159.21,94.83 159.31,94.93 159.31,95.07 159.21,95.17 156.44,95.17 156.33,95.28 156.33,95.42 156.44,95.52 159.2,95.52 159.3,95.62 159.3,95.76 159.2,95.86 151.48,95.86 150.73,96.61 149.52,96.61 148.69,97.44 v1(147.79,97.44)
DDR4_DIMM_CH0_CK_N0: length 81.7
  L14_SIG5 w0.079: v1(120.98,75.93) 121.28,76.31 121.46,76.49 121.58,76.77 121.58,77.07 121.47,77.33 121.47,77.53 121.57,77.78 121.57,78.08 121.47,78.33 121.47,78.52 121.57,78.77 121.57,79.1 121.47,79.36 121.47,79.54 121.58,79.82 121.58,80.03 121.47,80.3 121.47,80.53 121.58,80.8 121.58,81.05 121.46,81.33 121.46,81.51 121.58,81.78 121.58,82.07 121.47,82.33 121.47,82.59 121.68,82.81 127.38,82.81 127.77,83.19 127.77,83.75 127.47,84.05 121.43,84.05 120.44,83.06 120.2,83.06 120.02,83.24 120.02,83.47 120.74,84.19 120.74,84.71 120.86,84.83 129.14,84.83 129.44,85.13 129.44,85.73 129.14,86.04 122.6,86.04 122.45,86.18 122.45,86.67 122.6,86.81 129.23,86.81 129.51,87.09 129.51,87.77 129.23,88.04 124.93,88.04 124.79,87.9 121.56,87.9 121.23,87.56 121.23,86.2 121.06,86.03 120.75,86.03 120.58,86.2 120.58,87.96 120.73,88.12 120.73,88.61 120.93,88.81 124.18,88.81 124.44,89.07 124.44,90.49 124.56,90.62 124.9,90.62 125.02,90.49 125.02,89.07 125.28,88.81 125.81,88.81 126.07,89.07 126.07,90.03 126.19,90.16 126.53,90.16 126.65,90.03 126.65,89.07 126.91,88.81 127.44,88.81 127.7,89.07 127.7,89.9 127.87,90.07 128.11,90.07 128.28,89.9 128.28,89.07 128.55,88.81 129.25,88.81 129.51,89.07 129.51,90.18 128.9,90.78 128.9,91.25 v1(129.09,91.44)
DDR4_DIMM_CH0_CK_N1: length 81.1
  L03_SIG1 w0.081: v4(127.9,73.93) 128.35,74.38 128.35,75.17 127.97,75.55 127.62,75.55 127.34,75.83 126.94,75.83 126.6,76.17 126.6,82.15 126.36,82.39 126.36,83.7 126.65,84 126.65,87.58 126.88,87.8 127.61,87.8 129.41,89.6 130.09,89.88 130.8,89.88 131.71,90.79 132.45,90.79 133.93,92.27 133.93,96.14 134.42,96.63 134.8,96.63 135.11,96.32 135.71,96.32 136.02,96.63 136.79,96.63 136.89,96.53 136.89,96.16 136.31,95.57 136.31,94.98 136.64,94.64 137.7,94.64 138.3,94.89 139.44,94.89 139.75,95.2 139.75,95.81 139.42,96.14 138.39,96.14 138.29,96.25 138.29,96.63 138.39,96.74 140.31,96.74 140.68,96.37 141.15,96.37 141.46,96.68 141.46,97.44 140.77,98.13 140.77,98.38 141.46,99.07 141.46,99.34 142.3,100.19 142.3,101.69 141.99,102 140.56,102 140.27,101.71 140.27,100.39 140.07,100.2 139.92,100.2 139.84,100.28 139.65,100.74 139.65,101.57 139.22,102 137.12,102 136.58,102.54 136.58,102.97 135.99,104.41 135.54,104.86 135.13,104.86 134.65,104.38 134.51,104.38 134.02,104.87 133.39,104.87 133.05,104.53 133.05,104.05 133.68,103.42 133.68,103.31 133.62,103.16 133.55,103.09 133.18,103.09 132.66,103.61 132.24,103.61 131.97,103.33 131.81,103.33 130.99,102.52 130.99,102.11 131.29,101.81 131.93,101.81 132.14,102.03 132.44,102.03 132.65,101.81 133.28,101.81 133.59,101.5 133.59,101.25 133.49,101.15 131.44,101.15 131.17,100.88 131.17,98.84 130.9,98.58 130.3,98.58 129.64,97.91 129.64,97.27 129.34,96.98 129.01,96.98 128.91,97.08 128.91,97.26 v4(129.09,97.44)
DDR4_DIMM_CH0_CK_P0: length 81.6
  L14_SIG5 w0.079: v1(128.24,91.44) 128.67,91.01 128.67,90.69 129.28,90.08 129.28,89.16 129.16,89.04 128.64,89.04 128.51,89.17 128.51,89.99 128.2,90.3 127.78,90.3 127.47,89.99 127.47,89.17 127.34,89.04 127.01,89.04 126.88,89.17 126.88,90.13 126.62,90.39 126.1,90.39 125.84,90.13 125.84,89.17 125.71,89.04 125.38,89.04 125.25,89.17 125.25,90.58 124.99,90.85 124.47,90.85 124.21,90.58 124.21,89.17 124.08,89.04 120.84,89.04 120.5,88.71 120.5,88.21 120.35,88.06 120.35,86.11 120.66,85.8 121.15,85.8 121.46,86.11 121.46,87.47 121.66,87.67 124.88,87.67 125.03,87.81 129.14,87.81 129.28,87.68 129.28,87.19 129.13,87.04 122.5,87.04 122.22,86.76 122.22,86.09 122.5,85.81 129.04,85.81 129.21,85.64 129.21,85.22 129.04,85.05 120.76,85.05 120.51,84.8 120.51,84.28 119.79,83.57 119.79,83.14 120.11,82.83 120.53,82.83 121.52,83.82 127.37,83.82 127.54,83.65 127.54,83.29 127.29,83.04 122.71,83.04 122.62,83.13 122.3,83.13 122.21,83.04 121.59,83.04 121.24,82.68 121.24,82.29 121.35,82.03 121.35,81.83 121.23,81.56 121.23,81.29 121.35,81.01 121.35,80.84 121.24,80.57 121.24,80.26 121.35,79.99 121.35,79.87 121.24,79.59 121.24,79.31 121.35,79.05 121.35,78.82 121.24,78.57 121.24,78.29 121.35,78.04 121.35,77.83 121.24,77.58 121.24,77.28 121.35,77.03 121.35,76.81 121.27,76.62 121.19,76.54 121.08,76.54 120.98,76.64 v1(120.98,76.93)
DDR4_DIMM_CH0_CK_P1: length 80.8
  L03_SIG1 w0.081: v4(128.24,97.44) 128.59,97.09 128.59,96.95 128.88,96.65 129.48,96.65 129.96,97.14 129.96,97.78 130.44,98.25 131.03,98.25 131.42,98.64 131.42,100.67 131.57,100.83 133.63,100.83 133.92,101.12 133.92,101.64 133.42,102.14 132.79,102.14 132.58,102.35 132.01,102.35 131.79,102.14 131.42,102.14 131.32,102.24 131.32,102.38 131.94,103.01 132.1,103.01 132.38,103.28 132.52,103.28 133.04,102.77 133.68,102.77 133.89,102.98 134.01,103.25 134.01,103.56 133.38,104.19 133.38,104.4 133.52,104.54 133.89,104.54 134.37,104.06 134.79,104.06 135.26,104.53 135.41,104.53 135.71,104.23 136.26,102.91 136.26,102.41 136.99,101.68 139.09,101.68 139.33,101.44 139.33,100.67 139.57,100.1 139.79,99.87 140.21,99.87 140.59,100.26 140.59,101.57 140.7,101.68 141.85,101.68 141.98,101.55 141.98,100.32 141.13,99.48 141.13,99.21 140.44,98.52 140.44,97.99 141.13,97.3 141.13,96.81 141.01,96.69 140.81,96.69 140.44,97.06 138.26,97.06 137.97,96.77 137.97,96.11 138.26,95.82 139.29,95.82 139.43,95.68 139.43,95.34 139.3,95.22 138.23,95.22 137.64,94.97 136.78,94.97 136.63,95.11 136.63,95.44 137.22,96.02 137.22,96.67 136.93,96.96 135.89,96.96 135.57,96.64 135.24,96.64 134.93,96.96 134.29,96.96 133.6,96.28 133.6,92.4 132.32,91.11 131.57,91.11 130.66,90.21 130.02,90.21 129.39,89.94 127.5,88.05 126.79,88.05 126.33,87.59 126.33,84.13 126.03,83.83 126.03,82.39 125.74,82.1 125.74,75.7 126,75.43 126.33,75.43 126.83,74.93 127.14,74.93 127.45,74.62 127.71,74.62 127.9,74.82 v4(127.9,74.93)
DDR4_DIMM_CH0_CKE0: length 82.7
  L14_SIG5 w0.081: v1(120.11,77.43) 119.68,77.85 119.68,81.18 119.43,81.43 119.14,81.43 118.8,81.78 118.8,82.93 118.7,83.03 118,83.03 117.9,83.13 117.9,83.26 118,83.37 118.71,83.37 118.81,83.47 118.81,83.6 118.71,83.7 117.35,83.7 117.25,83.8 117.25,83.93 117.35,84.04 118.76,84.04 119.25,84.53 119.25,90.75 119.85,91.34 119.85,91.49 119.75,91.58 119.61,91.58 118.92,90.89 118.92,85.01 118.76,84.85 118.25,84.85 117.9,84.5 117.24,84.5 117.06,84.68 117.06,87.98 116.96,88.08 116.82,88.08 116.72,87.98 116.72,86.92 116.62,86.82 116.48,86.82 116.38,86.92 116.38,88.06 116.29,88.16 116.15,88.16 116.05,88.06 116.05,86.92 115.95,86.82 115.81,86.82 115.71,86.92 115.71,88.09 115.62,88.19 115.48,88.19 115.38,88.09 115.38,86.92 115.28,86.82 115.14,86.82 115.04,86.92 115.04,87.75 114.52,88.27 114.52,88.58 115.04,89.11 115.04,89.9 115.14,90 115.28,90 115.38,89.9 115.38,88.9 115.48,88.8 115.62,88.8 115.71,88.9 115.71,89.9 115.81,90 115.95,90 116.05,89.9 116.05,88.89 116.15,88.8 116.29,88.8 116.38,88.89 116.38,89.9 116.48,90 116.62,90 116.72,89.9 116.72,88.93 116.82,88.84 116.96,88.84 117.06,88.93 117.06,90.39 117.15,90.49 117.38,90.49 117.47,90.39 117.47,85.29 117.6,85.17 117.79,85.17 117.91,85.29 117.91,90.87 118.01,90.97 118.15,90.97 118.25,90.87 118.25,88.9 118.34,88.81 118.48,88.81 118.58,88.9 118.58,91.2 118.51,91.28 118.51,91.69 119.03,92.21 119.03,94.18 120.21,95.36 120.21,95.55 120.1,95.67 119.91,95.67 118.61,94.37 118.61,92.4 118.2,91.98 116.88,91.98 v1(116.34,91.44)
  BOTTOM w0.149: v1(116.34,91.44) 116.34,91.45 R12.2
DDR4_DIMM_CH0_CKE1: length 82.2
  L12_SIG4 w0.089: v1(115.49,97.44) 115.88,97.82 126.24,97.82 127.14,98.72 131.52,98.72 131.62,98.62 131.62,97.76 131.52,97.66 131.33,97.66 131.23,97.76 131.23,98.24 131.09,98.38 128.75,98.38 128.65,98.28 128.65,98.14 128.75,98.04 130.51,98.04 130.61,97.94 130.61,97.79 130.51,97.69 128.85,97.69 128.75,97.59 128.75,97.45 128.85,97.35 130.32,97.35 130.42,97.25 130.42,97.11 130.32,97.01 128.85,97.01 128.75,96.91 128.75,96.77 128.85,96.67 129.45,96.67 129.55,96.56 129.55,96.42 129.45,96.32 128.85,96.32 128.75,96.22 128.75,96.04 128.85,95.94 130.15,95.94 130.36,96.15 130.36,96.38 130.57,96.58 131.18,96.58 131.37,96.39 131.37,95.93 131.76,95.53 131.76,93.25 131.66,93.14 131.52,93.14 131.42,93.25 131.42,95.25 131.32,95.35 131.18,95.35 131.08,95.25 131.08,93.31 130.98,93.21 130.84,93.21 130.74,93.31 130.74,95.54 130.64,95.64 130.49,95.64 130.39,95.54 130.39,92.61 130.59,92.41 131.69,92.41 131.82,92.27 131.82,92.08 131.69,91.94 130.55,91.94 130.39,91.79 130.39,91.23 130.54,91.09 131.65,91.09 131.79,90.94 131.79,90.8 131.65,90.65 130.44,90.65 130.28,90.49 130.28,89.55 130.38,89.45 130.53,89.45 130.63,89.55 130.63,90.15 130.73,90.25 130.87,90.25 130.97,90.15 130.97,83.25 130.65,82.92 130.39,82.92 130.07,82.6 130.07,79.77 129.81,79.51 129.81,79.19 129.26,78.64 129.26,78.38 128.89,78.02 128.37,78.02 128.08,78.32 127.73,78.32 127.35,77.93 127.01,77.93 126.38,77.31 125.98,77.31 125.72,77.04 125.15,77.04 124.87,77.33 124.14,77.33 123.84,77.03 123.33,77.03 122.99,77.37 122.5,77.37 122.02,77.85 121.59,77.85 121.14,77.41 120.77,77.41 120.38,77.02 120.38,76.7 v1(120.11,76.43)
DDR4_DIMM_CH0_CS_N0: length 82.5
  L16_SIG6 w0.081: v1(141.84,91.44) 141.84,93.69 142.58,94.43 143.04,94.43 143.8,95.19 143.8,95.42 143.67,95.55 143.45,95.55 142.91,95.01 141.98,95.01 141.84,95.15 141.84,96.09 140.84,97.1 139.48,97.1 139.04,96.66 138.51,96.66 138.36,96.51 138.36,95.36 137.88,94.88 137.16,94.88 137.05,95 137.05,95.59 136.88,95.75 136.53,95.75 136.37,95.59 136.37,93.31 135.66,92.6 134.53,92.6 133.88,93.25 133.88,95.71 133.58,96.01 132.35,96.01 132.03,95.69 130.37,95.69 129.38,94.7 129.38,94.53 129.71,94.19 130.13,94.19 130.23,94.29 130.23,95.09 130.33,95.18 130.46,95.18 130.56,95.09 130.56,94.33 130.66,94.23 130.8,94.23 130.9,94.33 130.9,95.25 131,95.35 131.14,95.35 131.23,95.25 131.23,94.28 131.33,94.18 131.47,94.18 131.57,94.28 131.57,95.25 131.67,95.35 131.81,95.35 131.9,95.25 131.9,94.23 132,94.13 132.14,94.13 132.24,94.23 132.24,95.25 132.34,95.35 132.48,95.35 132.57,95.25 132.57,93.63 132.67,93.54 132.81,93.54 132.91,93.63 132.91,95.53 133.01,95.62 133.15,95.62 133.25,95.53 133.25,92.89 136.49,89.65 136.49,83.12 135.77,82.4 135.77,81.61 135.26,81.1 135.26,80.83 134.9,80.47 134.83,80.47 134.4,80.04 134.4,79.54 133.23,78.37 130.68,78.37 129.83,77.51 129.48,77.51 128.88,76.91 128.53,76.91 128.07,76.46 127.69,76.46 127.24,76.91 126.88,76.91 126.42,76.46 125.94,76.46 125.48,76.91 125.05,76.91 124.59,76.46 124.21,76.46 123.76,76.91 123.3,76.91 122.82,76.43 122.49,76.43 122,76.91 121.6,76.91 121.11,76.43 120.78,76.43 120.28,75.92 119.9,75.92 119.39,76.43 119.08,76.43 118.68,76.84 118.68,77.13 v1(118.38,77.43)
DDR4_DIMM_CH0_CS_N1: length 80.1
  L12_SIG4 w0.089: v1(146.09,91.44) 146.09,92.08 146.48,92.47 146.48,93.68 147.26,94.47 148.23,94.47 148.65,94.89 149.06,94.89 150.09,95.92 150.45,95.92 151.25,95.12 155.19,95.12 155.29,95.02 155.29,94.8 155.17,94.68 153.83,94.68 153.73,94.58 153.73,94.44 153.83,94.34 155.32,94.34 155.42,94.24 155.42,94.09 155.32,93.99 153.84,93.99 153.74,93.89 153.74,93.75 153.84,93.65 155.23,93.65 155.33,93.55 155.33,93.41 155.23,93.31 153.36,93.31 153.12,93.54 153.12,94.27 152.84,94.55 151.05,94.55 150.62,94.97 150.08,94.97 149.45,94.34 149.02,94.34 148.68,94.01 147.44,94.01 147.16,93.72 147.16,93.22 147.3,93.08 147.3,92.58 146.73,92.01 146.73,90.55 145.49,89.3 139.88,89.3 139.6,89.02 139.6,88.16 139.29,87.85 138.8,87.85 138.65,87.71 138.65,85.98 138.55,85.88 138.36,85.88 138.26,85.98 138.26,87.78 138.16,87.88 137.94,87.88 137.84,87.78 137.84,83.23 137.28,82.67 137.28,80.96 136.99,80.68 136.99,76.69 136.71,76.41 136.33,76.41 135.85,75.92 135.47,75.92 134.96,75.42 134.6,75.42 134.09,74.91 133.76,74.91 133.23,74.37 132.8,74.37 132.29,73.87 131.91,73.87 131.48,73.43 131.15,73.43 130.77,73.82 130.18,73.82 129.8,73.43 129.34,73.43 128.96,73.82 128.45,73.82 128.1,73.46 127.59,73.46 127.11,73.94 126.83,73.94 126.3,74.48 126.08,74.48 125.85,74.7 125.69,75.1 125.69,75.49 125.62,75.64 125.39,75.87 125.15,75.87 124.72,76.3 124.14,76.3 123.88,76.05 123.27,76.05 123,76.33 122.43,76.33 122.16,76.05 121.67,76.05 121.39,76.33 121.39,76.98 v1(121.84,77.43)
DDR4_DIMM_CH0_CS_N2: length 81.5
  L12_SIG4 w0.089: v1(123.57,74.43) 124.04,74.43 124.74,73.73 124.74,73.31 125.11,72.94 125.32,72.94 125.63,72.64 125.77,72.28 125.77,71.9 125.87,71.68 126.14,71.4 126.4,71.4 126.88,70.92 127.18,70.92 127.67,70.44 128.1,70.44 128.58,70.92 128.91,70.92 129.37,70.46 129.85,70.46 130.31,70.92 130.64,70.92 131.1,70.46 131.6,70.46 132.09,70.94 132.42,70.94 132.95,71.48 133.36,71.48 133.81,71.94 134.17,71.94 134.68,72.44 135.03,72.44 135.52,72.93 135.9,72.93 136.41,73.43 136.79,73.43 137.29,73.94 137.68,73.94 138.16,74.42 138.49,74.42 138.97,74.91 139.25,74.91 139.58,75.24 139.58,80.19 139.95,80.55 139.95,81.24 139.58,81.61 139.58,82.98 142.46,85.86 142.46,87.49 142.64,87.67 142.91,87.67 143.14,87.44 143.14,85.13 143.38,84.89 143.74,84.89 144.2,85.34 144.2,87.67 144.4,87.88 145.52,87.88 148.32,90.68 148.32,91.11 149.06,91.85 151.35,91.85 151.98,91.22 156.82,91.22 157.01,91.4 157.01,93.84 157.11,93.94 157.25,93.94 157.35,93.84 157.35,91.87 157.46,91.77 157.6,91.77 157.7,91.87 157.7,93.83 157.8,93.93 157.94,93.93 158.04,93.83 158.04,91.92 158.14,91.82 158.28,91.82 158.38,91.92 158.38,93.82 158.48,93.92 158.63,93.92 158.73,93.82 158.73,90.97 158.56,90.8 150.13,90.8 v1(149.49,91.44)
DDR4_DIMM_CH0_CS_N3: length 82.6
  L12_SIG4 w0.089: v1(149.49,97.44) 149.9,97.04 150.65,97.04 150.86,97.24 151.31,97.24 152.35,96.2 159.58,96.2 160.09,95.69 160.09,89.31 159.55,88.77 152.77,88.77 152.58,88.97 152.58,89.18 152.77,89.37 156.15,89.37 156.35,89.57 156.35,89.72 156.15,89.93 149.37,89.93 146.15,86.71 146.15,84.27 144.62,82.73 141.8,82.73 141.33,82.27 141.33,74.22 141,73.89 140.7,73.89 140.24,73.43 139.88,73.43 139.4,72.95 139,72.95 138.49,72.44 138.16,72.44 137.6,71.88 137.24,71.88 136.79,71.43 136.43,71.43 135.95,70.94 135.54,70.94 135.01,70.41 134.7,70.41 134.22,69.93 133.79,69.93 133.33,69.47 133,69.47 132.47,68.94 132.06,68.94 131.6,68.48 131.12,68.48 130.74,68.86 130.26,68.86 129.88,68.48 129.39,68.48 128.99,68.89 128.56,68.89 128.12,68.46 127.69,68.46 127.24,68.91 126.88,68.91 126.4,69.4 126.04,69.4 125.53,69.9 125.18,69.9 124.86,70.23 124.86,71.14 124.58,71.42 124.22,71.42 123.73,71.91 123.35,71.91 123.09,72.17 123.09,72.63 123.57,73.12 v1(123.57,73.43)
DDR4_DIMM_CH0_DBI_N0: length 75.7
  L16_SIG6 w0.079: 78.84,92.17 77.54,92.17 77.22,92.49 77.22,93 77.54,93.32 80.36,93.32 80.56,93.53 80.56,94.03 80.36,94.24 78.47,94.24 78.13,94.57 78.13,95.02 78.47,95.35 81.62,95.35 82.05,94.92 82.05,92.73 81.88,92.56 81.88,91.92 86.03,87.77 86.72,86.1 88.05,84.78 90.76,84.78 92.49,83.05 99.33,83.05 100.26,82.12 102.9,82.12 103.72,81.3 arc(104,81.11) 104.33,81.04 104.56,81.04 arc(104.78,80.99) 104.96,80.85 105.12,80.65 arc(105.21,80.57) 105.34,80.54 105.36,80.54 arc(105.64,80.48) 105.86,80.3 105.97,80.16 arc(106.08,80.07) 106.21,80.04 106.27,80.04 arc(106.42,80.08) 106.55,80.18 106.67,80.34 arc(106.86,80.49) 107.09,80.54 107.14,80.54 arc(107.39,80.49) 107.59,80.33 107.71,80.17 arc(107.82,80.07) 107.96,80.04 107.98,80.04 arc(108.15,80.08) 108.28,80.19 108.38,80.32 arc(108.59,80.48) 108.84,80.54 108.85,80.54 arc(109.11,80.48) 109.32,80.31 109.44,80.16 arc(109.55,80.07) 109.69,80.04 109.76,80.04 arc(109.88,80.07) 109.98,80.15 110.13,80.34 arc(110.31,80.49) 110.54,80.54 110.63,80.54 arc(110.86,80.49) 111.04,80.35 111.19,80.15 arc(111.29,80.07) 111.42,80.04 111.49,80.04 arc(111.61,80.07) 111.71,80.15 111.83,80.3 arc(112.05,80.48) 112.32,80.54 112.35,80.54 arc(112.57,80.49) 112.75,80.35 112.9,80.15 arc(113,80.07) 113.13,80.04 113.22,80.04 arc(113.35,80.07) 113.45,80.15 113.6,80.34 arc(113.78,80.49) 114,80.54 114.1,80.54 arc(114.32,80.49) 114.5,80.35 114.65,80.15 arc(114.75,80.07) 114.88,80.04 114.97,80.04 arc(115.08,80.07) 115.16,80.13 115.31,80.33 arc(115.51,80.49) 115.76,80.54 115.79,80.54 arc(115.94,80.58) 116.06,80.67 116.18,80.82 arc(116.38,80.98) 116.63,81.04 116.69,81.04 arc(116.82,81.07) 116.92,81.15 117.07,81.34 arc(117.25,81.49) 117.47,81.54 117.56,81.54 arc(117.79,81.49) 117.96,81.35 118.12,81.15 arc(118.22,81.07) 118.34,81.04 118.41,81.04 arc(118.63,80.99) 118.81,80.85 118.96,80.65 arc(119.07,80.57) 119.19,80.54 119.26,80.54 arc(119.46,80.5) 119.63,80.39 119.72,80.3 arc(119.82,80.15) 119.85,79.98 119.85,79.78 119.74,79.51 119.74,79.31 119.82,79.11 119.89,79.04 120.01,79.04 120.11,79.14 v1(120.11,79.43) ; v1(71.29,91.44) 71.59,91.74 71.59,92.02 71.83,92.25 72.24,92.25 74.08,90.41 78.83,90.41
  L16_SIG6 w0.081: 78.84,92.17 79.46,91.55 79.46,91.04 78.83,90.41
DDR4_DIMM_CH0_DBI_N1: length 55.7
  L12_SIG4 w0.085: v1(80.64,91.44) 80.96,91.76 80.96,92.03 81.21,92.28 81.59,92.28 82.81,91.06 83.58,91.06 84.59,92.07 84.59,93.94 84.23,94.3 84.23,95.09 84.69,95.55 85.46,95.55 86.3,94.71 89.17,94.71 90.22,93.67 90.22,92.22 89.58,91.58 89.58,91.24 89.89,90.93 90.96,90.93 93.83,88.05 94.38,88.05 95.08,87.36 95.08,86.23 95.64,85.67 104.57,85.67 105.39,86.49 106.62,86.49 107.18,87.04 115.48,87.04 116.48,86.05 117.13,86.05 118.13,85.05 118.63,85.05 119.02,84.66 119.02,83.98 119.28,83.72 119.28,82.77 119.74,82.31 119.82,82.12 119.9,82.04 120.01,82.04 120.11,82.14 v1(120.11,82.43)
DDR4_DIMM_CH0_DBI_N2: length 58.7
  L16_SIG6 w0.079: v1(89.99,91.44) 90.31,91.75 90.31,91.94 90.56,92.19 90.98,92.19 92.21,90.95 94.57,90.95 95.49,91.87 95.49,92.27 94.76,93 94.76,93.51 95.74,94.49 96.13,94.49 96.63,94.98 101,94.98 101.26,94.72 101.26,94.2 101,93.94 97.35,93.94 97.23,93.81 97.23,93.48 97.54,93.17 98.18,93.17 98.37,93.35 100.33,93.35 100.63,93.06 100.63,91.92 100.82,91.72 100.82,90.79 102.56,89.05 104.03,89.05 106.59,86.49 107.28,86.49 107.74,86.03 110.01,86.03 110.37,86.39 112.07,86.39 112.43,86.03 115.22,86.03 116.24,87.05 120.26,87.05 120.67,86.64 120.67,86.15 121.69,85.13 122.31,85.13 123.41,84.04 123.99,84.04 124.99,83.04 125.58,83.04 125.91,82.71 125.91,82.31 125.79,82.02 125.79,81.84 125.88,81.63 125.93,81.58 126.01,81.54 126.07,81.54 126.17,81.64 v1(126.17,81.93)
DDR4_DIMM_CH0_DBI_N3: length 52
  L12_SIG4 w0.085: v1(126.17,79.93) 126.17,79.64 126.07,79.54 125.97,79.54 125.88,79.64 125.79,79.84 125.79,80.01 125.91,80.3 125.91,80.56 125.8,80.84 125.8,81.02 125.91,81.29 125.91,81.58 125.79,81.87 125.79,82 125.91,82.29 125.91,88.75 124.43,90.23 123.45,90.23 122.24,91.44 122.24,91.62 122.56,91.94 122.75,91.94 123.16,91.52 123.49,91.52 123.8,91.83 123.8,92.53 123.2,93.13 118.91,93.13 118.72,92.94 117.88,92.94 117.65,93.16 116.98,93.16 116.81,93.33 115.44,93.33 114.86,93.9 113.96,93.9 113.14,93.09 112.72,93.09 111.82,93.99 109.9,93.99 109.67,94.21 109.25,94.21 108.7,94.76 105.19,94.76 104.94,94.51 103.12,94.51 102.79,94.84 102.79,95.07 102.12,95.74 101.55,95.74 100,94.19 100,93.72 100.3,93.42 100.74,93.42 101.64,94.32 101.82,94.32 102.05,94.09 102.05,93.87 101,92.83 99.99,92.83 99.66,92.5 99.66,91.75 v1(99.35,91.44)
DDR4_DIMM_CH0_DBI_N4: length 44.7
  L03_SIG1 w0.079: v4(154.59,91.44) 154.91,91.76 154.91,91.88 154.77,92.02 154.51,92.02 153.98,91.48 153.98,91.34 154.12,91.2 154.12,91.06 154.02,90.97 153.88,90.97 153.74,91.11 153.6,91.11 153.24,90.75 152.56,90.75 151.27,92.03 150.82,92.03 150.68,91.89 150.02,91.89 149.71,92.2 149.06,92.2 148.68,91.83 146.94,91.83 146.42,92.35 146.1,92.35 145.65,91.89 143.23,91.89 142.69,91.35 142.69,88.86 142.36,88.54 141.96,88.54 141.64,88.86 141.64,89.85 141.5,90 141.2,90 141.06,89.85 141.06,89.08 140.79,88.82 140.27,88.82 140.01,89.08 140.01,89.89 139.88,90.02 139.55,90.02 139.43,89.89 139.43,89.23 138.01,87.82 137.13,87.82 136.8,88.14 136.32,88.14 135.99,87.82 135.39,87.82 134.69,87.11 134.69,86.86 135.3,86.25 135.3,85.8 135.01,85.51 134.56,85.51 133.55,86.53 133.36,86.53 132.99,86.15 132.99,85.97 133.17,85.79 133.17,85.33 132.67,84.82 132.1,84.82 131.83,84.56 131.83,83.21 131.93,83.11 132.02,83.11 132.11,83.01 132.11,82.88 132.02,82.78 131.93,82.78 131.83,82.68 131.83,82.39 131.98,82.05 131.98,81.81 131.85,81.51 131.85,81.35 131.97,81.06 131.97,80.8 131.85,80.5 131.85,80.33 131.98,80.03 131.98,79.8 131.86,79.51 131.86,79.34 131.95,79.13 132.03,79.04 132.13,79.04 132.23,79.14 v4(132.23,79.43)
DDR4_DIMM_CH0_DBI_N5: length 51.6
  L16_SIG6 w0.079: v1(138.29,79.93) 138.29,79.64 138.4,79.54 138.5,79.54 138.61,79.65 138.66,79.79 138.78,79.91 arc(138.93,80.01) 139.11,80.04 139.2,80.04 arc(139.33,80.07) 139.43,80.15 139.58,80.35 arc(139.76,80.49) 139.98,80.54 140.07,80.54 arc(140.2,80.57) 140.3,80.65 140.45,80.85 arc(140.63,80.99) 140.86,81.04 140.92,81.04 arc(141.05,81.07) 141.15,81.15 141.3,81.35 arc(141.48,81.49) 141.71,81.54 141.8,81.54 arc(141.93,81.57) 142.03,81.65 142.17,81.83 143.25,82.91 145.08,82.91 145.29,83.12 145.29,83.6 145.08,83.82 143.31,83.82 143.02,84.1 143.02,84.74 143.33,85.04 145.07,85.04 145.26,85.24 145.26,85.63 145.07,85.82 142.45,85.82 142.12,86.15 142.12,86.72 142.45,87.05 143.81,87.05 144.02,87.26 144.02,88.03 145.95,89.96 146.32,89.96 146.69,89.59 146.69,89.22 145.25,87.78 145.25,87.6 145.48,87.37 145.66,87.37 148.52,90.22 150.92,90.22 151.04,90.35 151.04,90.61 151.3,90.87 151.83,90.87 152.09,90.61 152.09,90.35 152.21,90.22 152.78,90.22 152.91,90.35 152.91,90.54 153.17,90.81 153.69,90.81 153.95,90.54 153.95,90.35 ; 163.76,90.37 163.76,90.32 163.86,90.22 164.11,90.22 164.3,90.41 164.3,91.09 v1(163.94,91.44) ; 163.43,90.32 163.43,90.37
  L16_SIG6 w0.081: 163.43,90.37 163.53,90.47 163.67,90.47 163.76,90.37 ; 163.43,90.32 163.33,90.22 154.08,90.22 153.95,90.35
DDR4_DIMM_CH0_DBI_N6: length 59.9
  L03_SIG1 w0.079: 160.66,83.39 158.63,83.39 156.17,80.93 155.53,80.93 155.07,80.47 155.07,79.35 154.76,79.03 146.44,79.03 146.01,79.47 146.01,80.04 144.01,82.04 142.59,82.04 arc(142.36,81.99) 142.18,81.84 142.03,81.65 arc(141.93,81.57) 141.81,81.54 141.71,81.54 arc(141.59,81.57) 141.5,81.64 141.34,81.85 arc(141.16,81.99) 140.94,82.04 140.85,82.04 ; 139.59,82.35 139.43,82.15 arc(139.33,82.07) 139.21,82.04 arc(138.91,81.98) 138.68,81.78 138.53,81.59 arc(138.48,81.56) 138.43,81.54 138.39,81.54 138.29,81.64 v4(138.29,81.93) ; 161.58,85.77 161.92,86.1 162.39,86.1 163.12,85.37 166.57,85.37 166.8,85.61 166.8,85.97 166.57,86.2 163.66,86.2 163.24,86.62 163.24,88 163.98,88.73 164.94,88.73 165.27,88.39 165.27,87.51 165.45,87.34 165.85,87.34 166.02,87.51 166.02,88.42 166.33,88.73 167.52,88.73 167.84,88.41 167.84,86.97 168,86.81 168.26,86.81 168.42,86.97 168.42,88.41 168.74,88.73 171.58,88.73
  L03_SIG1 w0.081: v4(173.29,91.44) 173.69,91.05 173.69,90.83 173.48,90.63 173.08,90.63 172.78,90.33 172.78,89.92 171.58,88.73 ; 160.66,83.39 161.58,84.31 161.58,85.77 ; 139.59,82.35 arc(139.77,82.49) 139.99,82.54 arc(140.07,82.54) 140.15,82.52 140.33,82.46 arc(140.4,82.42) 140.46,82.37 140.62,82.16 arc(140.73,82.07) 140.85,82.04
DDR4_DIMM_CH0_DBI_N7: length 65.6
  L07_SIG3 w0.085: v1(182.64,91.44) 182.96,91.12 182.96,90.7 182.69,90.43 182.69,89.05 182.4,88.76 182.21,88.76 182.05,88.59 182.05,88.41 ; 179.37,87.7 179.37,86.38 179.17,86.17 178.82,86.17 178.62,86.38 178.62,87.69 178.32,87.99 177.77,87.99 177.11,87.33 ; 138.58,74.61 138.63,74.73 arc(138.67,74.81) 138.73,74.87 138.75,74.89 arc(138.91,75) 139.11,75.04 139.2,75.04 arc(139.33,75.07) 139.43,75.15 139.58,75.35 arc(139.76,75.49) 139.98,75.54 140.06,75.54 arc(140.19,75.57) 140.29,75.65 140.44,75.85 arc(140.62,75.99) 140.84,76.04 140.94,76.04 arc(141.17,75.99) 141.35,75.84 141.5,75.65 arc(141.6,75.57) 141.72,75.54 141.8,75.54 arc(141.92,75.57) 142.02,75.65 142.17,75.85 arc(142.35,75.99) 142.58,76.04 155.29,76.04 156.29,77.04 158.03,77.04 158.35,77.36 161.28,77.36 163.5,79.57 164.61,79.57 165.21,80.18 165.21,80.69 164.71,81.19 164.1,81.19 163.04,80.13 162.44,80.13 161.92,80.65 161.92,81.39 164.18,83.64 167.27,83.64 169.56,85.93
  L07_SIG3 w0.089: 138.58,74.61 138.53,74.55 138.41,74.55 138.29,74.67 v1(138.29,74.93) ; 169.56,85.93 176.56,85.93 177.11,86.47 177.11,87.33 ; 182.05,88.41 181.66,88.02 179.69,88.02 179.37,87.7
DDR4_DIMM_CH0_DBI_N8: length 43.7
  L16_SIG6 w0.079: v1(108.69,91.45) 108.92,91.68 108.92,93.94 109.22,94.23 109.78,94.23 110.34,93.67 110.34,93.12 110.44,93.02 110.85,93.02 110.95,93.12 110.95,93.71 111.18,93.95 112.38,93.95 112.57,94.14 123.7,94.14 124.71,93.13 126.69,93.13 126.98,92.84 126.98,91.99 127.2,91.77 127.2,91.22 126.98,91 126.98,90.63 127.23,90.38 127.98,90.38 128.49,90.89 128.89,90.89 129.26,90.51 129.26,90.13 128.71,89.59 128.71,89.44 129,89.16 129.14,89.16 130.27,90.29 131.17,90.29 131.85,89.61 131.85,89.06 131.26,88.47 131.26,88.08 131.36,87.97 132.45,87.97 132.73,87.69 132.73,87.22 132.45,86.93 131.98,86.93 131.85,86.79 131.85,82.34 131.93,82.13 132,82.06 132.05,82.04 132.13,82.04 132.23,82.14 v1(132.23,82.43)
DDR4_DIMM_CH0_DQ0: length 76.1
  L16_SIG6 w0.081: v1(117.51,79.93) 117.23,79.64 117.23,79.4 116.87,79.05 116.37,79.05 116.09,79.33 115.64,79.33 115.14,78.82 114.52,78.82 114.18,78.49 113.94,78.49 113.43,77.98 112.96,77.98 112.56,78.38 112.02,78.38 111.6,77.96 111.14,77.96 110.66,78.44 110.35,78.44 109.83,77.92 109.49,77.92 108.99,78.43 108.61,78.43 108.17,77.99 107.73,77.99 107.26,78.45 106.96,78.45 106.57,78.05 106.03,78.05 105.65,78.43 105.26,78.43 104.76,78.93 104.36,78.93 103.86,79.43 103.46,79.43 102.96,79.93 102.66,79.93 101.76,80.83 100.06,80.83 99.46,81.43 98.36,81.43 97.86,80.93 97.46,80.93 96.96,81.43 96.46,81.43 96.06,81.03 95.66,81.03 95.26,81.43 94.86,81.43 94.36,80.93 93.96,80.93 93.56,81.33 93.05,81.33 92.65,80.93 92.26,80.93 91.86,81.33 91.47,81.33 90.85,81.94 90.39,81.94 90.19,82.14 90.19,83.37 90.09,83.47 89.96,83.47 89.86,83.37 89.86,82.41 89.76,82.31 89.62,82.31 89.52,82.41 89.52,83.34 89.42,83.44 89.28,83.44 89.19,83.34 89.19,82.41 89.09,82.31 88.95,82.31 88.85,82.41 88.85,83.34 88.75,83.44 88.61,83.44 88.52,83.34 88.52,82.41 88.42,82.31 88.28,82.31 88.18,82.41 88.18,83.35 88.08,83.45 87.94,83.45 87.85,83.35 87.85,82.41 87.75,82.31 87.61,82.31 87.51,82.41 87.51,83.35 87.41,83.45 87.27,83.45 87.17,83.35 87.17,82.41 87.08,82.31 86.94,82.31 86.84,82.41 86.84,83.36 86.74,83.45 86.6,83.45 86.5,83.36 86.5,82.41 86.41,82.31 86.27,82.31 86.17,82.41 86.17,82.75 86.08,82.84 85.9,82.84 84.04,80.98 80.04,80.98 77.46,83.56 77.46,88.65 77.05,89.06 76.17,89.06 75.12,88.01 72.86,88.01 72.53,88.34 72.53,88.93 70.56,90.9 70.14,90.9 v1(69.59,91.44)
DDR4_DIMM_CH0_DQ1: length 76.6
  L16_SIG6 w0.081: v1(117.51,78.93) 117.13,78.93 117.02,78.82 116.5,78.82 116.12,78.44 115.59,78.44 115.06,77.91 114.76,77.91 114.37,77.51 113.98,77.51 113.49,77.03 112.93,77.03 112.53,77.43 112.1,77.43 111.66,76.98 111.24,76.98 110.81,77.41 110.27,77.41 109.77,76.91 109.58,76.91 109.04,77.46 108.79,77.46 108.28,76.95 107.87,76.95 107.32,77.49 107.05,77.49 106.6,77.04 106.05,77.04 105.65,77.43 105.26,77.43 104.76,77.93 104.36,77.93 103.86,78.43 103.46,78.43 103.06,78.83 102.66,78.83 102.06,79.43 101.76,79.43 101.26,79.93 100.86,79.93 100.46,80.33 100.06,80.33 99.46,80.93 99.05,80.93 98.65,80.53 98.46,80.53 97.96,80.03 92.26,80.03 91.86,80.43 91.36,80.43 90.85,80.93 90.46,80.93 90.01,81.38 84.96,81.38 84.22,80.64 79.91,80.64 76.89,83.65 76.89,86.59 76.79,86.68 76.66,86.68 76.56,86.59 76.56,85.32 76.46,85.22 76.32,85.22 76.22,85.32 76.22,86.59 76.12,86.69 75.99,86.69 75.89,86.59 75.89,85.48 75.79,85.38 75.65,85.38 75.47,85.56 75.47,86.84 75.2,87.11 73.19,87.11 72.27,88.03 71.74,88.03 69.17,90.6 69.17,91.58 73.41,95.82 73.41,97.62 73.21,97.82 71.93,97.82 71.55,97.44 v1(70.44,97.44)
DDR4_DIMM_CH0_DQ2: length 76.8
  L16_SIG6 w0.081: v1(75.54,91.44) 75.54,92.72 75.44,92.81 74.44,92.81 74.34,92.91 74.34,93.23 74.44,93.33 75.44,93.33 75.54,93.42 75.54,94.11 75.44,94.21 74.37,94.21 74.28,94.31 74.28,94.52 74.37,94.62 75.44,94.62 75.54,94.72 75.54,94.94 75.44,95.04 74.41,95.04 74.31,95.13 74.31,95.33 74.41,95.43 75.44,95.43 75.54,95.53 75.54,95.79 75.43,95.9 74.3,95.9 73.01,94.61 73.01,93.58 72.62,93.19 71.83,93.19 70.87,92.23 70.87,91.27 73.21,88.93 74.31,88.93 74.9,89.52 83.07,89.52 85.37,87.22 86.12,85.4 87.61,83.92 90.27,83.92 92.26,81.93 92.56,81.93 92.96,82.33 93.46,82.33 93.86,81.93 94.36,81.93 94.76,82.33 95.26,82.33 95.66,81.93 96.06,81.93 96.46,82.33 96.96,82.33 97.36,81.93 97.86,81.93 98.26,82.33 99.06,82.33 100.26,81.12 102.69,81.12 103.42,80.39 103.89,80.39 104.36,79.93 104.65,79.93 105.15,79.43 105.56,79.43 106.06,78.93 106.46,78.93 106.92,79.39 107.37,79.39 107.83,78.92 108.24,78.92 108.65,79.34 109.21,79.34 109.68,78.86 109.92,78.86 110.42,79.36 110.86,79.36 111.29,78.93 111.61,78.93 112.06,79.39 112.55,79.39 113.03,78.91 113.3,78.91 113.84,79.46 114.25,79.46 114.67,79.04 115.06,79.04 115.56,79.54 116.07,79.54 116.46,79.93 116.79,79.93 117.25,80.39 117.79,80.39 118.38,79.8 v1(118.38,79.43)
DDR4_DIMM_CH0_DQ3: length 76.8
  L16_SIG6 w0.081: v1(118.38,78.43) 118.78,78.43 118.89,78.54 119.46,78.54 119.95,78.06 120.27,78.06 120.75,78.54 121.17,78.54 121.47,78.84 121.47,79.58 121.65,79.76 121.65,80.09 121.42,80.32 121.42,81.13 121.11,81.44 120.71,81.44 120.2,81.94 119.77,81.94 118.73,82.98 116.59,82.98 115.96,82.35 115.55,82.35 115.23,82.03 114.63,82.03 114.33,82.33 113.69,82.33 113.4,82.04 112.96,82.04 112.69,82.32 112.06,82.32 111.78,82.04 111.13,82.04 110.85,82.31 110.35,82.31 110.08,82.05 109.39,82.05 109.11,82.33 108.65,82.33 108.37,82.05 107.73,82.05 107.36,82.43 106.86,82.43 106.43,82.85 104.03,82.85 103.05,83.83 101.07,83.83 99.57,85.33 92.63,85.33 91.04,86.92 90.47,86.92 90.16,87.22 88.58,87.22 87.9,87.9 87.78,87.9 86.29,89.39 86.29,89.75 85.34,90.7 85.34,94.23 85.2,94.37 84.19,94.37 84.09,94.47 84.09,94.61 84.19,94.71 85.59,94.71 85.69,94.81 85.69,94.94 85.59,95.04 84.17,95.04 84.07,95.14 84.07,95.28 84.17,95.38 85.84,95.38 85.94,95.48 85.94,95.61 85.84,95.71 84.21,95.71 84.11,95.81 84.11,95.95 84.21,96.05 85.81,96.05 85.9,96.15 85.9,96.29 85.81,96.38 84.21,96.38 84.11,96.48 84.11,96.62 84.21,96.72 85.72,96.72 85.81,96.82 85.81,96.96 85.72,97.05 83.8,97.05 83.59,97.26 82.88,97.26 82.68,97.05 81.21,97.05 81.01,97.26 80.22,97.26 80.01,97.05 76.78,97.05 v1(76.39,97.44)
DDR4_DIMM_CH0_DQ4: length 74.4
  L16_SIG6 w0.081: v1(67.89,91.44) 67.7,91.25 67.7,89.66 69.03,88.34 69.03,87.6 69.7,86.93 69.7,84.96 71.3,83.37 74.61,83.37 74.71,83.27 74.71,83.13 74.61,83.03 72.52,83.03 72.43,82.93 72.43,82.79 72.52,82.7 75.16,82.7 75.26,82.6 75.26,82.46 75.16,82.36 74.14,82.36 74.05,82.26 74.05,82.12 74.14,82.03 75.99,82.03 78.78,79.23 87.54,79.23 87.76,79.45 89.96,79.45 90.47,78.94 90.85,78.94 91.25,78.54 91.75,78.54 92.24,78.05 92.67,78.05 93.15,78.53 98.55,78.53 99.05,78.03 99.56,78.03 100.16,77.43 100.46,77.43 100.89,76.99 101.59,76.62 102.13,76.43 104,76.06 104.15,75.9 104.71,75.9 105.17,75.44 105.54,75.44 106,74.98 106.54,74.98 106.94,75.38 107.4,75.38 107.8,74.98 108.33,74.98 108.73,75.39 109.07,75.39 109.46,75 110.06,75 110.42,75.36 110.98,75.36 111.3,75.05 111.7,75.05 112.1,75.45 112.46,75.45 112.85,75.05 113.37,75.05 113.78,75.46 114.15,75.46 114.61,75.92 115,75.92 115.53,76.45 116.1,76.45 116.64,76.99 116.94,76.99 117.43,77.48 117.59,77.48 118.17,78.06 118.81,78.06 119.06,78.31 119.4,78.31 119.91,77.8 120.32,77.8 120.83,78.31 121.29,78.31 121.41,78.43 v1(121.84,78.43)
DDR4_DIMM_CH0_DQ5: length 74.6
  L16_SIG6 w0.081: v1(121.84,79.43) 122.23,78.48 122.23,78.24 122.13,78.14 121.6,77.79 120.65,77.28 120.41,77.12 120.14,77.04 120.06,77.04 118.87,77.53 118.69,77.71 118.47,77.8 118.22,77.8 118.05,77.63 117.95,77.39 117.95,77 117.82,76.69 117.7,76.57 117.3,76.4 117.05,76.15 116.38,75.88 115.67,75.35 114.33,74.64 114.1,74.54 113.96,74.54 113.33,74.8 113.05,74.8 111.72,74.1 111.46,74.03 109.63,74.03 108.97,74.3 108.69,74.3 108.08,74.05 107.85,74.05 107.24,74.3 107.02,74.3 106.39,74.04 106.17,74.04 105.11,74.48 104.59,75 104.34,75 103.88,75.47 103.01,75.83 99.65,76.85 98.78,77.43 98.36,77.43 97.97,77.81 97.24,77.81 96.96,77.53 94.75,77.53 94.46,77.82 93.85,77.82 93.59,77.56 92.95,77.56 92.71,77.8 92.12,77.8 91.79,77.47 91.14,77.47 90.9,77.72 90.28,78.13 88.43,78.9 78.39,78.9 75.6,81.69 72.5,81.69 69.33,84.86 66.64,91.34 67.04,93.33 v1(68.74,97.44)
DDR4_DIMM_CH0_DQ6: length 74.5
  L16_SIG6 w0.081: v1(120.98,79.93) 120.5,80.4 120.5,80.57 120.28,80.8 119.9,80.8 119.39,81.31 119.03,81.31 118.52,81.82 118.16,81.82 117.65,82.32 117.37,82.32 116.86,81.82 116.51,81.82 116,81.31 115.63,81.31 115.12,80.8 114.74,80.8 114.24,81.3 113.86,81.3 113.48,80.93 112.98,80.93 112.6,81.32 112.06,81.32 111.65,80.91 111.25,80.91 110.83,81.32 110.34,81.32 109.88,80.86 109.53,80.86 109.08,81.31 108.61,81.31 108.17,80.86 107.82,80.86 107.38,81.3 106.96,81.3 106.58,80.93 106.15,80.93 105.65,81.43 105.26,81.43 104.88,81.81 104.02,81.81 103.16,82.67 100.65,82.67 99.41,83.9 96.69,83.9 96.59,84 96.59,84.14 96.69,84.23 97.11,84.23 97.21,84.33 97.21,84.47 97.11,84.57 96.35,84.57 96.26,84.47 96.26,84 96.16,83.9 95.49,83.9 95.39,84 95.39,84.47 95.3,84.57 94.37,84.57 94.27,84.47 94.27,84.33 94.37,84.23 94.96,84.23 95.06,84.14 95.06,84 94.96,83.9 92.72,83.9 92.62,84 92.62,84.14 92.72,84.23 93.39,84.23 93.48,84.33 93.48,84.47 93.39,84.57 92.15,84.57 91.29,85.43 88.24,85.43 87.25,86.42 86.56,88.09 85.62,89.03 85.62,89.47 84.01,91.08 84.01,91.53 83.61,91.94 83.61,92.9 83.04,93.46 83.04,95.04 82.11,95.97 77.56,95.97 77.4,95.81 77.4,94.31 77.3,94.21 76.99,94.21 76.89,94.31 76.89,95.81 76.79,95.91 76.25,95.91 76.14,95.81 76.14,94.39 76.27,94.26 76.44,94.26 76.73,93.97 76.73,93.5 75.95,92.72 75.95,91.22 75.75,91.02 74.52,91.02 74.11,91.44 v1(73.84,91.44)
DDR4_DIMM_CH0_DQ7: length 75
  L16_SIG6 w0.081: v1(74.69,97.44) 75.25,97.44 75.4,97.29 75.4,97.13 75.25,96.98 74.5,96.98 74.37,96.85 74.37,96.44 74.5,96.32 75.81,96.32 75.92,96.42 75.92,96.99 76.02,97.09 76.16,97.09 76.25,96.99 76.25,96.42 76.35,96.32 76.49,96.32 76.59,96.42 76.59,96.58 76.69,96.68 76.83,96.68 76.92,96.58 76.92,96.42 77.02,96.32 77.16,96.32 77.26,96.42 77.26,96.58 77.36,96.68 77.5,96.68 77.6,96.58 77.6,96.42 77.69,96.32 77.83,96.32 77.93,96.42 77.93,96.58 78.03,96.68 78.17,96.68 78.27,96.58 78.27,96.42 78.36,96.32 78.5,96.32 78.6,96.42 78.6,96.58 78.7,96.68 78.84,96.68 78.94,96.58 78.94,96.42 79.03,96.32 79.17,96.32 79.27,96.42 79.27,96.58 79.37,96.68 79.51,96.68 79.61,96.58 79.61,96.42 79.71,96.32 79.84,96.32 79.94,96.42 79.94,96.58 80.04,96.68 80.18,96.68 80.28,96.58 80.28,96.42 80.38,96.32 82.36,96.32 83.51,95.16 83.51,93.61 83.78,93.34 84.25,93.34 84.39,93.48 84.39,93.9 84.49,94 84.9,94 85.01,93.9 85.01,92.68 84.91,92.58 84.77,92.58 84.67,92.68 84.67,92.92 84.57,93.02 84.43,93.02 84.34,92.92 84.34,92.42 84.47,92.28 84.47,91.09 85.95,89.61 85.95,89.22 87.28,87.89 87.28,87.27 87.54,87.01 87.96,87.01 88.11,86.85 89.96,86.85 90.05,86.76 90.05,86.62 89.96,86.52 88.31,86.52 88.21,86.42 88.21,86.28 88.31,86.18 90.38,86.18 90.65,85.91 91.48,85.91 92.41,84.98 97.95,84.98 98.05,84.88 98.05,84.69 98.15,84.59 98.29,84.59 98.38,84.69 98.38,84.88 98.48,84.98 98.62,84.98 98.72,84.88 98.72,84.69 98.82,84.59 98.96,84.59 99.05,84.69 99.05,84.88 99.15,84.98 99.33,84.98 100.17,84.14 100.17,83.71 100.88,83 103.25,83 104.24,82.02 104.69,82.02 105,82.33 105.56,82.33 105.96,81.93 106.46,81.93 106.84,81.54 107.51,81.54 107.77,81.8 108.29,81.8 108.55,81.54 109.21,81.54 109.48,81.81 109.98,81.81 110.25,81.54 110.91,81.54 111.19,81.82 111.81,81.82 112.1,81.53 112.71,81.53 112.99,81.8 113.5,81.8 113.76,81.55 114.42,81.55 114.68,81.81 115.28,81.81 115.55,81.54 115.92,81.54 116.43,82.04 116.79,82.04 117.3,82.55 117.72,82.55 118.23,82.04 118.6,82.04 119.11,81.54 119.47,81.54 119.95,81.05 120.32,81.05 120.88,80.5 120.94,80.5 121.37,80.06 121.37,79.78 120.98,79.39 v1(120.98,78.93)
