# Allegro board TS28247BC0_FM61_agilex_PCIe_DEVKIT_ADI_REVB1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND_QSFPDD0_CAGE: length 31.1
  BOTTOM w1.016: B1.1 58.99,77.59 60.1,76.48 B1.11 B1.12
  vias: v2(19.31,59.51) v2(19.31,58.5) v2(20.2,59.51) v2(20.2,58.5) v2(21.03,59.51) v2(21.03,58.5)
GND_QSFPDD1_CAGE: length 28.7
  BOTTOM w1.016: B2.6 57.91,33.8 60.1,35.99 B2.12 B2.11
  vias: v2(23.88,52.91) v2(23.88,51.89) v2(24.77,52.91) v2(24.77,51.89) v2(25.6,52.91) v2(25.6,51.89)
GNDSENSE: length 53.6
  L03_SIG1 w0.203: v1(111.45,62.43) 111.45,62.7 112.17,63.43 112.68,63.43 113.27,64.01 117.07,64.01 117.85,64.8 120.1,64.8 120.71,65.41 121.24,65.41 121.67,64.98 122.01,64.98 122.46,65.42 122.89,65.42 123.4,65.93 123.81,65.93 124.31,66.44 124.64,66.44 125.18,66.97 125.53,66.97 125.99,67.43 126.4,67.43 126.93,67.96 127.26,67.96 127.72,68.42 128.1,68.42 128.66,68.98 129.01,68.98 129.52,69.49 129.88,69.49 130.33,69.94 130.69,69.94 131.17,70.43 131.55,70.43 132.06,70.94 132.44,70.94 132.95,71.44 133.31,71.44 133.79,71.93 134.11,71.93 134.55,72.37 134.96,72.37 135.47,72.88 135.9,72.88 136.43,73.41 136.74,73.41 137.19,73.87 137.65,73.87 138.08,73.43 138.46,73.43 138.95,73.92 139.39,73.92 139.88,73.43 140.16,73.43 140.67,73.94 141.03,73.94 141.49,73.48 141.99,73.48 142.4,73.89 143.16,73.89 v1(143.63,73.43)
  BOTTOM w0.203: v1(143.63,73.43) 143.32,73.43 142.83,73.92 142.83,74.88 143.06,75.12 143.06,75.7 143.42,76.05 143.42,81.79 142.42,82.78 141.69,82.78 139.82,84.65 139.82,85.15 R239.1
PVCC: length 96.7
  TOP w0.254: U76.29 U76.28 189.01,82.89 189.16,82.73 189.16,82.6 189.57,82.2 v1(189.57,81.94) ; U77.29 U77.28 188.96,70.24 v1(189.72,69.48) ; v1(189.52,38.17) 189.17,38.52 U79.28 U79.29 ; v1(189.54,54.45) 189.29,54.7 U78.28 U78.29
  BOTTOM w0.203: C1997.2 188.82,54.9 189.28,54.45 v1(189.54,54.45)
  BOTTOM w0.254: v1(189.52,38.17) 189.33,38.17 188.77,38.73 C1999.2 ; v1(189.72,69.48) C1995.2 ; C1839.2 188.72,83.12 189.06,82.78 189.06,82.18 189.34,81.91 R5944.2
  BOTTOM w0.381: C1839.2 188.23,83.12 187.87,82.76 187.87,69.47 ; 181.49,60.61 181.44,60.61 178.87,58.04 178.87,48.21 183.24,43.84 185.5,43.84 186.32,43.03 186.32,40.06 187.65,38.73 C1999.2 ; 181.49,60.61 185.78,60.61 188.53,57.86 C1997.2 ; 181.49,60.61 181.49,64.42 183.04,65.97 186.32,65.97 187.87,67.52 187.87,69.47 ; C1995.2 187.88,69.48 187.87,69.47 ; C2029.2 193.53,47.45 192.56,48.42 192.56,50.78 189.54,53.8 v1(189.54,54.45)
  BOTTOM w0.508: v1(196.98,48.97) 195.76,47.75 C1867.2
  BOTTOM w0.635: v1(200.79,48.97) v1(202.06,48.97) ; v1(196.98,48.97) v1(198.25,48.97)
  vias: v3(197.62,48.16)
SVIN0: length 4
  TOP w0.149: v1(68.36,58.37) 68.79,58.8 68.79,60.07 68.61,60.25 67.47,60.25 67.09,59.87 v1(67.09,59.64)
SVIN1: length 1.9
  TOP w0.149: v1(67.01,73.36) 67.14,73.23 67.34,73.23 v1(68.39,72.19)
VBUS_5V: length 8.8
  TOP w0.279: v1(3.41,27.06) J13.1 5.4,27.06 v1(5.72,27.38)
  L07_SIG3 w0.508: v1(7.63,30.21) 7.63,29.29 v1(5.72,27.38) 5.09,26.75 3.72,26.75 v1(3.41,27.06)
VCC_HSSI_AGND: length 0.7
  BOTTOM w0.191: ST11.1 217.28,70.6 R6005.1
  vias: v1(220.92,72.5) v1(220.92,71.23) v1(222.19,72.5) v1(222.19,71.23)
VCC_HSSI_EN: length 64.5
  L12_SIG4 w0.127: v1(247.21,29.67) 246.4,29.67 245.37,30.7 245.37,40.67 245.6,40.9 245.6,50.47 245.37,50.7 245.37,60.28 v1(244.51,61.14)
  L16_SIG6 w0.127: v1(219.03,69.37) 219.03,68.53 219.49,68.07 228.44,68.07 230.88,65.64 237.27,65.64 238.28,64.62 242.73,64.62 244.51,62.84 v1(244.51,61.14)
  BOTTOM w0.127: R6014.1 v1(219.03,69.37)
VCC_HSSI_PG: length 102.8
  L05_SIG2 w0.127: v1(258.95,27.46) 259.66,26.75 261.5,26.75 270.36,35.61 270.36,46.56 270.14,46.79 270.14,54.69 v1(269.12,55.7)
  L07_SIG3 w0.127: v1(222.19,68.69) 222.73,68.15 223.58,68.15 224.09,67.64 224.09,64.75 225.27,63.57 230.11,63.57 230.54,63.13 230.54,61.55 232.11,59.97 237.37,59.97 238.84,58.5 241.97,58.5 243.62,60.15 245.04,60.15 250.2,54.99 257,54.99 257.99,54 267.42,54 v1(269.12,55.7)
  L12_SIG4 w0.127: v1(222.19,68.69) 222.19,68.68 222.74,68.13 223.65,68.13 224.11,68.58 224.11,74.43 v1(224.73,75.04)
VCC_INT:
  vias: v1(224.73,69.96)
VCC_SENSE: length 82.1
  TOP w0.203: 155.7,85.88 155.33,86.24 155.05,86.24 154.81,86 154.81,82.85 152.25,80.29 148.01,80.29 146.06,82.25 142.3,82.25 139.48,85.07 139.48,86.11 v1(139.16,86.43)
  TOP w0.254: 155.7,85.88 156.98,85.88 v1(157,85.85)
  L12_SIG4 w0.127: v1(157,85.85) 157.33,86.18 158.22,86.18 161.04,83.37 161.04,81.36 165.11,77.29 176.33,77.29 176.97,76.66 181.49,76.66 182.76,75.39 194.37,75.39 195.03,74.73 195.03,68.49 v1(191.23,64.7)
  BOTTOM w0.149: R6115.1 v1(191.23,64.7)
VCCA_PLL: length 9.3
  L05_SIG2 w0.381: v1(208.03,91.77) 208.03,92.03 206.51,93.55 203.33,93.55 v2(202.57,92.79)
  BOTTOM w0.381: v1(208.03,91.77) 208.03,91.14 208.32,90.85 C1665.2 R5785.2
  vias: v1(151.62,79.43) v1(151.62,78.43) v1(151.62,77.43) v1(152.62,79.43) v1(152.62,78.43) v1(152.62,77.43) v1(153.62,79.43) v1(153.62,78.43) v1(153.62,77.43) v1(154.5,77.44) v1(154.62,79.43) v1(154.62,78.43) v1(155.83,80.3) v1(156.83,80.3) v2(202.57,91.65) v2(203.84,92.79) v2(203.84,91.65) v2(204.99,92.79) v2(204.99,91.7) v2(206.26,92.79) v2(206.26,91.65) v2(214,93.3) v2(214,92.28) v2(214.74,93.3) v2(214.74,92.28) v3(204.99,91.72)
VCCA_PLL_EN: length 82
  L12_SIG4 w0.089: v1(242.53,37.52) 242.79,37.78 242.79,40.71 242.58,40.92 242.58,50.27 242.45,50.4 242.42,50.4 241.94,50.88 241.94,53.8 241.45,54.3 241.45,65.81 239.56,67.7 239.56,79.26 239.24,79.58 239.24,82.58 238.64,83.18 232.17,83.18 230.34,85.01 230.34,89.91 226.35,93.9 217.98,93.9 217.46,93.37 v1(217.16,93.37)
  BOTTOM w0.203: v1(242.53,37.52) 242.55,37.52 242.73,37.34 246.65,37.34 v1(247.53,36.46)
VCCA_PLL_FLTR: length 46.7
  L05_SIG2 w0.254: v1(154.62,80.3) 154.58,80.34 145.55,80.34 144.28,79.07 143.22,79.07 143.05,78.9 140.7,78.9 140.27,78.46 139.78,78.46 139.33,78.92 139,78.92 138.54,78.46 138.08,78.46 137.62,78.92 137.24,78.92 136.79,78.46 136.35,78.46 135.92,78.9 135.49,78.9 135.01,78.41 129.45,78.41 128.98,77.94 128.59,77.94 128.14,78.39 127.68,78.39 127.22,77.93 126.83,77.93 126.33,78.42 125.99,78.42 125.52,77.95 125.1,77.95 124.63,78.43 124.25,78.43 123.73,77.91 123.35,77.91 122.87,77.43 122.53,77.43 122.04,76.94 121.66,76.94 121.17,76.45 120.81,76.45 120.29,75.92 119.9,75.92 119.45,75.47 119.08,75.47 118.73,75.11 118.73,74.83 117,73.1 117,72.78 v1(116.65,72.43)
  L05_SIG2 w0.305: v1(113.18,72.43) 113.18,72.04
  BOTTOM w0.254: v1(154.62,80.3) 155.24,80.91 R5784.1
  vias: v1(113.18,51.43) v1(114.91,72.43) v1(114.91,51.43) v1(116.65,51.43) v1(118.38,72.43) v1(118.38,51.43) v1(151.62,75.43) v1(151.62,74.43) v1(151.62,73.43) v1(152.62,75.43) v1(152.62,74.43) v1(152.62,73.43) v1(152.62,72.43) v1(153.62,75.43) v1(153.62,74.43) v1(153.62,73.43) v1(153.62,72.43)
VCCA_PLL_PG: length 118
  L12_SIG4 w0.089: v1(208.72,96.26) 209.18,96.26 217.25,96.26 218.08,95.42 226.89,95.42 232.57,89.74 232.57,87.93 233.05,87.45 233.05,84.23 233.86,83.42 238.77,83.42 239.48,82.72 239.48,79.68 239.8,79.36 239.8,67.8 241.69,65.91 241.69,54.41 242.2,53.9 242.2,51.02 242.86,50.35 242.86,41.09 243.11,40.85 243.11,35.03 242.42,34.34 242.42,32.72 243.93,31.22 v1(244.3,31.22)
  L14_SIG5 w0.081: v1(255.75,28.26) 256.14,28.65 256.14,29.21 255.88,29.48 254.71,29.48 253.41,30.78 253.41,30.87 252.83,31.45 249.89,31.45 249.49,31.04 247.05,31.04 245.6,32.49 245.6,33.86 244.66,34.8 242.7,34.8 241.94,34.04 241.94,33.1 243.82,31.22 v1(244.3,31.22)
  BOTTOM w0.254: R5776.1 208.11,96.26 v1(208.72,96.26)
VCCAPLL_AGND: length 17.4
  BOTTOM w0.279: 207.34,92.92 ST31.2 207.34,93.84 207.25,93.93
  BOTTOM w0.381: 207.34,92.92 207.34,90.91 208.16,90.1 211.6,90.1 211.96,90.46 C1656.1 212.48,90.9 213.16,91.58 R978.2 C1654.2 ; v1(207.92,97.86) 207.52,97.86 206.97,97.3 206.97,94.22 207.25,93.93
VCCCLK_GXPL1:
  vias: v1(127.9,58.93) v1(129.64,58.93) v1(146.63,79.43) v1(146.63,78.43) v1(147.63,79.43) v1(147.63,78.43)
VCCFUSE_GXP:
  vias: v1(127.04,55.43)
VCCFUSEWR_EN: length 71.6
  TOP w0.127: U50.7 212.21,50.66 212.48,50.4 212.48,49.76 212.79,49.45 v1(213.36,49.45)
  L05_SIG2 w0.127: v1(213.36,49.45) 214.62,49.45 217.05,47.02 217.05,46.41 218.52,44.94 218.52,42.8 220.28,41.05 220.28,29.37 220.96,28.68 220.96,22.3 221.83,21.44 221.83,17.55 223.69,15.69 arc(223.73,15.66) 223.78,15.65 243.77,15.65 arc(243.82,15.66) 243.86,15.69 246.73,18.56 arc(246.76,18.6) 246.77,18.65 246.77,20.92 arc(246.78,20.97) 246.81,21.01 247.17,21.38 v1(247.17,21.44)
  BOTTOM w0.127: v1(213.36,49.45) 213.36,50.12 212.9,50.59 R547.1 212.34,50.48 R549.2
VCCFUSEWR_PG: length 81.5
  TOP w0.127: v1(207.58,49.02) 207.58,50.27 207.97,50.66 U50.4
  L07_SIG3 w0.127: v1(249.35,23.46) 249.35,23.44 248.95,23.04 248.95,22.15 248.67,21.87 248.67,21.06 248.5,20.88 246.9,20.88 246.56,21.21 246.56,23.12 244.2,25.48 242.53,25.48 241.47,26.53 241.14,26.53 241.1,26.57 236.75,26.57 236.28,26.1 236.28,20.12 234.7,18.54 223.43,18.54 220.78,21.19 220.78,28.59 213.52,35.85 213.52,40.77 212.48,41.81 209.33,41.81 208.69,42.45 208.69,47.91 v1(207.58,49.02)
  BOTTOM w0.127: v1(207.58,49.02) 207.58,50.41 R788.1
VCCFUSEWR_SDM: length 3.3
  TOP w0.457: C557.2 R546.2 206.96,52.26 206.97,52.25
  TOP w0.508: 208.52,52.26 U50.1
  BOTTOM w0.381: C293.1 v1(131.37,52.93)
  BOTTOM w0.635: v1(206.56,53.42) v3(207.88,53.42)
  vias: v1(131.37,51.93)
VCCH_GXER1_AGND: length 1
  BOTTOM w0.203: R6294.1 60.03,58.03 ST17.1
VCCH_GXER1_EN: length 353.7
  L07_SIG3 w0.127: v1(59.65,54) 61.42,54 62.59,55.17 62.59,59.51 61.6,60.51 53.8,60.51 53.04,61.27 42.59,61.27 40.25,63.61 39.2,63.61 38.71,64.1 36.57,64.1 v1(35.57,65.1)
  L12_SIG4 w0.127: v1(248.55,36.46) 248.55,41.1 249.05,41.6 249.05,45.37 250.98,47.31 250.98,59.28 244.86,65.4 244.86,76.24 240.93,80.18 240.93,83.26 240.37,83.82 240.37,83.82 239.07,85.12 239.07,88.72 236.61,91.19 232.87,91.19 226.22,97.84 221.37,97.84 218.47,100.74 211.05,100.74 209.83,101.96 208.31,101.96 207.27,103 206.36,103 205.52,103.84 202.98,103.84 201.8,105.02 196.41,105.02 194.34,102.95 191.26,102.95 188.14,106.07 150.53,106.07 149.18,107.42 134.45,107.42 132.45,105.43 131.62,105.43 131.4,105.21 131.4,104.86 130.21,103.67 126.58,103.67 125.75,104.5 123.85,104.5 122.88,105.47 111.5,105.47 110.55,104.52 105.09,104.52 104.81,104.8 103.26,104.8 102.7,104.24 96.98,104.24 95.18,106.05 90.26,106.05 88.58,107.73 77.96,107.73 77.05,106.81 73.77,106.81 72.76,105.8 71.45,105.26 67.29,105.26 67.06,105.49 59.06,105.49 56.55,102.97 56.55,102.62 55.76,101.83 55.76,100.28 54.05,98.57 49.09,98.57 41.85,91.33 41.85,90.06 37.09,85.3 37.09,83.39 36.33,82.63 35.19,82.63 34.42,81.87 34.42,81.49 34.04,81.11 34.04,80.09 32.39,78.44 32.39,74.37 28.84,70.82 28.84,67.39 29.98,66.25 34.93,66.25 35.57,65.61 v1(35.57,65.1)
  BOTTOM w0.127: R6084.2 59.65,54.6 v1(59.65,54)
VCCH_GXER1_PG: length 391.9
  L07_SIG3 w0.127: v1(34.81,65.74) 34.81,65.23 35.29,64.75 35.29,63.85 36.29,62.84 38.17,62.84 40.56,60.46 40.56,60.45 40.58,60.42 40.58,58.69 47.4,51.87 v1(48.01,51.87)
  L12_SIG4 w0.127: v1(257.35,24.26) 257.35,24.81 256.71,25.45 255.6,25.45 255.35,25.7 255.35,32.84 255.07,33.12 255.07,37.57 255.4,37.9 255.4,38.66 254.57,39.5 254.57,43.65 256,45.08 256,46.84 257.31,48.15 257.31,54.56 256.8,55.07 256.8,58.5 257.69,59.39 257.69,66.35 256.93,67.11 256.93,76.92 262.39,82.38 262.39,99.24 258.63,103 246.79,103 243.93,105.86 218.75,105.86 216.23,103.33 211.84,103.33 211.06,104.12 210.52,104.12 210.32,103.91 208.26,103.91 207.35,104.83 206.46,104.83 205.8,105.49 202.95,105.49 202.32,106.12 196.78,106.12 195.24,104.58 191.86,104.58 189.57,106.87 151.66,106.87 150.5,108.03 134.12,108.03 132.22,106.14 131.04,106.14 129.76,104.86 129.76,104.77 129.3,104.31 127.92,104.31 127.43,104.8 127.02,104.8 126.89,104.66 126.33,104.66 124.68,106.32 123.69,106.32 123.22,106.78 104.02,106.78 102.75,105.51 97.37,105.51 95.61,107.27 90.44,107.27 89.4,108.31 76.92,108.31 75.82,107.21 73.66,107.21 72.41,105.96 71.39,105.54 67.9,105.54 67.44,106 58.94,106 56.97,104.03 56.4,104.03 55.99,103.62 55.99,103 55.3,102.31 54.95,102.31 54.03,101.4 54.03,100.41 53.14,99.52 49.3,99.52 34.88,85.1 34.88,83.09 31.88,80.09 31.88,76.41 30.61,75.14 30.61,73.23 28.33,70.94 28.33,67.13 28.84,66.63 28.84,66.12 29.22,65.74 v1(34.81,65.74)
  L16_SIG6 w0.127: v1(56.13,55.87) 56.13,55.11 55.61,54.59 55.61,52.91 54.53,51.84 v1(54.53,51.77)
  BOTTOM w0.127: v1(54.53,51.77) 52.77,51.77 52.23,51.23 49,51.23 48.37,51.87 v1(48.01,51.87)
VCCH_GXPL1:
  vias: v1(128.77,66.43) v1(128.77,64.43) v1(128.77,63.43) v1(128.77,61.43) v1(128.77,60.43) v1(129.64,63.93) v1(129.64,62.93) v1(144.63,77.43) v1(144.63,76.43) v1(144.63,70.93) v1(144.63,69.93) v1(145.63,77.43) v1(145.63,76.43) v1(145.63,70.93) v1(145.63,69.93) v1(146.63,77.43) v1(146.63,76.43) v1(147.63,77.43) v1(147.63,76.43)
VCCH_VOSNS+: length 18.4
  L07_SIG3 w0.089: v1(219.65,78.85) 219.65,78.85 219.08,78.29 218.42,78.29 216.54,76.41 216.54,67.24 218.02,65.76 218.77,65.76 v1(219.65,64.88)
  BOTTOM w0.254: C1933.1 219.61,78.82 v1(219.65,78.85) 219.58,78.92 R6101.1
VCCH_VOSNS-: length 18.9
  TOP w0.149: v1(218.38,78.85) 217.54,78.02 216.3,78.02 ST21.2
  L07_SIG3 w0.089: v1(218.38,78.85) 216.23,76.71 216.23,67.03 v1(218.38,64.88)
  BOTTOM w0.254: v1(218.38,78.85) 218.41,78.82 C1933.2
VCCL_HPS_AGND: length 6.4
  L07_SIG3 w0.508: v1(68.39,73.46) 67.7,72.77 64.93,72.77 64.34,72.19 v1(63.31,72.19)
  BOTTOM w0.191: v1(68.39,73.46) 68.77,73.84 ST16.1
VCCL_HPS_EN: length 366.6
  TOP w0.127: v1(36.58,65.1) 36.99,65.51 38.64,65.51 39.05,65.1 41.51,65.1 42.81,66.4 42.81,74.75 45.85,77.8 63.81,77.8 v1(63.89,77.73)
  L12_SIG4 w0.127: v1(36.58,65.1) 35.06,66.63 30.87,66.63 30.04,67.45 30.04,70.63 30.74,71.33 30.74,71.96 32.9,74.12 32.9,77.93 34.93,79.96 34.93,80.72 35.31,81.1 35.82,81.1 37.7,82.98 37.7,85.02 42.74,90.06 42.74,91.46 48.01,96.73 50.81,96.73 52.08,98 54.74,98 57.03,100.28 57.03,102.82 59.19,104.98 66.17,104.98 66.83,104.32 72.96,104.32 73.41,104.78 73.41,105.11 74.15,105.84 74.89,105.84 75.39,106.35 82.78,106.35 83.86,107.43 86.51,107.43 88.32,105.62 94.32,105.62 94.65,105.29 94.65,104.7 95.43,103.91 111.51,103.91 112.07,104.47 123.29,104.47 123.7,104.06 124.89,104.06 125.55,103.39 127.08,103.39 127.23,103.24 131.08,103.24 131.4,103.56 131.4,103.93 134.6,107.14 148.37,107.14 149.92,105.59 186.29,105.59 187.64,104.25 189.46,104.25 191.04,102.67 194.46,102.67 196.24,104.45 201.53,104.45 202.6,103.38 205.09,103.38 206.33,102.14 207.47,102.14 208.67,100.94 209.91,100.94 211.41,99.44 218.6,99.44 220.48,97.56 226.08,97.56 232.74,90.9 234.42,90.9 235.39,89.93 235.39,88.39 235.82,87.96 237.51,87.96 238.74,86.74 238.74,85.05 240.65,83.14 240.65,80.06 244.51,76.2 244.51,65.36 250.69,59.17 250.69,47.41 248.77,45.49 248.77,41.75 247.54,40.53 247.54,37.05 245.93,35.44 245.93,32.13 246.36,31.7 v1(247.21,31.7)
  BOTTOM w0.127: R5997.1 62.55,71.52 62.14,71.94 62.14,75.97 v1(63.89,77.73)
VCCL_HPS_MGN: length 2.3
  BOTTOM w0.149: v1(72.2,68.38) 72.36,68.54 R6000.1
  BOTTOM w0.203: R6001.2 71.97,67.74 72.2,67.98 v1(72.2,68.38)
VCCL_HPS_PG: length 403.3
  L07_SIG3 w0.127: v1(70.93,69.65) 70.52,70.06 64.47,70.06 63.25,68.84 60.43,68.84 60.08,68.48 58.58,68.48 56.55,66.45 49.18,66.45 47.02,64.29 42.93,64.29 42.12,65.1 v1(38.49,65.1)
  L12_SIG4 w0.127: v1(258.95,25.06) 257.75,26.26 257.75,33.64 258.2,34.09 258.2,37.06 259.06,37.92 259.06,46.43 260.48,47.86 260.48,66.98 259.77,67.69 259.77,78.97 262.95,82.15 262.95,99.47 258.86,103.56 247.02,103.56 244.58,106 244.58,106.02 244.1,106.5 220.68,106.5 219.65,107.53 216.85,107.53 214.85,105.54 210.88,105.54 209.2,107.22 206.28,107.22 204.99,108.51 198.38,108.51 195.63,105.76 191.47,105.76 189.79,107.44 153.09,107.44 151.82,108.71 133.82,108.71 132.1,106.99 130.84,106.99 129.81,105.96 129.81,105.71 129.58,105.48 127.68,105.48 125.97,107.19 124.44,107.19 123.48,108.16 103.16,108.16 101.1,106.1 98.33,106.1 96.43,108 91.4,108 90.48,108.92 76.11,108.92 75.08,107.89 73.45,107.89 72,106.44 71.18,106.1 68.87,106.1 67.95,107.01 58.3,107.01 56.8,105.51 56.22,105.51 55.96,105.26 55.96,104.65 55.23,103.91 53.96,103.91 53.55,103.51 53.55,102.14 52.56,101.15 49.13,101.15 41.28,93.3 39,93.3 37.98,92.28 37.98,90.63 33.15,85.8 32.39,85.8 31.76,85.17 31.76,82.5 28.2,78.95 28.2,76.38 28.94,75.64 28.94,72.95 27.31,71.33 27.31,65.99 28.46,64.85 33.54,64.85 33.97,64.42 34.83,64.42 35.08,64.67 38.06,64.67 v1(38.49,65.1)
  BOTTOM w0.127: R5994.1 70.95,69.67 v1(70.93,69.65)
VCCL_SDM_EN: length 64
  L16_SIG6 w0.127: v1(249.56,34.56) 249.56,35.02 249.17,35.41 249.17,39.54 246.01,42.7 246.01,43.82 244.77,45.05 235.43,45.05 235.02,44.64 230.12,44.64 229.15,45.61 227.37,45.61 227.06,45.29 218.35,45.29 217.25,46.38 215.02,46.38 213.44,47.96 207.7,47.96 203.74,51.92 203.74,58.36 v1(204.17,58.79)
VCCL_SDM_PG: length 111.3
  L05_SIG2 w0.127: v1(258.15,25.06) 258.56,24.64 262.69,24.64 263.81,25.76 270.03,25.76 271.76,27.49 271.76,57.51 v1(270.39,58.88)
  L07_SIG3 w0.127: v1(270.39,58.88) 268.13,58.88 267.42,59.59 261.27,59.59 259.8,61.06 247.12,61.06 246.64,60.58 239.94,60.58 v1(238.92,59.57)
  L16_SIG6 w0.127: v1(238.92,59.57) 238.18,58.83 213.98,58.83 212.81,57.66 209.99,57.66 v1(209.28,56.95)
  BOTTOM w0.127: v1(209.28,56.95) 209.21,57.01 R5984.1
VCCLSENSE: length 56.1
  L03_SIG1 w0.203: v1(143.63,72.43) 143.18,72.88 142.37,72.88 141.92,72.42 141.64,72.42 141.13,72.93 140.67,72.93 140.22,72.47 139.83,72.47 139.38,72.93 139,72.93 138.54,72.47 136.38,72.47 135.87,71.96 135.54,71.96 135.01,71.43 134.63,71.43 134.17,70.97 133.83,70.97 133.31,70.44 132.95,70.44 132.44,69.94 132.06,69.94 131.55,69.43 131.17,69.43 130.69,68.94 130.33,68.94 129.88,68.49 129.52,68.49 129.01,67.98 128.66,67.98 128.1,67.42 127.72,67.42 127.26,66.96 126.93,66.96 126.4,66.43 125.99,66.43 125.53,65.97 125.18,65.97 124.64,65.44 124.31,65.44 123.81,64.93 123.4,64.93 122.89,64.42 122.46,64.42 122.02,63.99 121.65,63.99 121.17,64.47 117.99,64.47 117.2,63.68 113.4,63.68 112.97,63.25 112.97,62.86 112.58,62.46 112.15,62.46 111.61,61.93 v1(110.58,61.93)
  BOTTOM w0.203: v1(143.63,72.43) 143.13,72.92 142.49,72.92 142.19,73.22 142.19,73.74 142.5,74.05 142.5,74.88 142.19,75.19 142.19,75.68 142.46,75.95 142.85,75.95 143.09,76.19 143.09,81.65 142.29,82.45 141.55,82.45 139.49,84.51 139.49,85.15 R238.1
VCCPLL_HPS:
  vias: v1(107.99,72.43) v1(107.99,71.43) v1(144.63,62.93)
VCCPLL_SDM:
  vias: v1(129.64,52.93) v1(129.64,51.93)
VCCPLLDIG_HPS: length 50.6
  L07_SIG3 w0.279: v1(108.85,71.93) 107.8,71.93 107.3,71.43 106.95,71.43 106.42,71.96 106.09,71.96 105.55,71.43 106.04,70.94 106.43,70.94 106.94,70.44 107.32,70.44 107.81,70.93 v1(108.85,70.93) ; 99.52,70.94 100.01,71.43 100.39,71.43 100.89,71.93 101.23,71.93 101.71,71.45 102.09,71.45 102.61,70.93 102.99,70.93 103.71,71.65 103.43,71.94 102.6,71.94 102.11,72.43 99.99,72.43 99.5,71.94 99.15,71.94 98.65,72.43 98.26,72.43 97.77,71.94 95.69,71.94 95.2,72.43 94.81,72.43 94.32,71.94 93.94,71.94 93.43,72.44 93.1,72.44 92.58,71.93 92.22,71.93 91.72,72.43 91.33,72.43 90.83,71.93 90.49,71.93 89.99,72.43 89.2,72.43 88.91,72.14 89.62,71.43 90,71.43 90.5,70.93 90.85,70.93 91.35,71.43 91.7,71.43 92.2,70.93 92.57,70.93 93.1,71.46 93.43,71.46 93.94,70.94 94.32,70.94 94.8,71.43 95.18,71.43 95.68,70.93 97.65,70.93 98.15,71.43 98.65,71.43 99.14,70.94 99.52,70.94
  L07_SIG3 w0.508: v1(108.85,71.93) v1(108.85,70.93)
  L07_SIG3 w0.559: 103.71,71.65 104.66,71.65 104.88,71.43 105.55,71.43 ; v1(84.8,72.93) v1(85.8,72.93) 86.54,72.93 87.33,72.14 88.91,72.14
VCCPLLDIG_SDM:
  vias: v1(127.9,52.93) v1(127.9,51.93) v1(140.89,38.43) v1(140.89,37.45) v1(140.89,36.35)
VCCR_AGND: length 7.2
  TOP w0.203: v1(68.36,59.64) 67.73,59.01 63.72,59.01 U56.E1
  BOTTOM w0.203: v1(68.36,59.64) 68.77,60.05 ST12.1
  BOTTOM w0.254: R6092.2 68.45,59.55 v1(68.36,59.64)
VCCR_EN: length 263.2
  L14_SIG5 w0.127: v1(64.12,57.85) 60.79,57.85 59.02,56.08 59.02,52.72 56.09,49.79 56.09,35.97 54.69,34.57 54.69,28.32 53.83,27.46 53.83,24.67 55.2,23.29 55.2,21.54 56.83,19.92 56.83,18.06 61.45,13.44 79.03,13.44 81.11,11.36 81.16,11.36 82.56,9.96 107.09,9.96 110.52,13.39 133.46,13.39 136.38,16.31 153.02,16.31 158.6,21.9 191.65,21.9 198,15.55 208.23,15.55 208.82,16.14 210.15,16.14 212.39,18.38 216.48,18.38 v1(219.77,15.09)
  L16_SIG6 w0.127: v1(247.21,27.64) 247.38,27.64 248.14,26.88 248.14,25.5 248.65,25 248.65,19.94 243.52,14.81 220.05,14.81 v1(219.77,15.09)
VCCR_MGN: length 1.4
  BOTTOM w0.149: R6030.1 72.17,55.03 v1(72.17,54.56) 72.17,54.17 R6031.2
VCCR_PG: length 402.4
  L07_SIG3 w0.127: v1(34.42,63.96) 34.02,64.37 34.02,65.76 34.4,66.14 35.39,66.14 36.05,65.48 36.05,65.05 36.53,64.57 38.89,64.57 39.07,64.75 40.8,64.75 44,61.55 68.36,61.55 70.11,59.79 70.11,56.62 v1(70.9,55.83)
  L12_SIG4 w0.127: v1(34.42,63.96) 28.58,63.96 26.3,66.25 26.3,71.15 27.72,72.57 27.72,73.61 28.15,74.04 28.15,75.69 27.63,76.22 27.63,79.39 28.65,80.41 28.65,81.04 31.31,83.71 31.31,85.87 32.39,86.95 33.66,86.95 37.47,90.76 37.47,92.53 38.74,93.8 41.16,93.8 49.08,101.73 49.49,101.73 50.32,102.57 52.1,102.57 53.78,104.24 54.97,104.24 55.63,104.9 55.63,105.34 56.27,105.97 56.65,105.97 59.49,108.82 68.1,108.82 69.45,110.16 72.6,110.16 73.57,109.2 91.07,109.2 91.63,108.64 96.66,108.64 98.11,110.09 100.85,110.09 102.01,108.92 125.91,108.92 127.14,110.14 130.11,110.14 131.18,109.07 152.48,109.07 152.92,108.64 190.61,108.64 192.05,110.08 194.81,110.08 195.87,109.02 205.26,109.02 205.98,108.31 210.4,108.31 212.71,106 214.92,106 217.84,108.92 242.08,108.92 245.93,105.07 257.75,105.07 263.23,99.59 263.23,77.94 261.26,75.98 261.26,47.18 259.44,45.37 259.44,37.9 259.19,37.65 259.19,34.04 258.45,33.3 258.45,30.35 v1(258.95,29.86)
  BOTTOM w0.127: v1(70.9,55.83) 70.9,56.1 R6024.1
VCCRTPLL_GXER1: length 0.4
  BOTTOM w0.381: C1449.1 v1(83.8,55.97) ; C1448.1 v1(82.8,55.99)
  vias: v1(79.8,54.88) v1(80.8,54.88) v1(84.8,57.93) v1(85.75,57.93) v1(102.79,60.43) v1(102.79,59.43)
VDD25OUT: length 7.4
  L12_SIG4 w0.089: v1(233.43,51.77) 233.43,51.13 234.42,50.14 234.42,49.53 234.18,49.29 234.18,47.49 234.45,47.22 v1(234.45,45.04)
VDD33_OUT1: length 16.5
  TOP w0.254: v1(228.75,24.41) 229.2,24.41 229.22,24.42 U46.20
  L07_SIG3 w0.508: v1(231.83,19.22) 230.93,19.22 228.16,21.99 228.16,23.83 v1(228.75,24.41)
  BOTTOM w0.381: R6265.2 236.8,22.15 v1(233.84,19.19) 233.27,18.62 232.43,18.62 v1(231.83,19.22)
VDDIM: length 1.1
  BOTTOM w0.216: v1(27.22,103.96) U16.C1 U16.C2
  vias: v1(28.33,107.84) v1(29.85,108.03)
VSS_SENSE: length 86.6
  TOP w0.203: 155.71,87.01 155.36,86.66 154.91,86.66 154.46,86.21 154.46,83 152.11,80.65 148.16,80.65 146.2,82.6 142.45,82.6 139.83,85.21 139.83,86.1 v1(140.16,86.43)
  TOP w0.254: v1(156.98,87.02) 156.97,87.01 155.71,87.01
  L12_SIG4 w0.127: v1(196.7,65.26) 196.7,64.09 195.99,63.38 194.82,63.38 194.19,64.01 194.19,67.13 195.46,68.4 195.46,74.88 194.46,75.89 182.8,75.89 180.63,78.06 176.99,78.06 176.57,77.64 165.45,77.64 161.36,81.72 161.36,83.45 158.23,86.58 157.42,86.58 v1(156.98,87.02)
  BOTTOM w0.149: R6114.1 196.1,64.68 R5949.2
0P6V_DDR4_VTT_CH23_PG: length 57.6
  L16_SIG6 w0.127: v1(210.55,20) 212.78,20 215.7,17.08 235.46,17.08 236.05,16.49 243.75,16.49 245.35,18.09 245.35,23.6 246.62,24.87 246.62,27.61 247.12,28.12 248.93,28.12 249.19,27.86 251.43,27.86 252.23,27.06 254.55,27.06 v1(254.95,26.66)
  BOTTOM w0.254: v1(210.55,20) 210.5,19.94 U60.9
0P6V_VREF_DDR4_CH01: length 140.4
  L03_SIG1 w0.762: v1(67.04,104.81) 66.61,105.23 64.52,105.23 63,103.71 v2(63,98.27) 63,92.53 67.32,88.22 71.2,88.22 71.88,87.54 76.17,87.54 v1(76.72,88.09)
  L03_SIG1 w1.016: v2(63,98.27) 52.18,98.27 49.28,101.17 v2(49.28,102.57)
  L05_SIG2 w0.305: v1(109.72,72.43) v1(111.45,72.43)
  L14_SIG5 w0.254: 102.14,78.42 102.65,77.91 103.01,77.91 103.96,76.95 104.72,76.95 105.18,77.41 105.59,77.41 106.05,76.96 106.47,76.96 106.9,77.39 107.35,77.39 107.78,76.96 108.2,76.96 108.64,77.39 109.06,77.39 109.49,76.96 109.93,76.96 110.37,77.4 110.81,77.4 111.32,76.89 111.68,76.89 112.16,76.41 112.53,76.41 113,75.94 113.35,75.94 113.87,75.42 114.25,75.42 114.74,74.92 115.11,74.92 115.59,74.44 115.95,74.44 116.49,73.9 118.43,73.9 118.92,73.41 119.46,73.41 120.11,72.76 v1(120.11,72.43) 119.07,72.43 118.11,73.39 117.29,73.39 116.83,72.93 116.48,72.93 115.98,73.43 115.63,73.43 115.16,73.9 114.75,73.9 114.21,74.44 113.88,74.44 113.38,74.94 113.01,74.94 112.52,75.42 112.14,75.42 111.66,75.9 111.3,75.9 110.81,76.4 110.37,76.4 109.92,75.95 109.52,75.95 109.07,76.4 108.65,76.4 108.21,75.96 107.8,75.96 107.36,76.4 106.9,76.4 106.46,75.97 106.05,75.97 105.62,76.39 105.16,76.39 104.74,75.97 103.58,75.97 102.11,77.44 101.75,77.44 101.25,77.94 100.88,77.94 100.37,78.44 100.02,78.44 99.69,78.77 99.69,79.1 99.81,79.22 99.81,79.62 99.71,79.72 99.71,80.17 99.86,80.31 99.86,80.59 100.19,80.93 100.51,80.61 100.51,80.28 100.66,80.13 100.66,79.68 100.57,79.59 100.57,79.25 100.87,78.95 101.23,78.95 101.77,78.42 102.14,78.42
  L14_SIG5 w0.305: v1(121.84,72.43) v1(120.11,72.43)
  L14_SIG5 w0.635: 100.19,80.93 100.19,81.63 98.56,83.26 98.56,84.54 97.73,85.37 87.78,85.37 83.79,89.36 77.99,89.36 v1(76.72,88.09)
  BOTTOM w0.279: U59.6 49.68,102.96 49.47,102.76
  BOTTOM w0.381: 49.47,102.76 v2(49.28,102.57) ; v1(67.04,97.44) 66.99,97.49 C18.1
  BOTTOM w0.508: 65.98,98.17 C18.1 ; v2(49.28,102.57) 49.22,102.5 C658.1
  BOTTOM w0.635: v2(63,98.27) 63.36,98.63 65.52,98.63 65.98,98.17
0P6V_VREF_DDR4_CH23: length 225.6
  L03_SIG1 w0.305: v1(109.72,51.43) v1(111.45,51.43)
  L05_SIG2 w0.305: v1(120.11,51.43) v1(121.84,51.43) ; v1(109.72,51.43) v1(111.45,51.43)
  L05_SIG2 w0.635: v1(191.99,26.42) 192.79,25.62 192.79,24.46 191.99,23.66 v1(191.99,18.8)
  L07_SIG3 w0.305: v1(109.72,51.43) 109.72,51.74 110.1,52.12 110.1,52.13 110.38,52.41 110.74,52.41 110.77,52.45 110.78,52.45 111.21,52.88 111.22,52.88 111.28,52.94 111.62,52.94 111.64,52.91 111.65,52.91 112.12,52.45 112.52,52.45 112.7,52.62 112.7,52.63 112.98,52.91 112.99,52.91 113.01,52.94 113.36,52.94 113.88,52.41 114.25,52.41 114.27,52.38 114.28,52.38 114.71,51.95 115.08,51.95 115.53,51.49 115.53,51.49 115.58,51.45 115.98,51.45 116.45,51.91 116.84,51.91 117.26,51.49 117.27,51.49 117.31,51.45 117.71,51.45 118.18,51.91 118.58,51.91 118.86,51.63 118.86,51.62 119.06,51.43 v1(120.11,51.43) v1(121.84,51.43)
  L14_SIG5 w0.254: 137.27,50.94 137.65,50.94 137.9,51.19 137.9,51.63 137.81,51.71 137.81,52.13 137.99,52.31 137.99,52.52 137.81,52.7 137.81,53.15 138.06,53.4 138.45,53.4 138.97,53.92 139.32,53.92 139.8,54.4 140.17,54.4 140.67,54.9 141.04,54.9 141.55,55.41 142.28,55.41 143.26,56.39 145.92,56.39 146.38,55.93 145.9,55.45 142.98,55.45 141.96,54.43 141.57,54.43 141.11,53.97 140.76,53.97 140.22,53.43 139.84,53.43 139.33,52.92 139,52.92 138.69,52.61 138.69,52.22 138.8,52.11 138.8,51.75 138.65,51.6 138.65,51.24 138.81,51.08 138.81,50.75 138.46,50.4 138.06,50.4 137.56,49.9 137.21,49.9 136.76,49.45 136.41,49.45 135.88,48.92 135.48,48.92 134.99,48.43 134.63,48.43 134.12,47.92 133.76,47.92 133.22,47.39 132.87,47.39 132.37,46.89 132.01,46.89 131.57,46.45 131.16,46.45 130.7,46.91 130.28,46.91 129.82,46.46 129.41,46.46 128.92,46.94 128.58,46.94 128.09,47.43 127.7,47.43 127.19,47.95 126.81,47.95 126.3,48.46 125.91,48.46 125.69,48.68 125.69,49.12 125.82,49.25 125.82,49.62 125.48,49.96 125.08,49.96 124.58,50.47 124.21,50.47 123.72,50.96 123.36,50.96 122.89,51.43 v1(121.84,51.43) 121.84,51.74 122.5,52.4 122.92,52.4 123.38,51.93 123.75,51.93 124.24,51.44 124.59,51.44 125.09,50.94 125.46,50.94 125.96,50.43 126.33,50.43 126.68,50.09 126.68,49.79 126.56,49.68 126.56,49.23 126.84,48.94 127.19,48.94 127.69,48.44 128.06,48.44 128.59,47.91 128.96,47.91 129.41,47.46 129.86,47.46 130.33,47.93 130.68,47.93 131.18,47.44 131.58,47.44 132.08,47.95 132.44,47.95 132.91,48.42 133.31,48.42 133.8,48.92 134.15,48.92 134.68,49.44 135.02,49.44 135.54,49.95 135.9,49.95 136.39,50.44 136.77,50.44 137.27,50.94 ; 149.8,56.91 150.34,57.45 158.27,57.45 158.27,56.79 157.88,56.4 150.31,56.4 149.8,56.91
  L14_SIG5 w0.635: 158.27,57.45 161.71,57.45 167.65,51.51 171.32,51.51 171.97,50.86 171.97,49.94 172.5,49.41 172.98,49.41 173.57,48.82 173.57,48.11 174.14,47.53 177.01,47.53 178.97,45.57 179.79,45.57 181.11,44.25 189.67,44.25 194.19,39.73 194.19,35.34 196.41,33.12 199.93,33.12 204.02,29.03 205.93,29.03 206.94,28.02 209.43,28.02 ; 146.38,55.93 146.64,55.93 146.96,56.26 146.96,57.19 147.39,57.61 148.78,57.61 149.49,56.91 149.8,56.91
  L14_SIG5 w1.016: 210.19,24.89 v2(210.19,21.77) ; 210.19,24.89 210.09,25 193.41,25 v1(191.99,26.42) ; 210.19,24.89 210.19,27.26 209.43,28.02
  BOTTOM w0.254: U60.6 209.44,21.44 209.47,21.47
  BOTTOM w0.305: v1(111.45,51.43) 111.75,51.13 111.75,50.81 112.15,50.41 112.51,50.41 112.8,50.13 112.99,49.93 113.37,49.93 113.85,50.41 114.25,50.41 114.26,50.4 114.71,49.95 115.41,49.95 115.88,50.42 117.7,50.42 117.7,50.41 117.71,50.41 118.26,49.86 118.86,49.86 119.89,50.89 119.89,51.21 v1(120.11,51.43)
  BOTTOM w0.381: 209.47,21.47 209.89,21.47 v2(210.19,21.77) C672.1 ; v1(191.99,18.8) 192.03,18.76 C133.1 C123.1
  BOTTOM w0.406: v1(191.99,26.42) 192.1,26.3 C90.1
0P6V_VTT_DDR4_CH01: length 2.4
  BOTTOM w0.254: U59.3 53.98,103.96
  BOTTOM w0.279: U59.5 53.09,101.81 53.35,101.55
  vias: v1(53.47,100.41) v1(55.13,103.46) v1(55.13,101.86) v1(55.13,100.41) v1(130.79,104.98) v1(130.8,103.71) v1(130.79,100.41) v1(130.79,99.14) v1(130.79,97.36) v1(130.79,96.09) v1(130.79,92.79) v1(130.79,91.52)
0P6V_VTT_DDR4_CH01_PG: length 309.3
  L12_SIG4 w0.127: v1(258.15,22.66) 258.94,23.45 258.94,24.47 259.37,24.89 259.37,26.42 258.55,27.23 258.55,28.88 259.37,29.7 259.37,31.47 259.62,31.73 259.95,31.73 260.23,32.01 260.23,36.78 259.72,37.29 259.72,44.2 262.25,46.73 262.25,76.57 263.51,77.83 263.51,99.71 257.13,106.09 245.31,106.09 242.1,109.3 216.21,109.3 215.27,110.24 212.76,110.24 211.97,109.45 196.11,109.45 195.15,110.41 191.59,110.41 190.41,109.22 153.3,109.22 153.07,109.45 131.24,109.45 130.26,110.43 126.51,110.43 125.48,109.4 102.19,109.4 101.18,110.42 97.64,110.42 96.73,109.5 74.15,109.5 73.21,110.44 68.99,110.44 67.95,109.4 58.35,109.4 55.84,106.89 55.84,105.97 55.38,105.51 50.2,105.51 49.92,105.23 v1(47.76,105.23)
  BOTTOM w0.254: U59.9 49.42,104.46 49.03,104.85 48.14,104.85 v1(47.76,105.23)
0P6V_VTT_DDR4_CH23: length 2.6
  BOTTOM w0.254: U60.3 205.17,20.44
  BOTTOM w0.279: v1(205.75,23.07) 206.06,22.76 U60.5
  vias: v1(128.24,32.42) v1(128.24,31.42) v1(128.24,27.42) v1(128.24,26.42) v1(128.24,24.75) v1(128.24,23.8) v1(128.24,19.8) v1(128.24,18.8) v1(203.84,23.95) v1(203.77,22.55) v1(203.77,20.95) v1(204.86,23.95) v1(204.86,23.07) v1(205.75,23.95)
0P8V_AGND: length 0.6
  BOTTOM w0.203: ST3.1 v1(208.01,59.49)
  vias: v1(205.02,55.68) v1(205.02,54.74) v1(205.21,56.95)
0P8V_VCCL_SDM: length 156.8
  L05_SIG2 w0.254: v1(256.67,34.56) 256.08,33.96 252.76,33.96 248.8,30 248.8,23.57 248.11,22.89 247.99,22.89 247.66,22.56 247.66,19 243.96,15.31 223.31,15.31 221.39,17.22 221.39,21.19 220.45,22.13 220.45,27.51 219.36,28.6 213.04,28.6 v1(210.7,30.94)
  L07_SIG3 w0.254: v1(144.63,52.43) 145.59,53.39 148.93,53.39 150.83,55.3 153.14,55.3 154.29,56.44 157.97,56.44 158.78,55.63 160.9,55.63 165.07,51.46 176.97,51.46 179.69,48.75 179.69,45.49 181.67,43.51 185.27,43.51 186.14,42.65 186.14,39.88 188.07,37.95 188.07,35.54 189.75,33.86 190.75,33.86 191.82,34.93 193.94,34.93 195.13,33.73 209.53,33.73 210.7,32.57 v1(210.7,30.94)
  vias: v1(122.71,54.93) v1(122.71,53.93) v1(124.44,54.93) v1(124.44,53.93) v1(144.89,38.43) v1(144.89,37.43) v1(145.89,38.43) v1(145.89,37.43) v1(146.63,46.43) v1(146.63,45.43) v1(147.63,46.43) v1(147.63,45.43) v1(148.63,46.43) v1(148.63,45.43) v1(149.62,45.43) v1(209.28,55.68) v1(210.55,56.95) v1(210.55,55.68) v1(211.82,56.95) v1(211.82,55.68)
0P9V_VCCH: length 215.4
  TOP w0.381: v1(85.8,47.43) 85.8,47.43 C1268.1
  L03_SIG1 w0.203: v1(106.25,64.43) 106.25,64.8 106.89,65.43 107.25,65.43 107.7,64.98 108.27,64.98 108.72,65.43 109.03,65.43 109.48,64.98 109.92,64.98 110.37,65.43 110.71,65.43 111.18,64.96 111.88,64.96 112.02,65.1 113.29,65.1 113.62,64.77 117.02,64.77 117.28,65.04 117.28,65.45 117.61,65.77 120.09,65.77 120.68,66.37 121.21,66.37 121.62,65.96 121.99,65.96 122.46,66.42 122.89,66.42 123.4,66.93 123.81,66.93 124.31,67.44 124.64,67.44 125.18,67.97 125.53,67.97 125.99,68.43 126.4,68.43 126.93,68.96 127.26,68.96 127.72,69.42 128.1,69.42 128.66,69.98 129.01,69.98 129.52,70.49 129.88,70.49 130.33,70.94 130.69,70.94 131.17,71.43 131.55,71.43 132.06,71.94 132.44,71.94 132.95,72.44 133.31,72.44 133.79,72.93 134.14,72.93 134.65,73.43 135.01,73.43 135.47,73.89 135.82,73.89 136.3,74.37 136.76,74.37 137.29,74.91 137.65,74.91 138.08,74.48 138.47,74.48 138.91,74.92 139.32,74.92 139.78,74.46 140.2,74.46 140.67,74.93 141.07,74.93 141.58,74.43 142.23,74.43 142.39,74.59 143.26,74.59 145.4,72.45 v1(145.63,72.45)
  L03_SIG1 w0.254: v1(224.16,63.07) v1(224.16,62.18) v1(224.16,61.42) v1(224.16,60.66)
  L05_SIG2 w0.254: v1(264.68,35.06) 259.2,35.06 v1(258.71,34.56)
  L07_SIG3 w0.203: v1(220.47,79.68) 218.08,79.68 214.4,76 214.38,76 213.57,75.19 209.25,75.19 208.77,74.7 200.24,74.7 199.55,75.39 198.56,75.39 196.83,77.12 v1(196.83,78.13)
  L07_SIG3 w0.254: v1(224.16,63.07) v1(224.16,62.18) v1(224.16,61.42) v1(224.16,60.66) 224.49,60.33 224.49,60.28 225.65,59.12 237.13,59.12 238.21,58.04 238.21,52.12 242.78,47.55 259.34,47.55 262.64,44.25 262.64,36.64 264.23,35.05 264.67,35.05 v1(264.68,35.06)
  L16_SIG6 w0.203: v1(196.83,78.13) 196.17,78.13 195.46,78.84 195.46,81.05 194.93,81.59 194.93,84.97 192.23,87.66 190.84,87.66 190.28,87.1 188.17,87.1 187.38,87.89 169.02,87.89 160.41,79.28 158.96,79.28 158.47,78.79 158.47,74.67 158.12,74.32 156.65,74.32 155.91,73.59 155.91,73.26 154.21,71.55 146.52,71.55 v1(145.63,72.45)
  BOTTOM w0.381: C1280.1 v1(81.8,55.97) ; C1272.1 v1(144.63,75.43)
  vias: v1(79.8,55.99) v1(79.93,71.43) v1(79.93,69.93) v1(80.8,71.43) v1(80.8,69.93) v1(80.8,55.99) v1(81.8,71.43) v1(81.8,69.93) v1(82.8,71.43) v1(82.8,69.93) v1(85.8,63.93) v1(87.8,89.43) v1(87.8,88.43) v1(87.8,87.43) v1(87.8,86.43) v1(88.8,89.43) v1(88.8,88.43) v1(92.4,87.43) v1(92.4,86.43) v1(105.39,62.93) v1(105.39,61.93) v1(105.39,60.93) v1(105.39,58.93) v1(105.39,57.93) v1(105.39,55.93) v1(105.39,54.93) v1(106.25,63.43) v1(106.25,61.43) v1(106.25,60.43) v1(106.25,58.43) v1(106.25,57.43) v1(106.25,55.43) v1(114.28,66.22) v1(114.28,57.64) v1(115.81,66.22) v1(115.79,57.64) v1(117.48,57.64) v1(117.74,66.22) v1(126.17,63.93) v1(126.17,62.93) v1(126.17,60.93) v1(126.17,59.93) v1(126.17,58.93) v1(126.17,54.93) v1(127.04,65.43) v1(127.04,64.43) v1(127.04,63.43) v1(127.04,62.43) v1(127.04,61.43) v1(127.04,60.43) v1(143.63,53.43) v1(143.63,51.43) v1(143.63,50.43) v1(143.63,49.43) v1(144.63,66.93) v1(144.63,65.93) v1(144.63,64.93) v1(144.63,59.93) v1(144.63,58.93) v1(144.63,57.93) v1(144.63,51.43) v1(144.63,49.43) v1(145.63,74.43) v1(145.63,73.43) v1(145.63,66.93) v1(145.63,65.93) v1(145.63,64.93) v1(145.63,59.93) v1(145.63,58.93) v1(145.63,57.93) v1(145.63,51.43) v1(145.63,50.43) v1(145.63,49.43) v1(146.63,59.93) v1(146.63,58.93) v1(147.63,66.93) v1(147.63,65.93) v1(147.63,64.93) v1(147.63,47.43) v1(149.62,48.43) v1(149.62,47.43) v1(150.62,47.43) v1(151.62,62.93) v1(151.62,61.93) v1(218.38,77.58) v1(218.38,66.15) v1(219.65,77.58) v1(219.65,76.31) v1(219.65,66.15) v1(220.61,63.96) v1(220.61,63.07) v1(220.92,78.85) v1(220.92,77.58) v1(220.92,76.31) v1(220.92,66.15) v1(220.92,64.88) v1(221.5,63.96) v1(221.5,63.07) v1(221.5,62.18) v1(221.5,60.53) v1(222.19,78.85) v1(222.19,77.58) v1(222.19,76.31) v1(222.19,67.42) v1(222.19,66.15) v1(222.19,64.88) v1(222.38,63.96) v1(222.38,63.07) v1(222.51,62.18) v1(222.51,61.42) v1(222.51,60.53) v1(223.27,63.96) v1(223.27,63.07) v1(223.27,62.18) v1(223.27,61.42) v1(223.27,60.53) v1(223.46,78.85) v1(223.46,77.58) v1(223.46,76.31) v1(223.46,67.42) v1(223.46,66.15) v1(223.46,64.88) v1(224.16,63.96) v1(224.73,78.85) v1(224.73,77.58) v1(224.73,76.31) v1(224.73,68.69) v1(224.73,67.42) v1(224.73,66.15) v1(224.73,64.88) v2(67.27,49.56) v2(67.29,46.61) v2(68.08,48.34) v2(217.18,89.36) v2(217.18,88.47) v2(217.18,87.58) v2(218.07,89.36) v2(218.07,88.47) v2(218.07,87.58) v2(218.96,89.36) v2(218.96,88.47) v2(218.96,87.58) v2(219.72,89.36) v2(219.72,88.47) v2(219.72,87.58) v2(219.72,86.69) v2(220.61,89.36) v2(220.61,88.47) v2(220.61,87.58) v2(220.61,86.69) v2(220.61,85.68) v2(220.61,84.79) v2(220.61,83.9) v2(220.61,83.01) v2(220.61,82.12) v2(220.61,81.23) v2(221.5,89.36) v2(221.5,88.47) v2(221.5,87.58) v2(221.5,86.69) v2(221.5,85.68) v2(221.5,84.79) v2(221.5,83.9) v2(221.5,83.01) v2(221.5,82.12) v2(221.5,81.23) v2(221.5,80.47) v2(222.38,89.36) v2(222.38,88.47) v2(222.38,87.58) v2(222.38,86.69) v2(222.38,85.68) v2(222.38,84.79) v2(222.38,83.9) v2(222.38,83.01) v2(222.38,82.12) v2(222.38,81.23) v2(222.38,80.47) v2(223.27,89.36) v2(223.27,88.47) v2(223.27,87.58) v2(223.27,86.69) v2(223.27,85.68) v2(223.27,84.79) v2(223.27,83.9) v2(223.27,83.01) v2(223.27,82.12) v2(223.27,81.23) v2(223.27,80.47) v2(224.42,89.36) v2(224.42,88.47) v2(224.42,87.58) v2(224.42,86.69) v2(224.42,85.68) v2(224.42,84.79) v2(224.42,83.9) v2(224.42,83.01) v2(224.42,82.12) v2(224.42,81.23) v2(224.42,80.47) v2(225.31,89.36) v2(225.31,88.47) v2(225.31,87.58) v2(225.31,86.69) v2(225.31,85.68) v2(225.31,84.79) v2(225.31,83.9) v2(225.31,83.01) v2(225.31,82.12) v2(225.31,81.23) v2(226.19,89.36) v2(226.19,88.47) v2(226.19,87.58) v2(226.19,86.69) v2(226.19,85.68) v2(226.19,84.79) v2(226.19,83.9) v2(227.08,89.36) v2(227.08,88.47) v2(227.08,87.58) v2(227.08,86.69) v2(227.08,85.68) v2(227.08,84.79) v2(227.08,83.9) v2(227.85,85.68) v2(227.85,84.79) v2(227.97,89.36) v2(227.97,88.47) v2(227.97,87.58) v2(227.97,86.69) v2(227.97,83.9) v2(228.61,85.68) v2(228.61,84.79) v2(228.73,89.36) v2(228.73,88.47) v2(228.73,87.58) v2(228.73,86.69) v2(228.86,83.9) v3(217.1,89.44)
0P9V_VCCL_HPS: length 359.9
  L03_SIG1 w0.254: v1(55.76,13.79) 53.4,13.79 50.22,16.97 45.88,16.97 44.34,18.51 44.34,28.26 43.57,29.03 43.57,31.57 44.58,32.59 45.47,32.59 46.36,33.48 49.61,33.48 v1(50.83,32.26)
  L07_SIG3 w0.254: v1(182.13,15.7) 182.76,15.06 187.97,15.06 190.74,17.83 195.1,17.83 198.38,14.56 209.56,14.56 v1(210.07,15.06)
  L14_SIG5 w0.254: v1(50.83,32.26) 53.47,34.9 53.47,47.98 58.68,53.19 58.68,62.69 61.6,65.61 61.6,76.2 64.42,79.02 78.09,79.02 78.52,79.45 91.75,79.45 92.26,79.96 94.96,79.96 95.9,79.03 95.9,78.44
  BOTTOM w0.254: v1(55.76,13.79) 56.57,12.99 100.42,12.99 102.24,14.81 151.9,14.81 153.93,16.84 165.95,16.84 166.96,17.86 179.97,17.86 v1(182.13,15.7) ; v1(210.07,15.06) 210.57,15.57 210.57,16.18 212.25,17.86 215.98,17.86 218.29,15.55 244.76,15.55 247.23,18.02 251.44,18.02 252.36,17.1 258.07,17.1 262.67,21.69 262.67,27.9 263.91,29.15 263.91,35.26 261.97,37.2 259.44,37.2 R372.2
  vias: v1(73.47,74.73) v1(73.47,73.46) v1(73.47,72.19) v1(74.74,74.73) v1(74.74,73.46) v1(74.74,72.19) v1(74.74,70.92) v1(74.74,69.65) v1(76.01,74.73) v1(76.01,73.46) v1(76.01,72.19) v1(76.01,70.92) v1(76.01,69.65) v1(78.67,68.43) v1(79.67,68.43) v1(82.6,68.43) v1(83.6,68.43) v1(85.8,69.93) v1(86.8,71.43) v1(86.8,69.93) v1(108.85,69.93) v1(108.85,68.93) v1(108.85,67.93) v1(110.58,69.93) v1(110.58,68.93) v3(76,77.42)
0P9V_VCCRT_GXER1:
  vias: v1(79.8,53.43) v1(79.8,51.93) v1(79.8,50.43) v1(79.8,48.93) v1(80.8,53.43) v1(80.8,51.93) v1(80.8,50.43) v1(80.8,48.93) v1(81.8,53.43) v1(81.8,51.93) v1(81.8,50.43) v1(81.8,48.93) v1(84.8,45.8) v1(85.8,51.93) v1(87.5,37.43) v1(87.5,36.43) v1(87.5,35.43) v1(87.71,61.19) v1(87.8,52.43) v1(87.8,48.93) v1(88.8,37.43) v1(88.8,36.43) v1(88.8,35.43) v1(101.06,63.43) v1(101.06,62.43) v1(101.06,61.43) v1(101.06,60.43) v1(101.06,59.43) v1(101.06,58.43) v1(101.06,57.43) v1(101.06,56.43) v1(101.92,63.93) v1(101.92,62.93) v1(101.92,61.93) v1(101.92,57.93) v1(101.92,56.93) v1(101.92,55.93) v2(70.8,51.51) v2(70.8,50.12) v2(70.8,48.53) v2(70.8,47.07) v2(71.43,51.51) v2(71.43,50.12) v2(71.43,48.53) v2(71.43,47.07) v2(72.07,51.51) v2(72.07,50.12) v2(72.07,48.53) v2(72.07,47.07) v2(72.7,51.51) v2(72.7,50.12) v2(72.7,48.53) v2(72.7,47.07) v2(73.34,51.51) v2(73.34,50.12) v2(73.34,48.53) v2(73.34,47.07) v2(74.61,51.51) v2(74.61,50.12) v2(75.88,51.51) v2(75.88,50.12) v3(74.43,50.12)
0P9V_VCCRT_GXPL1: length 0.1
  BOTTOM w0.381: C1314.1 v1(145.63,62.93)
  vias: v1(130.5,66.43) v1(130.5,65.43) v1(130.5,61.43) v1(131.37,66.93) v1(131.37,65.93) v1(131.37,64.93) v1(131.37,63.93) v1(131.37,62.93) v1(131.37,61.93) v1(131.37,60.93) v1(144.63,56.93) v1(144.63,55.93) v1(144.63,54.7) v1(145.63,56.93) v1(145.63,55.93) v1(145.63,54.7) v1(146.63,62.93) v1(146.63,61.93) v1(147.63,59.93) v1(147.63,58.93) v1(147.63,56.93) v1(147.63,55.93) v1(147.63,54.7) v1(148.63,59.93) v1(148.63,58.93) v1(149.62,59.93) v1(149.62,58.93)
1P1V_VCCH_GXER1: length 365.2
  TOP w0.381: C2036.1 58.74,57.38 v1(58.02,57.38)
  L03_SIG1 w0.254: v1(57.03,13.79) 56.27,14.56 53.73,14.56 50.55,17.73 46.24,17.73 45.09,18.88 45.09,28.91 44.2,29.8 44.2,31.32 44.9,32.02 45.79,32.02 46.62,32.84 49.54,32.84 v1(51.06,31.32)
  L05_SIG2 w0.508: v1(56.93,54.27) 56.95,54.28 57.23,54.28 58.96,56.01 58.96,57.03 58.6,57.38 v1(58.02,57.38)
  L07_SIG3 w0.254: v1(209.3,15.06) 198.89,15.06 195.64,18.32 190.46,18.32 187.84,15.7 v1(183.4,15.7)
  L12_SIG4 w0.381: v1(87.92,64.14) 87.92,66.12 87.23,66.8 v1(85.8,66.8) v1(84.8,66.8)
  BOTTOM w0.254: v1(57.03,13.79) 57.16,13.66 99.31,13.66 101.05,15.4 151.72,15.4 153.68,17.35 165.41,17.35 166.38,18.32 180.78,18.32 v1(183.4,15.7) ; v1(51.06,31.32) 52.53,31.32 54.01,32.79 57.08,32.79 57.87,32.01 57.87,26.88 59.42,25.33 66.99,25.33 68.54,26.88 69.32,26.88 70.26,25.94 71.48,25.94 72.42,26.88 73.18,26.88 74.12,25.94 76.11,25.94 77.05,26.88 78.29,26.88 79.69,28.27 79.69,31.6 81.16,33.07 92.06,33.07 93.15,34.17 93.15,41.1 94.01,41.96 94.32,41.96 94.8,42.45 95.18,42.45 95.69,42.95 96.04,42.95 96.55,43.46 96.91,43.46 97.42,43.97 97.8,43.97 98.28,44.45 98.66,44.45 99.17,44.96 99.52,44.96 99.8,45.24 99.8,45.62 99.73,45.7 99.73,46.13 100.01,46.41 100.39,46.41 100.87,46.89 101.18,46.89 101.73,47.45 102.12,47.45 102.39,47.73 102.39,48.16 102.32,48.24 102.32,48.62 102.6,48.9 102.95,48.9 103.46,49.41 103.79,49.41 104.12,49.74 104.12,50.12 104.05,50.19 104.05,50.65 104.12,50.73 104.12,51.13 104.05,51.21 104.05,51.67 104.12,51.74 104.12,52.12 104.05,52.2 104.05,52.66 104.12,52.73 104.12,53.11 104.05,53.19 104.05,53.65 104.12,53.72 104.12,54.13 104.05,54.21 104.05,54.66 104.12,54.74 104.12,55.12 104.05,55.2 104.05,55.54 v1(103.66,55.93) ; R376.2 261.69,36.46 263.15,35 263.15,29.77 261.72,28.34 261.72,21.78 257.67,17.73 252.61,17.73 251.7,18.65 246.97,18.65 244.38,16.06 218.64,16.06 216.11,18.59 212.32,18.59 209.68,15.95 209.68,15.45 v1(209.3,15.06)
  BOTTOM w0.381: C1253.1 87.85,58.93 v1(87.8,58.98) ; C1254.1 v1(87.8,59.93)
  vias: v1(45.52,54.38) v1(45.96,54.69) v1(45.96,54.13) v1(52.11,54.27) v1(56.93,57.38) v1(61.3,59.01) v1(79.8,60.93) v1(79.8,59.43) v1(79.8,57.93) v1(80.8,60.93) v1(80.8,59.43) v1(80.8,57.93) v1(81.8,60.93) v1(81.8,59.43) v1(81.8,57.93) v1(84.8,60.93) v1(85.8,60.93) v1(87.8,55.98) v1(103.66,62.93) v1(103.66,61.93) v1(103.66,57.93) v1(103.66,56.93)
1P2V_DDR4_CH01: length 296
  TOP w0.381: J2.231 144.39,105.43 144.05,105.77 143.03,105.77 142.69,105.43 J2.229
  L12_SIG4 w0.203: v1(126.17,53.93) 125.19,53.93 124.87,54.24 124.87,68.16 124.6,68.43 124.27,68.43 123.75,68.95 123.4,68.95 123.14,69.21 123.14,70.11 123.13,70.11 123.13,70.13 122.71,70.55 v1(122.71,70.93) 123.72,70.93 124,70.65 124,70.61 124,70.61 124,70.25 124,70.25 124,69.73 124.31,69.42 124.59,69.42 125.1,68.91 125.48,68.91 125.74,68.66 125.74,54.73 126.17,54.3 v1(126.17,53.93)
  L12_SIG4 w0.254: v1(243.43,82.73) 243.43,79.53 246.55,76.41 254.08,76.41 254.46,76.02 254.46,74.7 255.2,73.97 255.2,67.54 255.66,67.08 255.66,48.86 254.28,47.49 254.28,46.74 252.15,44.61 252.15,40.46 253.07,39.55 253.07,36.15 252.61,35.69 v1(252.61,34.56)
  L12_SIG4 w0.508: v1(54.24,106.89) 52.84,108.28 49.03,108.28 46.62,105.87 42.93,105.87 42.3,106.51 40.9,106.51 40.26,105.86 30.38,105.86 26.96,102.44 25.28,102.44 22.49,99.65 13.85,99.65 12.71,100.79 3.36,100.79 1.02,98.45 1.02,62.44 1.98,61.48 v1(2.67,61.48)
  L14_SIG5 w0.191: 238.97,87.19 238.97,89.64 236.66,91.95 228.38,91.95 225.84,94.49 221.5,94.49 218.88,97.11 209.15,97.11 208.64,97.61 208.64,98.35 208.29,98.71 207.53,98.71 206.99,98.17 206.99,97.09 207.22,96.85 207.22,94.59 207.65,94.16 212.02,94.16 212.17,94.31 215.27,94.31 215.81,93.77 215.81,91.41 212.66,88.26 212.66,81.79 v1(212.22,81.36)
  L14_SIG5 w0.203: v1(243.43,82.73) 238.97,87.19
  BOTTOM w0.254: U59.2 53.85,104.46 53.98,104.6
  BOTTOM w0.305: R38.2 v1(120.11,84.43) ; R39.2 v1(109.72,84.43) ; C12.1 127.34,96.31 v1(127.39,96.36) ; v1(115.49,92.52) 115.39,92.63 R10.2 ; R673.1 v1(104.52,84.43) ; C43.1 126.86,103.93 v1(127.29,104.36) ; R790.2 120.58,104.47 120.59,104.46 v1(120.59,103.98) ; R36.2 v1(107.99,84.43) ; R47.2 v1(114.91,84.43) ; R50.1 R49.1
  BOTTOM w0.381: C1365.1 v1(121.84,83.43) ; v1(96.59,93.68) 96.57,93.7 U3.1 ; v1(137.59,96.36) 137.64,96.31 C25.1 ; R651.2 55.32,107.71 55.13,107.52 v1(55.13,106.89) ; U67.1 75.62,94.46 v1(76.33,93.74) ; v1(90.62,93.68) 90.1,94.2 U23.1 ; v1(83.95,93.74) 83.24,94.46 U68.1 ; C1333.1 v1(133.97,83.43) ; C1330.1 v1(132.23,83.43) ; v1(137.59,103.98) 137.64,103.93 C47.1 ; C1350.1 v1(123.57,83.43) ; C1360.1 v1(121.83,89.43) ; v1(105.86,93.68) 105.84,93.7 U1.1 ; R789.2 120.44,96.51 v1(120.59,96.36) ; R44.2 v1(111.45,84.43) ; v1(130.53,83.43) 130.5,83.45 C1331.1
  vias: v1(54.24,106) v1(54.24,105.11) v1(55.13,106) v1(55.13,105.11) v1(71.72,101.33) v1(79.34,101.33) v1(86.68,93.68) v1(88.46,93.68) v1(92.67,101.2) v1(101.94,101.2) v1(106.23,84.43) v1(109.72,85.43) v1(110.58,71.93) v1(110.58,70.93) v1(112.15,94.44) v1(112.33,101.97) v1(112.32,71.93) v1(112.32,70.93) v1(112.94,103.08) v1(112.94,101.08) v1(112.94,95.46) v1(112.94,93.46) v1(113.18,86.43) v1(113.18,85.43) v1(114.05,71.93) v1(114.05,70.93) v1(114.91,86.43) v1(114.91,85.43) v1(115.49,100.14) v1(115.78,71.93) v1(115.78,70.93) v1(116.34,103.98) v1(116.34,96.74) v1(116.65,86.43) v1(117.14,92.55) v1(117.19,100.14) v1(117.51,71.93) v1(117.51,70.93) v1(118.04,103.98) v1(118.04,102.98) v1(118.04,96.49) v1(118.04,95.36) v1(118.38,88.43) v1(118.38,87.43) v1(118.38,85.43) v1(119.24,71.93) v1(119.24,70.93) v1(119.74,100.14) v1(119.74,92.37) v1(119.98,87.43) v1(120.11,88.43) v1(120.11,85.43) v1(120.98,71.93) v1(120.98,70.93) v1(121.84,86.52) v1(122.29,100.14) v1(122.29,92.52) v1(122.71,71.93) v1(123.14,103.98) v1(123.14,96.36) v1(123.57,89.43) v1(123.57,86.43) v1(123.57,85.43) v1(124.84,100.14) v1(124.84,92.52) v1(125.31,88.43) v1(125.31,87.43) v1(125.31,85.43) v1(125.69,103.98) v1(125.69,96.36) v1(127.04,88.43) v1(127.04,87.43) v1(127.39,99.89) v1(127.39,92.14) v1(128.77,86.43) v1(128.77,85.43) v1(129.94,104.36) v1(129.93,99.77) v1(129.94,96.36) v1(129.93,92.15) v1(130.53,86.43) v1(130.53,85.43) v1(132.23,86.43) v1(133.97,85.43) v1(138.44,100.14) v1(138.44,92.52) v1(140.14,103.98) v1(140.14,96.36) v1(140.99,100.14) v1(140.99,92.52) v1(142.69,103.98) v1(142.69,100.14) v1(142.69,96.36) v1(142.69,92.52) v1(144.39,103.98) v1(144.39,96.36) v1(145.24,100.14) v1(145.24,92.52) v1(146.09,103.98) v1(146.09,96.36) v1(146.69,102.69) v1(146.69,94.47) v1(146.94,100.14) v1(146.86,92.83) v1(147.32,95.47) v1(147.45,102.69) v1(147.5,101.22) v1(147.58,93.57) v1(148.64,103.98) v1(148.64,100.14) v1(148.64,96.36) v1(148.64,92.66) v1(200.79,82.63) v1(200.79,81.36) v1(200.79,80.09) v1(203.33,80.09) v1(204.6,81.36) v1(204.6,80.09) v1(207.14,80.09) v1(208.41,81.36) v1(208.41,80.09) v1(210.95,80.09) v1(212.22,80.09) v2(201.05,77.32) v2(201.05,76.69) v2(201.68,77.32) v2(201.68,76.69) v2(202.9,77.47) v2(202.9,76.84) v2(203.54,77.47) v2(203.54,76.84) v2(211.46,77.32) v2(211.49,76.53) v3(199.75,77.45)
1P2V_DDR4_CH01_AGND: length 0.8
  BOTTOM w0.191: v1(207.14,87.71) 207.32,87.53 ST13.1
1P2V_DDR4_CH01_EN: length 102.2
  L12_SIG4 w0.127: v1(247.21,26.62) 246.72,27.12 246.72,28.76 245.07,30.41 245.07,40.76 245.24,40.94 245.24,50.44 245.09,50.59 245.09,59.45 243.49,61.05 243.49,63.72 243.06,64.15 243.06,76.86 240.02,79.9 240.02,82.98 240,82.98 238.18,84.8 238.18,86.5 237.28,87.4 v1(234.58,87.4)
  BOTTOM w0.127: R6033.2 204.78,88.89 205.53,88.14 208.59,88.14 209.73,87 213.52,87 216.75,90.22 229.75,90.22 230.31,89.66 230.31,88.7 231.6,87.4 v1(234.58,87.4)
1P2V_DDR4_CH01_PG: length 159.5
  L05_SIG2 w0.127: v1(258.15,29.06) 258.4,28.81 262.92,28.81 269.12,35 269.12,46.94 269.76,47.58 269.76,53.93 268.61,55.07 268.61,64.42 v1(266.02,67.01) ; v1(203.6,83.24) 203.33,82.97 v1(203.33,82.63)
  L14_SIG5 w0.127: v1(203.33,82.63) 203.73,82.63 204.1,83 204.1,85.47 204.65,86.03 209.99,86.03 215.42,91.47 215.42,93.55 214.99,93.98 212.3,93.98 212.17,93.85 207.51,93.85 206.89,94.47 206.89,96.73 206.59,97.03 206.59,98.22 207.41,99.04 208.48,99.04 209.02,98.5 209.02,97.77 209.35,97.44 219.13,97.44 221.72,94.85 225.97,94.85 228.51,92.31 236.82,92.31 244.8,84.32 244.82,84.32 245.6,83.54 252.69,83.54 255.43,80.8 255.43,78.54 257.06,76.91 257.06,69.6 259.65,67.01 v1(266.02,67.01)
1P2V_DDR4_CH23: length 106
  L05_SIG2 w0.305: v1(222.27,17.87) 223.88,16.26 243.9,16.26 245.78,18.14 245.78,28.92 248.03,31.17 249.05,31.17 252.13,34.24 252.13,34.78 252.41,35.05 254.15,35.05 v1(254.64,34.56)
  L05_SIG2 w0.508: v1(129.09,19.8) v1(131.64,19.8)
  L12_SIG4 w0.305: v1(222.27,17.87) 220.33,19.81 v1(220.33,28.43)
  BOTTOM w0.254: 205.24,19.88 205.3,19.94 U60.2
  BOTTOM w0.305: R83.2 102.79,39.43 R82.2 R81.2 ; v1(128.77,38.43) R676.1 ; R676.1 R674.1 R675.1 v1(130.5,38.43) ; R676.1 R677.1
  BOTTOM w0.381: C75.1 152.49,30.2 U4.1 ; v1(127.04,40.43) 125.45,40.43 C1368.1 ; C96.1 121.39,27.47 v1(121.44,27.42) ; v1(112.09,31.42) 112.05,31.42 111.05,32.42 109.86,32.42 109.18,33.1 106.1,33.1 105.26,33.94 105.26,35.89 104.6,36.55 103.89,36.55 103.66,36.79 R82.2 ; C1390.1 v1(114.91,40.43) ; U5.1 80.99,29.62 81.03,29.67 v1(81.03,30.11) 81.73,30.11 82.62,31 R833.1 ; C116.1 121.39,19.85 v1(121.44,19.8) ; v1(116.34,24.13) 116.34,24.13 C113.1 ; v1(143.52,31.7) 143.51,31.69 R61.2 ; C1382.1 v1(116.65,40.43) ; 146.73,19.53 146.74,19.53 151.37,19.53 151.84,19.07 152.34,19.07 152.66,19.38 153.17,19.38 153.44,19.11 154.02,19.11 156.39,21.48 U4.8 ; C1374.1 v1(118.38,40.43) ; C1377.1 v1(120.11,40.43)
  vias: v1(84.89,22.66) v1(110.39,31.42) v1(110.39,27.42) v1(110.39,23.8) v1(110.39,19.8) v1(110.58,52.93) v1(110.58,51.93) v1(111.46,30.42) v1(111.46,22.8) v1(112.09,29.42) v1(112.09,28.42) v1(112.09,23.8) v1(112.09,21.8) v1(112.22,20.8) v1(112.32,52.93) v1(112.32,51.93) v1(112.94,27.42) v1(112.94,19.8) v1(113.79,31.42) v1(113.79,23.8) v1(114.05,52.93) v1(114.05,51.93) v1(114.64,27.42) v1(114.64,19.8) v1(114.91,38.43) v1(114.91,37.43) v1(115.78,52.93) v1(115.78,51.93) v1(116.34,31.42) v1(116.34,27.42) v1(116.34,19.8) v1(116.65,37.43) v1(117.51,52.93) v1(117.51,51.93) v1(118.04,31.42) v1(118.04,23.8) v1(118.38,38.43) v1(118.38,37.43) v1(118.89,27.42) v1(118.89,19.8) v1(119.24,52.93) v1(119.24,51.93) v1(120.11,38.43) v1(120.11,36.43) v1(120.11,35.43) v1(120.59,31.42) v1(120.59,23.8) v1(120.98,52.93) v1(120.98,51.93) v1(121.84,36.43) v1(121.84,35.43) v1(122.71,52.93) v1(122.71,51.93) v1(123.57,38.43) v1(123.57,37.43) v1(125.31,38.43) v1(125.31,37.43) v1(127.04,36.43) v1(127.04,35.43) v1(128.77,36.43) v1(128.77,35.43) v1(129.09,31.42) v1(129.09,27.42) v1(129.07,23.8) v1(130.5,37.43) v1(131.64,31.42) v1(131.64,27.42) v1(131.64,23.8) v1(132.23,37.43) v1(133.34,27.42) v1(133.34,19.37) v1(133.91,38.43) v1(133.97,37.43) v1(134.19,31.42) v1(134.27,23.8) v1(135.7,38.43) v1(135.89,27.42) v1(135.89,19.8) v1(136.74,31.42) v1(136.74,23.8) v1(136.8,38.43) v1(138.44,27.42) v1(138.44,19.8) v1(139.29,31.42) v1(139.29,23.8) v1(140.99,28.42) v1(140.99,27.42) v1(140.99,19.8) v1(141.79,31.42) v1(141.84,23.8) v1(142.69,27.42) v1(142.69,19.8) v1(143.54,23.8) v1(145.99,30.42) v1(146.09,28.42) v1(152.53,30.27) v1(199.14,39.96) v1(199.14,38.69) v1(199.14,37.42) v1(201.68,37.42) v1(202.95,38.69) v1(202.95,37.42) v1(203.97,19.51) v1(203.97,18.49) v1(203.97,17.48) v1(204.86,19.51) v1(204.86,18.49) v1(204.86,17.48) v1(204.85,16.25) v1(205.49,37.42) v1(206.76,38.69) v1(206.76,37.42) v1(209.3,37.42) v1(210.57,38.69) v1(210.57,37.42) v2(198.38,36.15) v2(200.41,34.45) v2(201.05,34.45) v2(202.06,34.45) v2(202.7,34.45) v2(210.27,34.47) v2(210.73,33.56) v3(212.48,34.11)
