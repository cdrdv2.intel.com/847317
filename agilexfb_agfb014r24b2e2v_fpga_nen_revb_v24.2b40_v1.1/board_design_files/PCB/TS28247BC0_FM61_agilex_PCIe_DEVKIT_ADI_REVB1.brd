# Allegro board TS28247BC0_FM61_agilex_PCIe_DEVKIT_ADI_REVB1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_DIMM_CH3_CS_N1: length 81.7
  L07_SIG3 w0.089: v1(112.94,24.79) 112.94,23.21 113.41,22.74 113.41,22.6 113.21,22.4 113.07,22.4 112.48,23 112.48,24.71 112.39,24.8 112.22,24.8 112.08,24.66 112.08,24.45 111,23.37 110.86,23.37 110.74,23.49 110.74,23.63 110.99,23.89 110.99,24.03 110.82,24.2 110.82,24.34 110.92,24.44 111.07,24.44 111.24,24.27 111.38,24.27 111.67,24.56 111.67,24.97 111.44,25.2 110.62,25.2 110.52,25.3 110.52,25.48 110.41,25.58 110.18,25.58 110.08,25.48 110.08,24.71 109.55,24.18 108.31,24.18 108.21,24.29 108.21,24.53 108.31,24.63 109.06,24.63 109.16,24.73 109.16,24.87 109.06,24.97 108.26,24.97 108.16,25.07 108.16,25.21 108.26,25.31 109.61,25.31 109.71,25.42 109.71,25.55 109.61,25.66 107.92,25.66 107.8,25.54 107.8,25.25 107.7,25.15 107.56,25.15 107.46,25.25 107.46,25.54 107.36,25.64 107.22,25.64 107.12,25.54 107.12,25.27 107.02,25.17 106.88,25.17 106.78,25.27 106.78,25.54 106.67,25.64 106.53,25.64 106.43,25.54 106.43,25.27 106.33,25.17 106.19,25.17 106.09,25.27 106.09,25.54 105.99,25.64 105.85,25.64 105.75,25.54 105.75,24.49 105.65,24.39 105.51,24.39 105.4,24.49 105.4,25.55 105.3,25.65 105.16,25.65 105.06,25.55 105.06,24.46 104.96,24.36 104.15,24.36 104.05,24.46 104.05,25.05 104.22,25.22 104.6,25.22 104.7,25.33 104.7,25.5 104.6,25.61 103.31,25.61 103.21,25.5 103.21,24.44 103.11,24.34 102.45,24.34 102.34,24.44 102.34,25.02 102.5,25.17 102.67,25.17 102.78,25.28 102.78,25.48 102.67,25.58 101.58,25.58 101.48,25.48 101.48,24.44 101.38,24.34 100.72,24.34 100.62,24.44 100.62,25.05 100.77,25.2 100.97,25.2 101.07,25.3 101.07,25.48 100.97,25.58 99.88,25.58 99.78,25.48 99.78,24.41 99.68,24.31 99.02,24.31 98.91,24.41 98.91,25.12 99.03,25.24 99.32,25.24 99.42,25.34 99.42,25.48 99.32,25.58 98.18,25.58 98.08,25.48 98.08,24.5 97.97,24.4 97.37,24.4 97.26,24.5 97.26,25.07 97.4,25.21 97.59,25.21 97.7,25.31 97.7,25.45 97.59,25.56 96.91,25.56 96.74,25.72 96.74,26.17 96.63,26.27 96.49,26.27 96.39,26.17 96.39,25.44 96.29,25.34 96.13,25.34 96.03,25.44 96.03,25.93 95.93,26.03 95.78,26.03 95.68,25.93 95.68,25.42 95.58,25.32 95.43,25.32 95.33,25.42 95.33,26.55 95.23,26.65 95.08,26.65 94.98,26.55 94.98,26.09 94.88,25.99 94.72,25.99 94.62,26.09 94.62,26.69 94.44,26.88 94.29,26.88 94.19,26.98 94.19,27.19 94.29,27.29 94.62,27.29 94.72,27.39 94.72,27.57 94.62,27.68 94.26,27.68 94.13,27.8 94.13,32 93.87,32.26 93.87,32.57 94.65,33.35 94.65,33.81 95.34,34.5 95.34,35.76 95.85,36.27 96.09,36.27 97.16,37.34 97.16,38.74 97.35,38.93 97.7,38.93 97.98,39.21 97.98,39.57 98.12,39.71 98.46,39.71 98.56,39.82 98.56,39.95 98.46,40.06 97.92,40.06 97.82,40.16 97.82,40.3 97.92,40.4 98.48,40.4 98.58,40.5 98.58,40.64 98.48,40.74 97.92,40.74 97.82,40.84 97.82,40.98 97.92,41.09 98.53,41.09 98.63,41.19 98.63,41.33 98.53,41.43 v1(97.59,41.43)
DDR4_DIMM_CH3_CS_N2: length 85.6
  L05_SIG2 w0.081: v1(95.86,44.43) 95.86,43.96 95.49,43.59 95.49,42.27 95.68,42.08 95.68,41.78 95.49,41.58 95.49,41.07 95.57,40.99 95.57,38.74 95.83,38.48 95.83,36.2 96.58,35.45 96.58,33.93 97.22,33.29 97.22,30.77 98.06,29.92 98.06,26.14 98.94,25.26 98.94,24.3 98.51,23.87 98.51,22.73 99.09,22.15 99.09,21.33 98.51,20.75 98.51,19.67 98.94,19.24 98.94,18.62 100.23,17.33 107.27,17.33 108.24,18.3 108.24,19.77 109.15,20.69 109.15,22.25 108.88,22.53 108.88,23.3 109.17,23.6 109.17,24.08 108.93,24.33 108.93,25.49 109.17,25.74 109.17,29.91 109.27,30.01 109.52,30.01 109.62,29.91 109.62,28.3 109.72,28.2 109.86,28.2 109.96,28.3 109.96,29.91 110.06,30.01 110.19,30.01 110.29,29.91 110.29,28.28 110.39,28.19 110.53,28.19 110.63,28.28 110.63,28.69 110.73,28.79 110.87,28.79 110.96,28.69 110.96,27.91 110.87,27.81 109.72,27.81 109.62,27.72 109.62,25.3 109.72,25.2 109.91,25.2 110.01,25.3 110.01,26.89 110.11,26.99 111.21,26.99 111.34,27.12 111.34,28.14 111.44,28.24 111.62,28.24 111.72,28.14 111.72,27.1 111.82,27 112.05,27 112.15,27.1 112.15,27.96 112.26,28.06 112.44,28.06 112.54,27.96 112.54,26.75 112.44,26.65 110.5,26.65 110.4,26.55 110.4,26.42 110.5,26.32 112.53,26.32 112.63,26.22 112.63,26.08 112.53,25.98 110.65,25.98 110.49,25.83 110.49,25.34 110.64,25.19 112.43,25.19 112.53,25.09 112.53,24.52 112.43,24.42 109.92,24.42 v1(109.54,24.8)
DDR4_DIMM_CH3_CS_N3: length 85.8
  L05_SIG2 w0.081: v1(109.54,18.8) 109.54,19.71 110.21,20.38 111.27,20.38 111.37,20.48 111.37,20.61 111.27,20.72 110.19,20.72 110.09,20.82 110.09,20.95 110.19,21.05 111.63,21.05 111.73,21.15 111.73,21.29 111.63,21.39 110.19,21.39 110.09,21.49 110.09,21.62 110.19,21.72 111.58,21.72 111.69,21.82 111.69,21.96 111.58,22.06 110.25,22.06 110.15,22.16 110.15,22.29 110.25,22.39 111.65,22.39 112.16,22.9 112.83,22.9 113.34,23.41 114.04,23.41 114.2,23.58 114.2,24.31 114.3,24.41 114.43,24.41 114.53,24.31 114.53,23.62 114.63,23.52 114.77,23.52 114.87,23.62 114.87,24.38 114.97,24.48 115.1,24.48 115.2,24.38 115.2,22.53 115.1,22.43 114.96,22.43 114.86,22.53 114.86,23.06 114.76,23.16 114.63,23.16 114.52,23.06 114.52,22.44 114.42,22.34 112.55,22.34 112.45,22.24 112.45,21.99 112.55,21.89 114.55,21.89 114.66,21.78 114.66,21.65 114.55,21.55 112.41,21.55 112.31,21.45 112.31,21.32 112.41,21.22 114.09,21.22 114.19,21.11 114.19,20.98 114.09,20.88 112.72,20.88 112.62,20.78 112.62,20.65 112.72,20.54 113.19,20.54 113.29,20.44 113.29,20.31 113.19,20.21 111.76,20.21 111.66,20.11 111.66,19.98 111.76,19.87 112.35,19.87 112.45,19.77 112.45,19.64 112.35,19.54 110.86,19.54 109.62,18.29 109.36,18.29 107.41,16.34 100.15,16.34 98.71,17.79 97.49,18.29 97.2,18.58 97.2,19.29 97.69,19.78 97.69,23.93 97.2,24.42 97.2,25.54 96.4,26.34 96.4,30.19 95.53,31.06 95.53,31.59 95.84,31.89 95.84,33.53 95.05,34.32 95.05,37.98 94.72,38.31 94.72,40.99 94.84,41.11 94.84,41.56 94.62,41.77 94.62,42.08 94.78,42.24 94.78,42.61 94.62,42.77 94.62,43.1 94.84,43.32 95.11,43.32 95.23,43.44 95.23,43.64 95.42,43.83 95.42,44.99 v1(95.86,45.43)
DDR4_DIMM_CH3_DBI_N0: length 92.6
  L05_SIG2 w0.079: v1(111.45,46.43) 111.45,46.71 111.55,46.81 111.65,46.81 111.75,46.72 111.82,46.54 111.82,46.36 111.71,46.09 111.71,45.78 111.82,45.52 111.82,45.35 111.71,45.08 111.71,44.87 arc(111.75,44.68) 111.86,44.53 111.91,44.47 arc(112.09,44.35) 112.29,44.31 112.34,44.31 arc(112.46,44.29) 112.55,44.22 112.77,43.99 arc(112.95,43.86) 113.16,43.81 113.21,43.81 arc(113.32,43.79) 113.42,43.72 113.64,43.49 arc(113.82,43.36) 114.03,43.31 114.08,43.31 arc(114.19,43.29) 114.28,43.22 114.5,42.99 arc(114.68,42.86) 114.9,42.81 114.94,42.81 arc(115.06,42.79) 115.15,42.72 115.37,42.49 arc(115.55,42.36) 115.76,42.31 115.81,42.31 arc(115.92,42.29) 116.02,42.22 116.23,41.99 arc(116.41,41.86) 116.63,41.81 116.67,41.81 arc(116.79,41.79) 116.88,41.72 117.1,41.49 arc(117.28,41.36) 117.49,41.31 117.54,41.31 arc(117.65,41.29) 117.75,41.22 117.97,40.99 arc(118.15,40.86) 118.36,40.81 118.41,40.81 arc(118.52,40.79) 118.61,40.72 118.79,40.53 119.88,39.8 127.62,39.8 130.92,38.71 131.62,38.01 132.14,37.8 134.13,37.8 135.11,36.99 135.43,36.86 135.77,36.81 137.68,36.23 138.83,35.75 141.32,35.75 144.96,34.24 147.01,33.51 147.67,33.31 150.05,32.84 166.81,32.84 167.83,31.82 172.7,31.82 172.83,31.69 172.83,30.77 173.09,30.51 173.61,30.51 173.87,30.77 173.87,31.69 174,31.82 174.33,31.82 174.46,31.69 174.46,30.35 174.72,30.09 175.24,30.09 175.5,30.35 175.5,31.66 175.63,31.78 175.96,31.78 176.09,31.66 176.09,30.04 176.4,29.73 179.06,29.73 180.12,28.67 181.59,28.67 182.95,27.31 184.01,27.31 184.72,26.61 185.24,25.34 186.7,23.88 187.2,23.88 187.43,24.12 187.43,24.36 v1(187.74,24.67)
DDR4_DIMM_CH3_DBI_N1: length 90.2
  L07_SIG3 w0.085: v1(178.34,24.8) 178.08,25.06 178.08,25.5 177.66,25.92 176.64,25.92 176.31,26.26 176.31,26.7 176.48,26.87 176.48,27.57 175.79,28.26 171.17,28.26 171.04,28.39 171.04,28.85 171.17,28.97 174.09,28.97 174.35,29.23 174.35,29.88 174.09,30.14 168.08,30.14 163.92,34.3 163.92,35.04 162.91,36.05 153.65,36.05 152.8,35.2 148.81,35.2 146.57,37.44 146.57,37.66 146.18,38.05 143.59,38.05 142.6,39.03 138.93,39.03 137.77,40.2 137.77,40.54 136.76,41.54 136.52,41.54 arc(136.39,41.57) 136.29,41.65 136.14,41.85 arc(135.96,41.99) 135.73,42.04 135.65,42.04 arc(135.42,41.99) 135.24,41.85 135.09,41.65 arc(134.99,41.57) 134.87,41.54 134.78,41.54 arc(134.66,41.57) 134.56,41.65 134.41,41.85 arc(134.23,41.99) 134,42.04 133.92,42.04 arc(133.79,42.07) 133.69,42.15 133.54,42.35 arc(133.36,42.49) 133.14,42.54 133.05,42.54 arc(132.93,42.57) 132.83,42.65 132.67,42.85 arc(132.49,42.99) 132.27,43.04 132.19,43.04 arc(132.06,43.07) 131.96,43.15 131.81,43.35 arc(131.63,43.49) 131.4,43.54 131.32,43.54 arc(131.19,43.57) 131.09,43.65 130.94,43.85 arc(130.76,43.99) 130.54,44.04 130.45,44.04 arc(130.33,44.07) 130.23,44.15 130.08,44.35 arc(129.9,44.49) 129.67,44.54 129.59,44.54 arc(129.46,44.57) 129.36,44.65 129.21,44.85 arc(129.03,44.99) 128.81,45.04 128.72,45.04 arc(128.6,45.07) 128.5,45.15 128.34,45.35 arc(128.16,45.49) 127.94,45.54 127.86,45.54 arc(127.73,45.57) 127.63,45.65 127.48,45.85 arc(127.3,45.99) 127.07,46.04 126.99,46.04 arc(126.86,46.07) 126.76,46.15 126.61,46.35 arc(126.43,46.49) 126.21,46.54 125.75,46.54 125.25,47.04 123.53,47.04 arc(123.4,47.07) 123.3,47.15 123.15,47.35 arc(122.97,47.49) 122.74,47.54 122.66,47.54 arc(122.43,47.49) 122.25,47.35 122.1,47.15 arc(122,47.07) 121.88,47.04 121.79,47.04 arc(121.67,47.07) 121.57,47.15 121.42,47.35 arc(121.24,47.49) 121.01,47.54 120.93,47.54 arc(120.7,47.49) 120.52,47.35 120.37,47.15 arc(120.27,47.07) 120.15,47.04 120.06,47.04 arc(119.94,47.07) 119.84,47.15 119.68,47.35 arc(119.5,47.49) 119.28,47.54 119.2,47.54 arc(118.97,47.49) 118.79,47.35 118.64,47.15 arc(118.54,47.07) 118.41,47.04 116.6,47.04 arc(116.47,47.07) 116.37,47.15 116.22,47.35 arc(116.04,47.49) 115.82,47.54 115.73,47.54 arc(115.51,47.49) 115.33,47.35 115.17,47.15 arc(115.07,47.07) 114.95,47.04 114.87,47.04 arc(114.74,47.07) 114.64,47.15 114.49,47.35 arc(114.31,47.49) 114.08,47.54 114,47.54 arc(113.87,47.57) 113.77,47.65 113.62,47.85 arc(113.44,47.99) 113.22,48.04 113.13,48.04 arc(113.01,48.07) 112.91,48.15 112.76,48.35 arc(112.58,48.49) 112.35,48.54 112.27,48.54 arc(112.14,48.57) 112.04,48.65 111.89,48.85 arc(111.71,48.99) 111.49,49.04 111.37,49.04 111.25,49.09 111.13,49.21 111.08,49.34 111.08,49.54 111.16,49.73 111.24,49.81 111.35,49.81 111.45,49.71 v1(111.45,49.43)
DDR4_DIMM_CH3_DBI_N2: length 91.3
  L05_SIG2 w0.079: v1(105.39,48.93) 105.41,49.14 105.33,49.26 105.25,49.27 105.18,49.26 105.14,49.24 105.05,49.13 105.01,49.03 105.01,48.83 105.12,48.56 105.12,48.28 105.01,48.02 105.01,47.86 105.13,47.58 105.13,47.31 105,46.99 105,46.85 105.12,46.54 105.12,46.31 105.01,46.04 105.01,45.85 105.12,45.58 105.12,45.29 105.01,45.02 105.01,44.85 105.13,44.57 105.13,44.31 105.01,44.02 105.01,43.86 105.12,43.57 105.12,43.3 105.01,43.01 105.01,42.84 105.12,42.56 105.12,42.28 105.02,42.02 105.02,41.82 105.15,41.49 105.15,41.19 105.31,41.03 105.31,40.86 105.15,40.7 105.15,40.52 105.27,40.4 105.53,40.4 105.66,40.27 105.66,40.01 105.87,39.81 105.87,39.28 106.12,39.03 106.63,39.03 107.63,38.04 108.25,38.04 112.38,33.91 113.31,33.91 116.2,31.02 122.74,31.02 123.18,31.46 124.79,31.46 125.49,30.76 125.49,28.68 125.62,28.55 125.95,28.55 126.08,28.68 126.08,29.87 126.34,30.13 126.86,30.13 127.12,29.87 127.12,28.34 127.25,28.21 127.58,28.21 127.71,28.34 127.71,29.87 127.97,30.13 128.49,30.13 128.75,29.87 128.75,28.34 128.88,28.21 129.21,28.21 129.34,28.34 129.34,29.87 129.6,30.13 129.98,30.13 130.98,29.13 137.16,29.13 138.27,28.02 141.56,28.02 142.54,27.04 145.55,27.04 146.55,26.04 168.23,26.04 168.72,25.54 168.72,25.11 v1(169.04,24.8)
DDR4_DIMM_CH3_DBI_N3: length 71.4
  L07_SIG3 w0.085: v1(111.45,41.43) 111.45,41.7 111.37,41.78 111.23,41.78 111.17,41.73 111.1,41.61 111.07,41.54 111.07,41.35 111.17,41.1 111.98,40.29 111.98,39.69 112.91,38.76 112.91,38.45 114.32,37.04 122.44,37.04 122.55,36.93 125.51,36.93 126.66,35.78 126.66,35.27 126.93,35 128.83,35 129.85,33.98 131.31,33.98 132.45,32.84 134.79,32.84 136.6,31.03 142.09,31.03 144.09,29.03 147.2,29.03 147.46,28.77 147.46,27.86 147.59,27.74 147.97,27.74 148.1,27.86 148.1,28.77 148.36,29.03 148.96,29.03 149.23,28.77 149.23,27.84 149.35,27.71 149.74,27.71 149.87,27.84 149.87,28.77 150.13,29.03 150.67,29.03 150.93,28.77 150.93,27.84 151.05,27.71 151.4,27.71 151.52,27.84 151.52,28.77 151.78,29.03 152.32,29.03 152.58,28.77 152.58,27.75 152.71,27.63 153.05,27.63 153.18,27.75 153.18,28.77 153.44,29.03 153.97,29.03 154.23,28.77 154.23,27.75 154.36,27.62 154.7,27.62 154.83,27.75 154.83,28.77 155.09,29.03 155.63,29.03 155.89,28.77 155.89,27.98 156.01,27.85 156.37,27.85 156.49,27.98 156.49,28.77 156.75,29.03 157.1,29.03 159.42,26.7 159.42,25.07 v1(159.69,24.8)
DDR4_DIMM_CH3_DBI_N4: length 37.7
  L05_SIG2 w0.079: v1(104.44,24.8) 104.13,25.11 104.13,25.82 104.26,25.95 104.26,26.62 103.76,27.12 102.33,27.12 102.23,27.22 102.23,27.6 102.33,27.71 104.59,27.71 104.82,27.94 104.82,28.51 104.59,28.75 101.52,28.75 101.42,28.85 101.42,29.4 101.52,29.5 104.64,29.5 104.88,29.73 104.88,30.42 104.64,30.65 101.99,30.65 101.59,31.06 101.59,32.15 100.62,33.12 100.62,35.15 98.86,36.91 98.86,39.74 99,39.87 99,40.12 98.86,40.25 98.86,40.82 98.95,40.9 98.95,41.52 99.06,41.81 99.06,42.05 98.94,42.35 98.94,42.51 99.07,42.81 99.07,43.05 98.95,43.33 98.95,43.51 99.06,43.79 99.06,44.07 98.95,44.36 98.95,44.49 99.06,44.77 99.06,45.08 98.95,45.35 98.95,45.51 99.06,45.78 99.06,46.09 98.95,46.36 98.95,46.54 99.03,46.72 99.12,46.81 99.22,46.81 99.32,46.71 v1(99.32,46.43)
DDR4_DIMM_CH3_DBI_N5: length 40.1
  L14_SIG5 w0.079: v1(99.32,49.43) 99.32,49.67 99.22,49.78 99.1,49.78 99.02,49.7 98.95,49.53 98.95,49.34 99.06,49.07 99.06,48.77 98.95,48.5 98.95,48.36 99.06,48.09 99.06,47.8 98.96,47.56 98.82,47.42 98.57,47.31 98.42,47.31 arc(98.32,47.29) 98.23,47.23 97.97,46.96 arc(97.82,46.85) 97.64,46.81 97.56,46.81 arc(97.45,46.79) 97.37,46.73 97.11,46.46 arc(96.96,46.35) 96.78,46.31 96.72,46.31 96.61,46.29 96.51,46.25 96.41,46.15 96.35,46.01 96.35,45.84 96.47,45.55 96.47,45.32 96.37,45.09 96.18,44.9 95.98,44.81 95.78,44.81 95.62,44.74 95.56,44.69 95.49,44.52 95.49,44.34 95.6,44.07 95.6,43.82 95.48,43.52 95.48,43.36 95.59,43.09 95.59,42.77 95.47,42.47 95.47,42.37 95.6,42.07 95.6,41.78 95.48,41.5 95.48,41.31 95.98,40.11 95.98,36.14 95.52,35.67 95.52,33.75 96.37,32.9 96.37,32.34 95.81,31.78 94.16,31.78 94.06,31.68 94.06,31.02 94.16,30.92 96.13,30.92 96.36,30.68 96.36,29.97 96.13,29.74 93.92,29.74 93.82,29.64 93.82,29.19 93.92,29.08 95.93,29.08 96.16,28.85 96.16,28.18 95.93,27.95 93.99,27.95 93.89,27.84 93.89,27.26 94,27.16 94.38,27.16 94.98,26.57 94.98,26.09 94.82,25.93 94.82,25.07 v1(95.09,24.8)
DDR4_DIMM_CH3_DBI_N6: length 58.5
  L05_SIG2 w0.079: v1(93.26,46.93) 93.26,47.21 93.18,47.3 93.04,47.3 92.97,47.23 92.88,47.01 92.88,46.85 93,46.57 93,46.3 92.89,46.05 92.75,45.9 92.53,45.81 90.65,45.81 arc(90.43,45.86) 90.25,45.99 90.04,46.22 arc(89.94,46.29) 89.83,46.31 89,46.31 88,45.31 87.29,45.31 86.84,45.76 86.69,45.76 86.42,45.49 86.42,45.35 87.02,44.75 87.02,44.42 86.61,44.02 86.28,44.02 85.81,44.48 85.67,44.48 85.4,44.21 85.4,44.07 86.21,43.25 86.21,42.92 85.81,42.51 85.48,42.51 83.59,44.4 83.44,44.4 83.17,44.13 83.17,43.99 86.21,40.95 86.21,33.15 85.97,32.92 85.4,32.92 85.16,33.15 85.16,35.88 85.06,35.99 84.68,35.99 84.51,35.82 84.51,33.92 84.27,33.68 83.59,33.68 83.35,33.92 83.35,34.92 83.25,35.02 82.81,35.02 82.7,34.92 82.7,33.89 82.47,33.66 81.9,33.66 81.66,33.89 81.66,34.8 81.56,34.9 81.18,34.9 81.07,34.8 81.07,33.27 81.3,33.05 83.65,33.05 85.24,31.46 85.24,29.51 84.46,28.74 84.46,27.71 85.7,26.47 85.7,26.09 85.38,25.77 85.38,25.16 v1(85.74,24.8)
DDR4_DIMM_CH3_DBI_N7: length 51
  L07_SIG3 w0.085: v1(93.26,48.93) 93.36,49.14 93.34,49.24 93.26,49.31 93.15,49.3 93.03,49.23 92.87,49.04 92.74,48.91 92.5,48.81 92.35,48.81 arc(92.22,48.78) 92.12,48.7 91.97,48.51 arc(91.79,48.37) 91.57,48.31 91.48,48.31 arc(91.26,48.37) 91.08,48.51 90.93,48.7 arc(90.83,48.78) 90.7,48.81 90.62,48.81 arc(90.49,48.78) 90.39,48.7 90.24,48.51 arc(90.06,48.37) 89.84,48.31 89.52,48.31 88.01,47.69 86.42,46.1 86.42,41 86.19,40.76 85.59,40.76 85.35,41 85.35,43.69 85.25,43.79 84.83,43.79 84.73,43.69 84.73,42.69 84.5,42.45 83.89,42.45 83.65,42.69 83.65,43.14 83.37,43.41 82.96,43.41 82.73,43.19 80.25,43.19 77.92,40.86 77.92,33.07 76.61,31.75 76.61,31.38 76.89,31.1 77.19,31.1 77.92,31.82 78.34,31.82 78.72,31.44 78.72,31 74.31,26.59 74.31,25.96 74.55,25.73 75.83,25.73 76.08,25.48 76.08,25.11 v1(76.39,24.8)
DDR4_DIMM_CH3_DBI_N8: length 83.9
  L14_SIG5 w0.081: v1(105.39,46.93) 105.39,47.22 105.3,47.31 105.17,47.31 105.09,47.22 105.01,47.04 105.01,46.84 105.14,46.54 105.14,46.33 105.01,46.02 105.01,45.83 105.12,45.56 105.12,45.3 105.01,45.03 105.01,44.85 105.13,44.57 105.13,44.3 105,44 105,43.86 105.13,43.54 105.13,43.32 105.01,43.02 105.01,42.83 105.12,42.56 105.12,42.27 105.01,42 105.01,41.86 105.17,41.47 105.17,41.24 105.28,41.13 105.28,40.94 105.17,40.84 105.17,40.28 105.45,40 105.45,35.98 105.73,35.7 105.73,32.28 105.91,32.09 105.91,31.17 105.77,31.03 105.77,27.02 105.92,26.87 105.92,25.27 105.65,25 105.65,24.52 106.86,23.31 106.86,22.09 109.55,19.4 112.41,19.4 114.24,17.58 120.47,17.58 121.05,18.16 124.76,18.16 127.75,21.15 130.12,21.15 130.79,21.82 142.23,21.82 142.46,21.59 144.26,21.59 145.09,22.42 146.11,22.42 146.35,22.19 146.35,21.61 146.57,21.39 148.13,21.39 148.25,21.51 148.25,21.89 148.15,21.99 147.21,21.99 146.98,22.23 146.98,22.8 147.21,23.04 148.18,23.04 148.28,23.14 148.28,23.52 148.18,23.62 147.73,23.62 147.17,24.18 147.17,25.06 147.53,25.43 148.39,25.78 149.59,25.78 150.03,25.35 150.03,25.11 v1(150.34,24.8)
DDR4_DIMM_CH3_DQ0: length 94.4
  L05_SIG2 w0.081: v1(189.44,24.79) 189.44,26.1 185.41,30.13 182.74,30.13 182.63,30.25 182.63,30.41 182.74,30.52 184.63,30.52 184.74,30.63 184.74,30.79 184.63,30.91 182.68,30.91 181.42,32.17 181.42,32.92 180.86,33.48 180.43,33.48 180.3,33.35 180.3,32.98 180.17,32.85 179.96,32.85 179.84,32.98 179.84,33.35 179.71,33.48 179.5,33.48 179.38,33.35 179.38,32.84 179.25,32.71 179.04,32.71 178.91,32.84 178.91,33.35 178.79,33.48 178.58,33.48 178.45,33.35 178.45,32.98 178.32,32.85 178.12,32.85 177.99,32.98 177.99,33.35 177.86,33.48 176.79,33.48 175.98,33.77 175.38,34.02 174.54,34.86 174.2,35.08 164.76,35.08 162.35,34.6 149.66,34.6 147.83,34.99 145.97,35.81 142.94,37.07 141.06,37.91 139.23,37.91 137.63,38.81 136.18,38.91 135.85,38.96 135.53,39.06 134.45,39.78 131.29,40.41 129.87,40.92 128.85,41.94 128.58,41.94 128.2,42.32 127.74,42.32 127.34,41.91 126.88,41.91 126.47,42.32 125.94,42.32 125.56,41.94 125.05,41.94 124.67,42.32 124.24,42.32 123.83,41.91 123.35,41.91 122.92,42.34 122.51,42.34 122.21,42.04 121.57,42.04 121.29,42.32 120.68,42.32 120.33,41.96 119.87,41.96 119.36,42.47 119.05,42.47 118.47,43.06 118.2,43.06 117.86,43.4 117.5,43.4 116.86,44.04 116.43,44.04 115.94,44.54 115.58,44.54 115.15,44.96 114.76,44.96 114.33,45.39 113.94,45.39 113.65,45.68 113.65,45.96 v1(113.18,46.43)
DDR4_DIMM_CH3_DQ1: length 94.4
  L05_SIG2 w0.081: v1(188.59,18.8) 188.59,22.19 189.88,23.48 189.88,26.21 184.8,31.28 182.95,31.28 182.24,32 182.24,32.62 181.01,33.84 177.69,33.84 176.99,34.55 176.37,34.97 176.04,35.1 174.61,35.39 174.1,35.44 164.57,35.44 162.07,34.94 149.82,34.94 148.21,35.26 144.13,36.95 142.52,37.88 141.46,38.62 141.06,38.79 140.66,38.87 139.22,39.01 135,40.12 131.93,40.66 130.69,41.9 130.27,41.9 129.72,42.45 129.36,42.45 128.83,42.98 128.51,42.98 128.18,43.31 127.59,43.31 127.21,42.93 126.78,42.93 126.37,43.34 125.89,43.34 125.46,42.9 125.03,42.9 124.54,43.39 124.21,43.39 123.73,42.9 123.4,42.9 122.94,43.36 122.54,43.36 122.13,42.95 121.7,42.95 121.34,43.31 120.68,43.31 120.38,43 119.79,43 119.39,43.41 119.09,43.41 118.5,44.01 118.13,44.01 117.79,44.35 117.44,44.35 116.8,44.99 116.36,44.99 115.87,45.49 115.51,45.49 115.08,45.91 114.71,45.91 114.13,46.49 113.83,46.49 113.46,46.86 113.46,47.15 v1(113.18,47.43)
DDR4_DIMM_CH3_DQ2: length 95.8
  L05_SIG2 w0.081: v1(114.05,47.93) 112.94,47.93 112.56,48.3 112.16,48.3 111.67,47.81 111.29,47.81 110.98,47.5 110.98,44.56 111.13,44.22 111.23,44.11 111.39,44.05 111.67,44.05 112.17,43.54 112.53,43.54 113.02,43.05 113.39,43.05 113.81,42.63 114.46,42.2 114.71,42.1 115.35,41.62 117.49,40.48 118.31,39.93 119.7,39.19 120.07,39.03 121.5,38.96 122.21,38.96 125.1,38.82 125.41,38.79 125.57,38.75 126.63,38.18 127.03,38.01 127.83,37.77 129.34,37.46 130.19,37.09 130.42,37.05 132.33,36.86 134.69,36.39 135.69,35.97 137.67,35.58 139.07,35 139.58,35 143.42,34.23 145.75,33.27 146.03,33.22 146.63,32.97 147.49,32.11 147.67,32.03 148.06,32.03 148.49,32.21 148.9,32.21 149.39,32.01 150.5,32.01 151.05,32.24 151.29,32.24 151.56,32.18 151.92,32.03 152.26,32.03 152.55,32.15 153.08,32.15 153.39,32.09 153.57,32.01 154.76,31.9 161.93,31.9 164,31.8 164.72,31.65 165.41,31.37 165.64,31.32 166.15,31.27 166.38,31.27 166.9,31.17 167.24,31.03 173.29,29.82 180.93,27.71 182.13,26.81 182.25,26.63 182.25,26.11 182.56,25.8 182.56,25.43 182.25,25.12 182.25,23.59 182.35,23.49 182.49,23.49 182.59,23.59 182.59,24.31 182.69,24.41 182.82,24.41 182.92,24.31 182.92,22.72 183.02,22.62 183.16,22.62 183.26,22.72 183.26,24.19 183.36,24.29 183.49,24.29 183.59,24.19 183.59,22.3 183.69,22.2 183.83,22.2 183.93,22.3 183.93,24.36 v1(183.49,24.8)
DDR4_DIMM_CH3_DQ3: length 95.6
  L05_SIG2 w0.081: v1(182.64,18.8) 181.88,19.56 178.57,19.56 176.51,21.62 176.51,24.2 176.18,24.99 176,25.21 174.98,25.89 174.64,26.23 174.49,26.61 174.4,26.71 174.27,26.81 171.79,28.13 169.16,29.22 166.66,29.72 164.86,29.9 149.88,29.9 147.42,30.38 146.59,30.38 146.12,30.85 145.27,30.85 143.9,31.12 143.38,31.34 142.97,31.61 142.03,32.55 141.43,32.8 139.55,33.18 138.16,33.6 137.85,33.66 133.65,33.66 131.87,34.39 125.16,35.05 124.62,35.28 124.01,35.69 123.74,35.8 123.27,35.89 122.92,35.89 120.2,36.03 117.95,36.47 116.25,37.18 115.76,37.51 115.34,37.68 115.1,37.84 114.86,37.92 114.29,38.49 114.09,38.96 113.95,39.1 113.55,39.58 113.24,39.89 113.15,39.93 112.67,40.42 112.55,40.74 112.02,41.39 111.61,41.79 111.1,42.14 110.63,42.33 109.92,42.81 109.83,42.85 109.62,42.99 109.38,43.22 109.29,43.44 109.29,43.86 109.18,44.13 108.88,44.43 108.77,44.47 108.43,44.81 108.43,47.15 108.83,47.54 109.15,47.54 109.27,47.59 109.38,47.7 109.63,47.81 109.9,47.81 110.5,47.56 110.74,47.56 111.24,48.06 111.61,48.06 112.09,48.54 112.44,48.54 113.1,48.81 113.35,48.81 113.66,48.68 114.23,48.31 114.44,48.09 114.44,47.33 v1(114.05,46.93)
DDR4_DIMM_CH3_DQ4: length 92.4
  L05_SIG2 w0.081: v1(110.58,47.93) 110.58,48.12 111.3,48.84 111.63,48.84 112.1,49.31 112.54,49.31 112.81,49.05 113.47,49.05 113.76,49.34 114.24,49.34 114.62,48.95 115.39,48.95 116.34,48.01 116.64,48.01 117.61,47.04 117.9,46.35 118.32,45.93 118.68,45.93 119.15,45.46 119.52,45.46 120.07,44.91 120.38,44.91 120.89,44.4 121.17,44.4 121.53,44.04 122.07,44.04 122.36,44.33 122.97,44.33 123.37,43.92 123.78,43.92 124.29,44.43 124.62,44.43 125.13,43.92 125.53,43.92 126.02,44.4 126.37,44.4 126.85,43.92 127.24,43.92 127.72,44.4 128.05,44.4 128.51,43.94 128.95,43.94 129.43,43.46 129.8,43.46 130.34,42.92 130.64,42.92 131.12,42.44 131.47,42.44 131.96,41.95 132.36,41.95 133.21,41.11 133.83,40.81 135.22,40.43 140.65,39.89 140.95,39.82 141.1,39.75 141.39,39.56 143.06,38.19 144.7,37.09 148.15,35.66 150.12,35.27 151.32,35.27 153.61,35.44 155.58,35.73 157.53,35.88 162.51,35.88 164.29,35.79 174.39,35.79 178.21,35.42 179.7,35.16 179.94,35.1 180.55,34.83 181.71,33.87 182.87,33.1 183.96,32.65 185.51,31.3 190.53,26.75 190.69,26.48 190.96,25.38 v1(191.14,24.79)
DDR4_DIMM_CH3_DQ5: length 92.4
  L05_SIG2 w0.081: v1(110.58,46.93) 109.92,46.86 109.68,46.81 109.5,46.74 109.4,46.64 109.34,46.51 109.34,46.35 109.4,46.22 109.46,46.16 109.51,46.03 109.51,45.79 109.49,45.73 109.4,45.65 109.34,45.5 109.34,45.36 109.4,45.21 109.65,44.97 109.75,44.93 110.06,44.62 110.23,43.75 110.37,43.61 110.52,43.55 110.66,43.55 110.9,43.45 111.3,43.05 111.66,43.05 112.07,42.63 112.51,42.34 113.37,41.77 113.54,41.59 113.92,41.03 114.7,40.07 118.27,38.05 119,37.83 121.14,37.4 122.54,37.2 123.61,37.04 127.22,36.86 128.24,36.86 128.85,36.8 129.78,36.42 131.08,36.02 131.4,35.99 132.29,35.81 132.93,35.55 133.29,35.31 133.78,35.09 134.68,34.86 136.74,34.51 140.36,34.15 140.96,34.03 142.51,33.39 143.19,32.94 143.35,32.87 143.61,32.82 144.35,32.82 144.65,32.73 146.41,31.55 146.74,31.22 147.03,31.1 149.18,31.1 149.3,31.15 150.61,31.15 151.23,31.03 152.46,31.03 153.24,30.87 154.81,30.64 164.33,30.64 166.92,30.38 169.53,29.86 175.18,27.84 176.12,27.4 176.86,26.78 176.97,26.67 177.1,26.49 177.2,26.25 177.26,26.16 178,25.55 179.14,24.8 179.65,24.38 181.79,22.32 184.4,19.37 184.55,19.16 184.95,18.76 185.55,18.44 185.99,18.35 189,18.35 189.53,18.41 v1(190.29,18.8)
DDR4_DIMM_CH3_DQ6: length 91.4
  L05_SIG2 w0.081: v1(109.72,46.43) 110.16,45.99 110.16,44.83 110.35,44.64 110.35,44.51 110.5,44.36 110.68,44.36 111.24,43.81 111.6,43.81 112.09,43.31 112.46,43.31 112.96,42.81 113.33,42.81 113.62,42.52 113.62,41.83 113.84,41.61 114.68,41.05 114.91,40.95 116.35,39.99 116.82,39.8 117.96,39.04 118.94,38.74 119.86,38.12 120.16,38 120.63,37.91 125,37.91 125.66,37.84 128.75,37.23 129.94,36.74 131.02,36.46 132.54,36.46 134.16,36.14 134.63,35.95 135.42,35.15 135.58,35.05 138.02,35.05 138.96,34.66 139.53,34.66 143.27,33.92 145.7,32.91 146.06,32.84 146.37,32.71 147.24,31.84 148.19,31.45 148.93,31.45 149.04,31.56 150.79,31.56 150.9,31.45 152.25,31.45 152.61,31.8 153.04,31.8 153.37,31.47 154.34,31.07 154.78,30.98 165.63,30.98 171.45,29.83 177.48,27.33 179.35,25.46 180.11,25.46 180.54,25.03 180.54,24.51 183.25,21.8 184.39,21.8 184.52,21.93 184.52,24.3 184.62,24.4 184.76,24.4 184.86,24.31 184.86,22.46 184.95,22.36 185.09,22.36 185.19,22.46 v1(185.19,24.67)
DDR4_DIMM_CH3_DQ7: length 91.4
  L05_SIG2 w0.081: v1(184.34,18.8) 183.06,20.08 180.6,20.08 180.5,20.17 180.5,21.35 180.4,21.44 180.26,21.44 180.16,21.35 180.16,20.17 180.06,20.08 179.59,20.08 177.11,22.56 177.11,25.05 174.97,27.19 169.28,29.54 166.69,30.06 164.47,30.28 154.46,30.28 152.53,30.66 150.7,30.66 150.37,30.8 149.41,30.8 149.3,30.75 146.69,30.75 146.21,31.23 145.17,31.23 144.05,31.7 143.6,32.14 143.42,32.22 142.94,32.7 142.39,33.06 140.81,33.72 140.46,33.79 138.06,34.03 133.94,34.03 131.63,34.98 130.56,34.98 130.13,35.16 128.98,35.77 128.76,35.83 128.24,35.89 126.62,35.89 122.06,36.8 121.77,36.83 118.57,36.99 118.14,37.07 117.7,37.25 116.53,38.03 116.03,38.24 115.12,38.85 114.82,38.97 114.47,39.32 114.36,39.64 113.76,40.38 113.28,40.85 113.03,40.96 112.57,41.42 112.3,41.42 111.91,41.8 111.91,42.5 111.66,42.75 111.52,42.8 111.24,42.8 110.8,43.24 110.63,43.31 110.36,43.31 109.83,43.85 109.64,43.85 109.52,43.97 109.52,44.09 109.25,44.36 109.25,45.08 109.11,45.21 109.11,45.66 109.23,45.78 109.23,46.09 109.12,46.2 109.12,46.67 109.28,46.83 109.28,46.99 v1(109.72,47.43)
DDR4_DIMM_CH3_DQ8: length 92.7
  L07_SIG3 w0.089: v1(113.18,49.43) 113.3,49.55 114.3,49.55 114.56,49.81 116.92,49.81 117.19,49.55 117.78,49.55 117.89,49.66 119.81,49.66 119.95,49.81 120.53,49.81 120.8,49.55 123.02,49.55 123.29,49.81 123.89,49.81 124.16,49.54 124.62,49.54 125.11,49.05 125.61,49.05 125.87,49.3 126.45,49.3 126.9,48.85 127.3,48.85 127.7,48.46 127.96,48.46 128.47,47.94 128.92,47.94 129.44,47.42 129.8,47.42 130.28,46.94 130.67,46.94 131.14,46.47 131.55,46.47 132.11,45.91 132.46,45.91 132.9,45.48 133.28,45.48 133.77,44.99 134.09,44.99 134.65,44.43 134.95,44.43 135.42,44.89 135.89,44.89 136.48,44.31 136.84,44.31 137.24,43.91 137.71,43.91 138.16,43.46 138.41,43.46 138.94,42.94 139.19,42.94 139.57,42.55 139.57,41.86 139.9,41.52 140.26,41.52 140.54,41.8 141.22,41.8 141.53,41.49 145.4,41.49 148.08,44.17 152.67,44.17 155.76,41.08 155.76,39.49 156.37,38.87 163.48,38.87 164.74,37.61 165.31,37.61 166.1,36.82 166.1,36.54 169.77,32.87 175.22,32.87 175.42,32.67 175.42,32.1 180.53,27 180.53,24.56 180.84,24.25 180.84,21.09 180.74,20.99 180.38,20.99 180.28,21.09 180.28,24.03 180.09,24.21 v1(180.09,24.8)
DDR4_DIMM_CH3_DQ9: length 94.2
  L07_SIG3 w0.089: v1(179.24,18.8) 179.68,19.23 179.68,19.75 179.58,19.85 178.59,19.85 178.49,19.95 178.49,20.09 178.59,20.19 179.58,20.19 179.68,20.28 179.68,20.42 179.58,20.52 178.47,20.52 178.37,20.62 178.37,20.76 178.47,20.86 179.58,20.86 179.68,20.95 179.68,21.09 179.58,21.19 179.02,21.19 178.92,21.29 178.92,21.43 179.02,21.53 179.58,21.53 179.68,21.62 179.68,26.83 174.7,31.81 170.26,31.81 165.63,36.44 165.63,36.77 165.24,37.15 164.56,37.15 163.83,37.89 155.55,37.89 155.33,38.11 155.33,41.01 152.52,43.82 148.29,43.82 145.52,41.05 140.07,41.05 139.16,41.96 138.99,41.96 138.49,42.46 138.04,42.46 137.55,42.95 137.31,42.95 136.84,43.42 136.33,43.42 135.89,43.86 135.45,43.86 135.06,43.48 134.57,43.48 134.1,43.95 133.69,43.95 133.11,44.53 132.77,44.53 132.27,45.02 131.92,45.02 131.54,45.41 131.2,45.41 130.65,45.96 130.35,45.96 129.84,46.47 129.38,46.47 128.8,47.05 128.51,47.05 128.06,47.5 127.72,47.5 127.28,47.94 126.86,47.94 126.49,48.31 125.97,48.31 125.47,48.81 125.02,48.81 124.73,48.52 124.3,48.52 123.81,49.01 121.56,49.01 121.27,49.31 120.72,49.31 120.36,48.95 119.77,48.95 119.41,49.31 117.23,49.31 116.85,48.93 v1(114.05,48.93)
DDR4_DIMM_CH3_DQ10: length 92.9
  L07_SIG3 w0.089: v1(174.14,24.8) 173.74,24.39 171.76,24.39 171.66,24.3 171.66,24.01 171.76,23.91 173.64,23.91 173.74,23.81 173.74,23.54 173.64,23.44 171.15,23.44 169.41,25.18 167.51,25.18 159.27,33.42 154.65,33.42 154.2,32.97 147.61,32.97 147.01,33.58 145.81,33.58 144.38,35 138.65,35 135.73,37.93 131.86,37.93 129.89,39.9 128.52,39.9 127.45,40.96 126.45,40.96 125.47,41.94 125.08,41.94 124.57,42.46 124.26,42.46 123.8,42.91 123.42,42.91 122.96,42.46 122.44,42.46 121.97,42.92 121.66,42.92 121.19,42.46 120.76,42.46 120.3,42.92 119.93,42.92 119.47,42.46 119.04,42.46 118.6,42.9 118.19,42.9 117.72,42.43 117.33,42.43 116.85,42.92 116.45,42.92 115.99,42.46 115.57,42.46 115.09,42.93 114.71,42.93 114.44,43.21 114.44,44.07 114.21,44.3 113.84,44.3 113.34,44.8 112.98,44.8 112.6,44.42 112.15,44.42 111.76,44.82 111.23,44.82 110.91,44.49 110.46,44.49 110.06,44.89 109.62,44.89 109.23,45.29 109.23,46.08 108.88,46.43 108.71,46.43 108.4,46.74 108.4,49.21 108.69,49.5 108.96,49.5 109.51,50.05 109.87,50.05 110.37,50.55 110.74,50.55 111.24,51.05 111.76,51.05 112.02,51.31 112.47,51.31 112.83,50.95 112.83,50.78 v1(113.18,50.43)
DDR4_DIMM_CH3_DQ11: length 95.1
  L07_SIG3 w0.089: v1(114.05,49.93) 112.97,49.93 112.45,50.45 112.02,50.45 111.66,50.8 111.29,50.8 110.79,50.3 110.43,50.3 109.92,49.8 109.56,49.8 109.3,49.54 109.3,46.31 109.64,45.97 110,45.97 110.52,45.45 110.78,45.45 111.19,45.05 111.71,45.05 111.97,45.31 112.71,45.31 112.97,45.05 113.39,45.05 113.89,44.55 114.26,44.55 114.84,43.97 115.06,43.97 115.57,43.46 116,43.46 116.43,43.9 116.84,43.9 117.33,43.4 117.65,43.4 118.11,43.87 118.59,43.87 119.04,43.42 119.46,43.42 119.92,43.88 120.31,43.88 120.72,43.47 121.19,43.47 121.61,43.89 122.07,43.89 122.5,43.46 122.96,43.46 123.4,43.89 123.78,43.89 124.23,43.44 124.6,43.44 125.15,42.9 125.47,42.9 125.93,42.44 126.33,42.44 126.85,41.92 127.27,41.92 128.76,40.42 130.31,40.42 131.87,38.86 135.79,38.86 136.07,38.58 136.07,38.09 138.3,35.87 144.19,35.87 145.93,34.12 147.02,34.12 147.81,33.33 153.93,33.33 154.4,33.8 159.39,33.8 167.66,25.53 173.96,25.53 174.54,24.95 174.54,21.47 174.44,21.38 173.99,21.38 173.89,21.28 173.89,21.14 173.99,21.04 174.44,21.04 174.54,20.94 174.54,20.8 174.44,20.7 173.67,20.7 173.57,20.61 173.57,20.47 173.67,20.37 174.44,20.37 174.54,20.27 174.54,20.04 v1(173.29,18.8)
DDR4_DIMM_CH3_DQ12: length 89.2
  L07_SIG3 w0.089: v1(109.72,50.43) 109.72,50.84 110.3,51.42 110.77,51.42 111.16,51.81 111.86,51.81 112.13,51.54 112.53,51.54 113.02,51.05 113.39,51.05 113.92,50.52 114.31,50.52 114.61,50.82 115.1,50.82 115.6,50.32 117.76,50.32 118.03,50.05 120.29,50.05 120.58,50.35 123,50.35 123.31,50.04 123.78,50.04 124.1,50.36 124.75,50.36 125.16,49.95 125.54,49.95 125.96,49.53 126.44,49.53 126.77,49.86 127.19,49.86 127.69,49.37 128.11,49.37 128.62,48.87 129,48.87 129.39,48.48 129.71,48.48 130.28,47.91 130.71,47.91 131.2,47.43 131.52,47.43 131.96,46.99 132.33,46.99 132.89,46.43 133.18,46.43 133.67,45.93 134.12,45.93 134.62,45.43 134.96,45.43 135.36,45.83 135.99,45.83 136.49,45.33 136.82,45.33 137.25,44.9 137.62,44.9 138.09,44.43 138.6,44.43 139.07,43.97 139.2,43.97 139.61,43.55 139.61,42.82 139.99,42.43 140.31,42.43 140.69,42.05 141.1,42.05 141.44,42.39 141.99,42.39 142.35,42.03 145.4,42.03 147.89,44.52 152.92,44.52 156.22,41.21 156.22,40.22 156.51,39.93 156.85,39.93 157.51,39.27 165.16,39.27 168.23,36.2 175.74,33.09 179.77,29.06 181.14,27 181.35,26.5 181.35,25.24 v1(181.79,24.8)
DDR4_DIMM_CH3_DQ13: length 90.7
  L07_SIG3 w0.089: v1(180.94,18.8) 180.46,18.32 176.52,18.32 176.24,18.6 176.24,22.68 176.14,22.78 175.66,22.78 175.56,22.88 175.56,23.02 175.66,23.11 176.14,23.11 176.24,23.21 176.24,23.35 176.14,23.45 175.81,23.45 175.71,23.55 175.71,23.69 175.81,23.78 176.14,23.78 176.24,23.88 176.24,25.07 175.38,25.94 175.38,26.57 174.68,27.27 170.78,27.27 168.95,29.1 167.54,29.1 161.7,34.94 153.88,34.94 153.31,34.37 148.45,34.37 145.79,37.03 143.34,37.03 142.31,38.05 140.74,38.05 140.58,38.21 138.48,38.21 136.16,40.54 133.84,40.54 132.42,41.96 132.01,41.96 131.52,42.44 131.22,42.44 130.65,43.01 130.27,43.01 129.8,43.48 129.45,43.48 128.98,43.95 128.52,43.95 128.01,44.46 127.7,44.46 127.22,44.95 126.86,44.95 126.36,45.45 126.04,45.45 125.61,45.87 125.07,45.87 124.63,46.31 122.29,46.31 122.03,46.05 121.58,46.05 121.33,46.3 118.88,46.3 118.63,46.05 118.09,46.05 117.82,46.31 115.42,46.31 115.16,46.05 114.54,46.05 114.19,46.41 113.99,46.41 113.56,46.84 113.17,46.84 112.59,47.41 112.17,47.41 111.66,47.93 111.2,47.93 110.58,48.55 v1(110.58,48.93)
DDR4_DIMM_CH3_DQ14: length 90.7
  L07_SIG3 w0.089: v1(175.84,24.8) 175.84,24.98 174.56,26.26 174.56,26.56 174.26,26.86 170.62,26.86 169.58,27.9 167.63,27.9 167.54,28 167.54,28.13 167.63,28.23 168.96,28.23 169.06,28.33 169.06,28.47 168.96,28.57 167.54,28.57 166.62,29.48 166.48,29.48 166.39,29.38 166.39,29.24 167.19,28.44 167.19,28.3 167.09,28.2 166.95,28.2 165.91,29.24 165.91,29.38 166.25,29.72 166.25,29.86 165.06,31.05 164.92,31.05 164.82,30.95 164.82,30.81 165.56,30.07 165.56,29.93 165.46,29.83 165.32,29.83 164.35,30.81 164.35,30.95 164.68,31.28 164.68,31.42 161.57,34.53 154.04,34.53 153.53,34.02 148.26,34.02 145.67,36.61 143.02,36.61 142.56,37.07 140.54,37.07 139.8,37.82 137.99,37.82 136.76,39.04 136.76,39.42 136.01,40.17 132.35,40.17 130.52,42 130.2,42 129.77,42.43 129.41,42.43 128.84,43 128.5,43 128.02,43.48 127.76,43.48 127.25,43.99 126.79,43.99 126.32,44.46 125.95,44.46 125.43,44.98 125.06,44.98 124.58,45.46 124.23,45.46 123.77,45.91 123.39,45.91 122.93,45.46 122.4,45.46 122.06,45.8 121.5,45.8 121.16,45.46 120.72,45.46 120.35,45.83 119.81,45.83 119.44,45.46 119.01,45.46 118.67,45.8 118.06,45.8 117.69,45.43 117.3,45.43 116.82,45.92 116.42,45.92 115.96,45.46 115.54,45.46 115.19,45.8 114.62,45.8 114.37,45.55 113.89,45.55 113.39,46.05 112.86,46.05 112.58,46.32 112.09,46.32 111.6,46.81 111.42,46.81 110.72,47.51 110.46,47.51 110.2,47.77 110.2,48.08 110.32,48.19 110.32,48.66 110.2,48.78 110.2,49.55 v1(110.58,49.93)
DDR4_DIMM_CH3_DQ15: length 89.2
  L07_SIG3 w0.089: v1(109.72,49.43) 109.72,48.96 110.09,48.59 110.09,48.27 109.99,48.17 109.99,47.69 110.09,47.58 110.09,46.72 110.34,46.48 110.71,46.48 111.26,45.93 111.61,45.93 112,45.54 112.71,45.54 112.97,45.81 113.34,45.81 113.84,45.3 114.31,45.3 114.68,44.93 115.06,44.93 115.54,44.46 115.96,44.46 116.42,44.92 116.82,44.92 117.3,44.43 117.69,44.43 118.16,44.9 118.57,44.9 119.01,44.46 119.44,44.46 119.89,44.92 120.27,44.92 120.72,44.46 121.16,44.46 121.62,44.92 121.94,44.92 122.4,44.46 122.93,44.46 123.39,44.91 123.77,44.91 124.23,44.46 124.55,44.46 125.07,43.94 125.43,43.94 125.9,43.47 126.25,43.47 126.79,42.93 127.19,42.93 127.72,42.39 128.17,42.39 128.61,41.95 128.87,41.95 129.99,40.83 130.41,40.83 131.43,39.81 135.86,39.81 136.42,39.25 136.42,38.26 137.95,36.73 142.27,36.73 142.77,36.23 144.45,36.23 145.69,34.98 146.71,34.98 148.02,33.68 153.71,33.68 154.2,34.17 160.32,34.17 167.63,26.86 168.43,26.86 169.37,25.92 174.4,25.92 175.39,24.93 175.39,24.62 174.99,24.21 174.99,22.33 175.09,22.23 175.65,22.23 175.75,22.14 175.75,22 175.65,21.9 175.09,21.9 174.99,21.8 174.99,21.66 175.09,21.56 175.65,21.56 175.75,21.47 175.75,21.33 175.65,21.23 175.09,21.23 174.99,21.13 v1(174.99,18.8)
DDR4_DIMM_CH3_DQ16: length 93.5
  L05_SIG2 w0.081: v1(170.74,24.8) 170.74,25.82 170.32,26.23 170.32,26.56 169.68,27.2 168.61,27.64 166.23,28.12 164.39,28.3 147.31,28.3 146.82,28.79 145.55,28.79 145.08,29.26 143.07,29.26 142.32,30 139.16,30 138.21,30.95 135.06,30.95 134.96,31.05 134.96,31.31 134.86,31.41 134.72,31.41 134.63,31.31 134.63,31.05 134.53,30.95 133.82,30.95 133.72,31.05 133.72,31.5 133.62,31.6 133.48,31.6 133.38,31.5 133.38,31.05 133.29,30.95 133.15,30.95 133.05,31.05 133.05,31.5 132.95,31.6 132.81,31.6 132.71,31.5 132.71,31.05 132.61,30.95 132.48,30.95 132.38,31.05 132.38,31.5 132.28,31.6 132.14,31.6 132.04,31.5 132.04,31.05 131.94,30.95 131.21,30.95 130.26,31.91 127.13,31.91 126.03,33.01 123.34,33.01 123.24,33.11 123.24,33.42 123.14,33.52 123.01,33.52 122.91,33.42 122.91,33.07 122.8,32.97 122.67,32.97 122.57,33.07 122.57,33.44 122.47,33.55 122.34,33.55 122.24,33.44 122.24,32.97 122.09,32.83 121.49,32.83 121.24,33.08 121.24,33.54 121.13,33.64 120.88,33.64 120.78,33.54 120.78,32.76 120.68,32.66 120.54,32.66 120.44,32.76 120.44,33.58 120.35,33.68 120.21,33.68 120.11,33.58 120.11,32.76 120.01,32.66 119.87,32.66 119.77,32.76 119.77,33.58 119.68,33.68 118.75,33.68 118.66,33.58 118.66,32.78 118.56,32.68 118.42,32.68 118.32,32.78 118.32,33.58 118.22,33.68 118.08,33.68 117.98,33.58 117.98,32.78 117.89,32.68 117.75,32.68 117.65,32.78 117.65,33.58 117.55,33.68 116.39,33.68 115.05,35.02 114.49,35.02 113.55,35.96 113.04,35.96 112.62,36.37 112.62,36.87 111.54,37.95 111.26,37.95 110.31,38.9 109.62,38.9 108.56,39.95 107.89,39.95 107.54,40.3 107.54,40.86 106.69,41.71 106.69,42.52 106.48,42.72 106.48,43.13 106.63,43.27 106.63,43.58 106.48,43.72 106.48,44.13 106.63,44.27 106.63,44.58 106.48,44.72 106.48,45.13 106.63,45.28 106.63,45.58 106.48,45.72 106.48,46.13 106.63,46.27 106.63,46.58 106.48,46.72 106.48,47.13 106.63,47.27 106.63,47.58 106.48,47.72 106.48,48.13 106.81,48.46 106.81,48.62 v1(107.12,48.93)
DDR4_DIMM_CH3_DQ17: length 93.6
  L05_SIG2 w0.081: v1(169.89,18.8) 169.89,20.85 169.99,20.95 170.18,20.95 170.28,20.85 170.28,19.55 170.38,19.45 170.58,19.45 170.68,19.55 170.68,20.89 170.78,20.99 170.97,20.99 171.07,20.89 171.07,19.98 171.17,19.87 171.35,19.87 171.45,19.98 171.45,24.23 171.16,24.53 171.16,26.54 170.44,27.26 168.68,27.99 166.33,28.45 164.49,28.64 147.48,28.64 146.99,29.12 145.69,29.12 145.22,29.59 143.21,29.59 142.21,30.59 140.19,30.59 139.75,31.02 139.08,31.02 138.5,31.61 137.44,31.61 137.22,31.82 136.49,31.82 136.28,31.61 135.51,31.61 135.12,32 130.67,32 130.39,32.28 130.39,32.57 130.12,32.84 128.23,32.84 127.31,33.22 124.95,33.69 120.88,34.09 116.83,34.09 115.18,35.74 114.36,36.29 113.51,36.64 111.82,38.33 111.82,38.58 111.6,38.8 110.95,38.8 109.84,39.9 109.11,39.9 108.15,40.87 107.86,40.87 107.53,41.2 107.53,42.04 107.27,42.3 107.2,42.3 106.74,42.76 106.74,43.1 106.83,43.19 106.83,43.67 106.74,43.76 106.74,44.1 106.83,44.19 106.83,44.67 106.74,44.76 106.74,45.1 106.83,45.19 106.83,45.67 106.74,45.76 106.74,46.1 106.83,46.19 106.83,46.67 106.74,46.76 106.74,47.1 106.83,47.19 106.83,47.67 106.74,47.76 106.74,48.1 107.01,48.36 107.23,48.36 107.36,48.5 107.36,48.63 107.53,48.79 107.53,49.08 107.3,49.3 107.3,49.75 v1(107.12,49.93)
DDR4_DIMM_CH3_DQ18: length 93.5
  L05_SIG2 w0.081: v1(107.99,50.43) 107.99,50.75 107.42,51.32 106.89,51.32 106.62,51.05 106.03,51.05 105.76,51.31 105.09,51.31 104.64,50.87 104.34,50.87 104.07,50.6 104.07,48.8 103.94,48.67 103.94,48.19 104.05,48.07 104.05,47.78 103.94,47.67 103.94,47.19 104.05,47.08 104.05,46.78 103.94,46.67 103.94,46.19 104.05,46.08 104.05,45.78 103.94,45.67 103.94,45.19 104.05,45.08 104.05,44.78 103.94,44.67 103.94,44.19 104.05,44.07 104.05,43.78 103.94,43.67 103.94,43.19 104.05,43.08 104.05,42.78 103.94,42.67 103.94,42.19 104.05,42.08 104.05,41.78 103.86,41.59 103.86,39.5 104.52,38.84 104.64,38.84 105.86,37.62 105.86,37.28 106.13,37 106.92,37 107.33,36.59 107.85,36.59 108.87,35.57 108.87,35.08 111.13,32.81 111.72,32.81 113.57,30.95 114.42,30.95 115.97,29.4 121.02,29.4 123.3,27.13 125.28,27.13 126.9,26.04 128.83,26.04 129.67,26.89 135.37,26.89 135.46,26.79 135.46,26.48 135.56,26.38 135.7,26.38 135.8,26.48 135.8,26.79 135.9,26.89 137.72,26.89 138.16,26.45 138.73,26.45 139.17,26.01 141.88,26.01 142.17,25.89 143.02,25.89 143.26,25.65 143.73,25.65 144.81,25.2 145.62,24.39 146.24,24.39 146.67,24.82 147.05,24.82 147.45,24.41 147.96,24.41 148.37,24.82 148.9,24.82 149.34,24.38 150.73,24.38 150.93,24.59 151.52,24.59 151.8,24.31 152.19,24.31 152.53,24.65 153.26,24.65 153.58,24.34 154.03,24.34 154.29,24.59 154.74,24.59 155.63,23.7 156.66,23.7 156.76,23.8 156.76,24.27 156.86,24.37 157,24.37 157.1,24.27 157.1,23.8 157.2,23.7 158.39,23.7 158.49,23.8 158.49,24.31 158.59,24.4 158.73,24.4 158.83,24.31 158.83,23.8 158.92,23.7 159.06,23.7 159.16,23.8 159.16,24.31 159.26,24.4 159.4,24.4 159.5,24.31 159.5,23.8 159.59,23.7 159.73,23.7 159.83,23.8 159.83,24.31 159.93,24.4 160.07,24.4 160.17,24.31 160.17,23.8 160.26,23.7 160.98,23.7 161.08,23.8 161.08,24.26 161.18,24.36 161.32,24.36 161.42,24.26 161.42,23.8 161.51,23.7 162.67,23.7 163.33,24.36 164.36,24.36 v1(164.79,24.79)
DDR4_DIMM_CH3_DQ19: length 93.4
  L05_SIG2 w0.081: v1(163.94,18.8) 164.62,18.44 166.73,18.02 171.42,18.02 172.05,18.65 172.05,26.51 171.89,26.75 171.15,27.36 168.83,28.32 166.48,28.79 164.59,28.97 148.39,28.97 147.22,29.46 145.82,29.46 145.36,29.93 143.35,29.93 142.35,30.92 141.7,30.92 139.9,31.67 139.66,31.67 139.39,31.94 138.48,31.94 137.86,32.2 136.36,32.2 136.1,31.94 135.65,31.94 135.22,32.37 132.77,32.37 131.56,32.61 130.54,33.03 130.23,33.34 129.57,33.66 119.75,34.62 117.49,34.62 116.43,35.06 115.55,35.94 114.31,36.86 111.71,39.22 110.23,40.7 109.8,40.99 108.89,41.36 108.42,41.83 108.42,42.52 108.08,42.86 107.94,42.86 107.5,43.3 107.5,44.09 107.4,44.19 107.4,44.67 107.5,44.78 107.5,45.09 107.4,45.18 107.4,45.67 107.5,45.77 107.5,46.09 107.4,46.19 107.4,46.67 107.49,46.76 107.49,47.09 107.4,47.18 107.4,47.69 107.49,47.78 107.59,48.02 107.59,48.47 107.66,48.64 107.78,48.75 v1(107.99,49.43)
DDR4_DIMM_CH3_DQ20: length 90.2
  L05_SIG2 w0.081: v1(104.52,50.43) 105.51,50.43 105.88,50.8 106.57,50.8 106.94,50.42 107.3,50.42 107.8,49.92 108.19,49.92 108.44,49.67 108.44,48.29 108.13,47.98 107.99,47.98 107.61,47.6 107.61,47.27 107.7,47.18 107.7,46.68 107.61,46.58 107.61,46.27 107.71,46.17 107.71,45.68 107.61,45.59 107.61,45.27 107.71,45.17 107.71,44.68 107.6,44.58 107.6,44.28 107.95,43.93 108.13,43.93 108.39,43.67 108.39,42.86 108.82,42.43 109.04,42.43 109.58,41.89 109.79,41.89 114.55,37.13 115.48,36.75 118.07,35.06 119.14,35.03 131.38,33.82 131.66,33.7 132.38,32.98 132.87,32.78 135.58,32.78 135.74,32.94 137.46,32.94 137.7,32.71 138.12,32.71 138.24,32.82 138.5,32.82 139.33,32.48 139.8,32 141.74,32 143.49,30.26 145.5,30.26 145.96,29.79 147.31,29.79 148.49,29.31 164.62,29.31 166.6,29.11 169.04,28.63 171.35,27.67 172.58,26.85 172.87,26.56 172.87,22.02 172.77,21.92 172.54,21.92 172.44,22.02 v1(172.44,24.8)
DDR4_DIMM_CH3_DQ21: length 90.8
  L05_SIG2 w0.081: v1(171.59,18.8) 171.17,18.38 167.12,18.38 166.93,18.57 166.93,24.89 166.65,25.17 146.29,25.17 144.2,25.98 143.4,25.98 143.16,26.22 142.32,26.22 140.35,27.04 138.38,27.04 137.16,27.55 135.6,27.86 131.79,27.86 130.51,27.6 129.16,27.04 127.01,27.04 125.99,27.46 123.44,27.46 121.06,29.84 116.09,29.84 113.2,32.73 112.4,32.73 110.48,34.65 109.91,34.65 109.26,35.3 109.26,35.69 107.98,36.97 107.5,36.97 106.57,37.91 106.08,37.91 105.04,38.94 105.04,39.44 104.27,40.21 104.27,40.96 104.15,41.08 104.15,41.58 104.28,41.71 104.28,42.14 104.15,42.27 104.15,42.58 104.28,42.72 104.28,43.14 104.15,43.27 104.15,43.58 104.28,43.71 104.28,44.14 104.15,44.27 104.15,44.58 104.28,44.71 104.28,45.14 104.15,45.27 104.15,45.58 104.28,45.72 104.28,46.14 104.15,46.27 104.15,46.58 104.28,46.71 104.28,47.14 104.15,47.27 104.15,47.58 104.28,47.71 104.28,48.14 104.15,48.27 104.15,48.58 104.28,48.71 104.28,49.19 v1(104.52,49.43)
DDR4_DIMM_CH3_DQ22: length 89.7
  L05_SIG2 w0.081: v1(166.49,24.79) 166.49,22.01 166.39,21.9 166.26,21.9 166.16,22.01 166.16,22.77 166.06,22.87 165.92,22.87 165.82,22.77 165.82,22.06 165.72,21.96 165.59,21.96 165.49,22.06 165.49,22.94 164.58,23.85 163.51,23.85 162.98,23.33 155.25,23.33 154.82,23.75 153.61,23.75 153.09,24.27 152.7,24.27 152.11,23.68 149.56,23.68 148.8,24.44 148.5,24.44 148.09,24.03 147.35,24.03 147.05,24.34 146.69,24.34 146.12,23.76 144.89,23.76 143.44,25.21 139.49,25.21 138.66,26.04 129.32,26.04 128.99,25.71 125.97,25.71 124.89,26.79 123.16,26.79 121.91,28.05 121.29,28.05 120.36,28.97 119.86,28.97 119.76,28.87 119.76,28.47 119.66,28.37 119.52,28.37 119.42,28.47 119.42,28.87 119.33,28.97 115.86,28.97 114.91,29.92 113.72,29.92 113,30.63 113,31.03 111.65,32.39 111.03,32.39 108.45,34.97 108.45,35.5 107.89,36.06 107.22,36.06 106.79,36.49 106.07,36.49 104.52,38.04 104.18,38.04 103.53,38.7 103.53,41.53 103.28,41.77 103.28,42.08 103.45,42.25 103.45,42.61 103.28,42.77 103.28,43.08 103.45,43.25 103.45,43.61 103.28,43.77 103.28,44.08 103.45,44.25 103.45,44.61 103.28,44.77 103.28,45.08 103.45,45.25 103.45,45.61 103.28,45.77 103.28,46.08 103.45,46.25 103.45,46.61 103.28,46.77 103.28,47.08 103.45,47.25 103.45,47.61 103.28,47.78 103.28,48.08 103.45,48.25 103.45,48.72 v1(103.66,48.93)
DDR4_DIMM_CH3_DQ23: length 89.9
  L05_SIG2 w0.081: v1(103.66,49.93) 103.17,49.44 103.17,48.26 103.08,48.17 103.08,47.69 103.17,47.59 103.17,47.26 103.08,47.17 103.08,46.69 103.17,46.59 103.17,46.26 103.08,46.17 103.08,45.69 103.17,45.59 103.17,45.26 103.08,45.17 103.08,44.69 103.17,44.59 103.17,44.26 103.08,44.17 103.08,43.69 103.17,43.59 103.17,43.26 103.08,43.17 103.08,42.69 103.17,42.59 103.17,42.26 103.08,42.17 103.08,41.69 103.19,41.57 103.19,38.54 103.95,37.78 103.95,37.43 104.34,37.03 104.94,37.03 105.9,36.07 106.66,36.07 113.27,29.46 114.61,29.46 116.09,27.98 116.72,27.98 116.82,28.08 116.82,28.46 116.92,28.56 117.06,28.56 117.16,28.46 117.16,28.08 117.25,27.98 117.39,27.98 117.49,28.08 117.49,28.46 117.59,28.56 117.73,28.56 117.83,28.46 117.83,28.08 117.92,27.98 118.06,27.98 118.16,28.08 118.16,28.46 118.26,28.56 118.4,28.56 118.5,28.46 118.5,28.08 118.59,27.98 120.35,27.98 121.32,27.01 122.46,27.01 123.02,26.46 124.58,26.46 125.83,25.21 138.84,25.21 139.75,24.3 141.39,24.3 141.49,24.39 141.49,24.69 141.59,24.79 141.73,24.79 141.83,24.69 141.83,24.39 141.93,24.3 143.78,24.3 144.89,23.19 154.82,23.19 155.09,22.92 163.71,22.92 164.88,21.76 164.88,20.57 164.98,20.47 165.19,20.47 165.29,20.57 165.29,21.29 165.39,21.39 165.54,21.39 165.64,21.29 v1(165.64,18.8)
DDR4_DIMM_CH3_DQ24: length 73.2
  L07_SIG3 w0.089: v1(113.18,41.43) 114.18,40.43 114.18,40.14 114.53,39.78 114.53,39.27 114.89,38.91 115.2,38.91 115.3,39.01 115.3,39.46 115.39,39.55 115.53,39.55 115.63,39.46 115.63,39.01 115.73,38.91 116.98,38.91 117.08,39.01 117.08,39.49 117.18,39.58 117.32,39.58 117.41,39.49 117.41,39.01 117.51,38.91 118.72,38.91 118.82,39.01 118.82,39.46 118.91,39.55 119.05,39.55 119.15,39.46 119.15,39.01 119.25,38.91 120.51,38.91 120.61,39.01 120.61,39.45 120.71,39.54 120.85,39.54 120.94,39.45 120.94,39.01 121.04,38.91 121.18,38.91 121.28,39.01 121.28,39.47 121.38,39.57 121.52,39.57 121.61,39.47 121.61,39.01 121.71,38.91 121.85,38.91 121.95,39.01 121.95,39.46 122.05,39.56 122.19,39.56 122.28,39.46 122.28,39.01 122.38,38.91 122.52,38.91 122.62,39.01 122.62,39.46 122.72,39.56 122.86,39.56 122.95,39.46 122.95,39.01 123.05,38.91 123.85,38.91 123.95,39.01 123.95,39.46 124.05,39.56 124.19,39.56 124.29,39.46 124.29,39.01 124.38,38.91 125.53,38.91 126.77,37.68 128.31,37.68 130.19,35.8 133.44,35.8 133.54,35.7 133.54,35.46 133.44,35.36 132.9,35.36 132.8,35.26 132.8,35 132.9,34.89 134.17,34.89 134.62,34.44 136.22,34.44 137.82,32.85 138.41,32.85 138.51,32.95 138.51,33.27 138.61,33.37 138.75,33.37 138.85,33.27 138.85,32.79 138.95,32.69 139.09,32.69 139.18,32.79 139.18,33.27 139.28,33.37 139.42,33.37 139.52,33.27 139.52,32.77 139.62,32.67 139.76,32.67 139.86,32.77 139.86,33.27 139.95,33.37 140.09,33.37 140.19,33.27 140.19,32.92 140.29,32.82 140.95,32.82 141.05,32.92 141.05,33.26 141.15,33.35 141.28,33.35 141.38,33.26 141.38,32.76 141.48,32.66 141.62,32.66 141.72,32.76 141.72,33.25 141.82,33.35 141.96,33.35 142.05,33.25 142.05,32.95 142.15,32.85 142.79,32.85 143.53,32.11 143.65,32.11 144.96,30.8 146.17,30.8 146.39,30.58 149.11,30.58 149.36,30.83 149.69,30.83 149.85,30.66 158.46,30.66 161.82,27.3 161.82,25.22 v1(161.39,24.8)
DDR4_DIMM_CH3_DQ25: length 73.4
  L07_SIG3 w0.089: v1(160.54,18.8) 159.59,18.8 159.49,18.9 159.49,19.13 159.59,19.23 160.78,19.23 160.87,19.32 160.87,19.82 160.97,19.92 161.16,19.92 161.27,19.82 161.27,19.38 161.37,19.28 161.5,19.28 161.6,19.38 161.6,20.87 161.7,20.97 161.83,20.97 161.94,20.87 161.94,19.38 162.04,19.28 162.17,19.28 162.27,19.38 162.27,23.47 161.81,23.93 161.81,24.42 162.28,24.89 162.28,25.79 162.67,26.18 162.67,27.06 158.73,31 150.08,31 149.89,31.19 149.2,31.19 148.95,30.94 146.54,30.94 146.28,31.2 145.06,31.2 143.5,32.77 143.37,32.77 142.42,33.72 137.7,33.72 136.52,34.9 135.16,34.9 133.91,36.15 130.39,36.15 128.5,38.05 126.89,38.05 126.62,38.32 126.62,38.73 125.41,39.94 114.87,39.94 114.53,40.28 114.53,40.6 113.64,41.49 113.64,41.97 v1(113.18,42.43)
DDR4_DIMM_CH3_DQ26: length 74.4
  L07_SIG3 w0.089: v1(155.44,24.8) 155.44,22.65 155.34,22.54 155.18,22.54 155.08,22.65 155.08,23.64 154.98,23.74 154.82,23.74 154.72,23.64 154.72,23.35 154.62,23.24 154.11,23.24 154.01,23.35 154.01,24.23 153.91,24.33 153.42,24.33 153.32,24.23 153.32,22.35 153.22,22.24 152.6,22.24 152.5,22.35 152.5,24.95 152.25,25.2 144.17,25.2 141.34,28.03 140.85,28.03 140.36,28.51 139.08,28.51 138.59,28.03 138.21,28.03 137.64,28.6 136.3,28.6 135.25,29.66 133.84,29.66 133.21,30.29 128.63,30.29 127.72,31.2 127.72,31.65 127.48,31.88 126.9,31.88 124.47,34.31 113.24,34.31 111.35,36.2 111.05,36.2 110.14,37.11 110.14,38.71 109.92,38.93 109.48,38.93 109.33,38.78 109.33,38.22 109.23,38.12 109.1,38.12 108.97,38.25 108.97,41.52 109.24,41.78 109.24,42.67 109.47,42.9 109.9,42.9 110.54,43.54 110.91,43.54 111.31,43.93 111.7,43.93 112.08,43.55 112.63,43.55 112.89,43.81 113.37,43.81 113.67,43.51 113.67,43.31 v1(114.05,42.93)
