# Allegro board TS28247BC0_FM61_agilex_PCIe_DEVKIT_ADI_REVB1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
1P2V_DDR4_CH23_AGND: length 10.7
  L03_SIG1 w0.508: v1(213.62,46.15) 210.17,46.15 209.48,46.84 207.12,46.84 206.41,46.13 v1(206.41,46.12)
  BOTTOM w0.203: v1(213.62,46.15) 213.6,46.18 ST14.1
  BOTTOM w0.381: v1(206.41,46.12) R6041.1 205.49,46.11 v1(205.49,45.04)
1P2V_DDR4_CH23_EN: length 83
  L16_SIG6 w0.127: v1(211.46,47.13) 211.93,47.6 213.34,47.6 214.89,46.05 217.15,46.05 218.47,44.73 218.47,34.29 216.54,32.36 213.7,32.36 211.11,29.77 211.11,21.39 210.12,20.4 210.12,19.54 211.16,18.49 213.65,18.49 215.98,16.16 243.88,16.16 245.8,18.08 245.8,22.76 246.62,23.57 v1(247.21,23.57)
1P2V_DDR4_CH23_PG: length 97.5
  L05_SIG2 w0.127: v1(219.84,17.66) 219.84,16.03 221.35,14.53 243.84,14.53 248.77,19.46 248.77,20.63 249.05,20.91 249.31,20.91 250.93,22.53 251.67,22.53 252.15,23.02 252.15,30.02 252.39,30.26 258.55,30.26 v1(258.95,30.66)
  L07_SIG3 w0.127: v1(201.68,39.96) 201.68,40.01 202.14,40.46 212.25,40.46 212.78,39.93 212.78,35.44 216.59,31.63 216.59,26.8 217.57,25.82 217.57,18.31 218.22,17.66 v1(219.84,17.66)
  BOTTOM w0.127: v1(201.68,39.96) 201.68,40.64 202.34,41.3 202.34,43.74 203.66,45.06 R6045.1
1P2V_PRE: length 4.7
  BOTTOM w0.254: v2(21.85,37.92) 21.85,37.16 21.6,36.91 19.05,36.91 18.95,37.01 C683.2 R680.2
  vias: v1(24.99,20.42) v1(26.03,20.42) v1(28.23,17.62) v2(20.28,39.18) v2(20.28,37.91) v2(21.85,43.77) v2(21.85,39.19)
1P2V_PRE_PG: length 2.7
  L03_SIG1 w0.127: v1(17.17,37.04) 17.17,38.49 v1(16.73,38.93)
  BOTTOM w0.149: U64.4 v1(16.73,38.93)
1P2V_UBII:
  vias: v1(25.47,17.62) v1(26.23,17.62) v1(30.03,20.42) v1(30.83,20.42)
1P2V_VCCR:
  vias: v1(73.44,60.91) v1(73.44,59.64) v1(73.44,58.37) v1(74.3,64.47) v1(74.3,63.58) v1(74.71,60.91) v1(74.71,59.64) v1(74.71,58.37) v1(75.98,60.91) v1(75.98,59.64) v1(75.98,57.1) v1(75.98,55.83) v1(84.8,68.43) v1(84.8,59.43) v1(84.8,54.88) v1(85.8,68.43) v1(85.77,59.43) v1(85.8,54.88) v1(86.8,68.43) v1(86.85,59.93) v1(87.93,68.43) v1(88.8,69.93) v1(109.72,68.43) v1(109.72,55.43) v1(111.45,68.43) v1(111.45,55.43) v1(113.18,68.43) v1(113.18,55.43) v1(120.98,69.93) v1(120.98,68.93) v1(120.98,54.93) v1(120.98,53.93) v3(76.36,62.26)
1P8V: length 141.3
  L05_SIG2 w0.203: v1(207.47,70.64) 206.66,71.46 191.15,71.46 190.61,70.92 188.86,70.92 188.06,71.71 169.01,71.71 168.87,71.86 161.96,71.86 161.07,70.97 161.07,70.01 161.32,69.75 161.32,63.99 156.95,59.62 155.66,59.62 153.5,57.46 144.46,57.46 144.18,57.74 144.18,58.04 143.85,58.37 143.54,58.37 143.03,58.88 142.45,58.88 141.94,58.37 141.59,58.37 141.08,57.86 140.7,57.86 140.32,57.48 139.86,57.48 139.48,57.86 138.97,57.86 138.59,57.48 138.11,57.48 137.6,56.97 137.14,56.97 136.74,57.38 136.48,57.38 136,57.86 135.52,57.86 135.14,57.48 134.53,57.48 134.14,57.86 133.76,57.86 133.38,57.48 132.93,57.48 132.54,57.86 132.04,57.86 131.66,57.48 131.2,57.48 130.82,57.86 130.31,57.86 129.93,57.48 129.45,57.48 129.06,57.86 128.58,57.86 128.2,57.48 127.72,57.48 127.34,57.86 126.85,57.86 126.47,57.48 125.99,57.48 125.61,57.86 125.13,57.86 124.75,57.48 124.26,57.48 123.88,57.86 123.37,57.86 122.99,57.48 122.08,57.48 121.57,56.97 121.57,56.9 121.17,56.49 120.91,56.49 120.41,55.99 120.41,55.73 v1(120.11,55.43)
  L07_SIG3 w0.508: 260.74,35.36 v1(260.74,34.56) 260.74,34.5 261.02,34.22
  L14_SIG5 w0.203: v1(120.11,68.43) 120.53,68.85 120.53,69.12 120.78,69.37 121.14,69.37 121.75,69.98 122.03,69.98 122.28,70.23 122.28,70.72 122.26,70.74 122.26,71.1 122.54,71.38 122.89,71.38 ; v1(226.72,57.47) 216.99,57.47 215.4,59.06 210.32,59.06 209.35,60.02 209.1,60.02 208.62,60.51 208.62,61.72 209.05,62.16 209.05,69.07 v1(207.47,70.64)
  BOTTOM w0.381: R5963.1 v1(226.72,57.47)
  vias: v1(114.91,68.43) v1(114.91,55.43) v1(116.65,68.43) v1(116.65,55.43) v1(118.38,68.43) v1(118.38,55.43) v1(130.5,52.43) v1(130.5,51.43) v1(135.7,83.43) v1(137.43,83.43) v1(142.62,85.43) v1(142.62,84.43) v1(142.62,83.43) v1(143.63,87.43) v1(143.63,86.43) v1(143.63,85.43) v1(143.63,84.43) v1(143.63,83.43) v1(144.63,87.43) v1(144.63,86.43) v1(144.63,83.43) v1(144.63,61.93) v1(148.63,79.43) v1(148.63,78.43) v1(148.63,77.43) v1(148.63,76.43) v1(148.63,75.43) v1(149.62,79.43) v1(149.62,78.43) v1(149.62,77.43) v1(149.62,76.43) v1(149.62,75.43) v1(149.62,69.93) v1(150.62,79.43) v1(150.62,78.43) v1(150.62,77.43) v1(150.62,76.43) v1(150.62,75.43) v1(223.27,47.96) v1(224.54,47.96) v1(225.81,47.96) v1(227.08,47.96) v1(233.43,47.96) v1(234.7,47.96) v1(235.97,47.96) v1(237.24,47.96) v2(215.4,46.94) v2(216.26,46.97) v2(216.62,44.43) v2(217.3,45.14) v2(217.61,46.92) v2(217.84,44.2) v2(218.47,46.94) v2(219.77,46.92) v2(220.66,46.89) v2(237.5,44.27) v2(239.68,44.27) v2(241.82,45.57) v2(241.87,44.27) v3(238.16,45.04)
1P8V_AGND: length 6.7
  TOP w0.191: v1(234.02,49.82) 234.02,51.12 v1(234,51.13)
  TOP w0.203: 232.85,53.65 v1(235.27,53.65) ; 231.53,49.66 231.53,48.72 231.66,48.59 v1(231.69,48.59)
  BOTTOM w0.203: v1(231.69,48.59) 231.6,48.5 ST19.1
  BOTTOM w0.305: v1(232.86,49.89) 232.93,49.82 v1(234.02,49.82)
  vias: v1(229.62,54.31) v1(229.62,53.04) v1(230.89,54.31) v1(230.89,53.04) v1(231.55,52.19) v1(232.84,51.13)
1P8V_EN: length 30.7
  L16_SIG6 w0.127: v1(249.56,36.46) 249.46,36.57 249.46,44.96 248.06,46.36 240.21,46.36 237.93,48.64 233.3,48.64 232.33,49.62 231.06,49.62 230.24,50.44 v1(230.24,51.15)
1P8V_PRE: length 4.7
  BOTTOM w0.254: v2(30.11,37.92) 30.11,37.16 29.85,36.91 27.3,36.91 27.2,37.01 C459.2 R445.2
  vias: v1(33.5,17.92) v1(34.11,17.29) v2(28.54,39.18) v2(28.54,37.91) v2(30.11,43.77) v2(30.11,39.19)
1P8V_PRE_PG: length 2.7
  L03_SIG1 w0.127: v1(24.99,38.93) 24.99,37.47 v1(25.42,37.04)
  BOTTOM w0.149: U45.4 v1(24.99,38.93)
1P8V_SI52202: length 3.2
  TOP w0.203: v1(210.97,101.44) 211.23,101.7 U18.19 ; U18.10 210.03,105.53 v1(209.81,105.74) ; U18.15 v1(209.28,102.44) ; U18.4 212.88,104.11 v1(212.99,104.22)
  BOTTOM w0.381: C322.1 212.92,104.16 v1(212.99,104.22)
  vias: v1(208.62,102.44)
1P8V_UBII:
  vias: v1(31,17.6) v1(31.63,20.42) v1(32.01,17.6) v1(32.43,20.42)
2P5V: length 196.2
  L03_SIG1 w0.254: 139.38,76.93 139.84,76.47 140.22,76.47 140.67,76.93 141.11,76.93 141.63,76.41 141.99,76.41 142.48,75.92 142.81,75.92 143.3,75.43 v1(143.63,75.43) 143.63,76.17 142.86,76.94 142.44,76.94 141.95,77.43 141.54,77.43 141.08,77.89 140.7,77.89 140.25,77.43 139.81,77.43 139.35,77.89 138.97,77.89 138.51,77.43 138.08,77.43 137.62,77.89 137.24,77.89 136.78,77.43 136.34,77.43 135.83,76.91 135.47,76.91 135.01,76.46 134.68,76.46 134.12,75.9 133.74,75.9 133.28,75.44 132.9,75.44 132.37,74.91 132,74.91 131.52,74.42 131.2,74.42 130.7,73.93 130.32,73.93 129.84,73.45 129.46,73.45 128.91,72.9 128.55,72.9 128.1,72.44 127.71,72.44 127.23,71.96 126.9,71.96 126.34,71.39 125.96,71.39 125.46,70.89 125.07,70.89 124.59,70.41 124.26,70.41 123.75,69.89 123.39,69.89 122.88,69.39 122.52,69.39 122.06,68.93 121.62,68.93 121.16,69.39 120.79,69.39 120.33,68.93 119.89,68.93 119.43,69.39 119.05,69.39 118.6,68.93 118.16,68.93 117.63,68.4 117.3,68.4 116.84,67.95 116.5,67.95 115.97,67.41 115.6,67.41 115.06,67.96 114.76,67.96 114.24,67.44 113.88,67.44 113.41,67.91 112.95,67.91 112.49,67.44 112.08,67.44 111.58,67.94 111.25,67.94 110.79,68.4 110.35,68.4 109.92,67.97 109.49,67.97 109.06,68.4 108.62,68.4 108.15,67.92 107.83,67.92 107.3,68.45 106.58,68.45 105.07,66.94 104.35,66.94 104.06,66.64 104.06,66.25 104.16,66.14 104.16,65.79 v1(104.52,65.43) 104.9,65.81 104.9,66.11 105.22,66.42 105.5,66.42 105.98,66.91 106.4,66.91 106.89,67.4 107.3,67.4 107.77,66.93 108.18,66.93 108.66,67.41 109.02,67.41 109.5,66.93 109.87,66.93 110.35,67.4 110.76,67.4 111.2,66.96 117.21,66.96 118.22,67.97 118.57,67.97 119.02,68.43 119.46,68.43 119.92,67.97 120.3,67.97 120.76,68.43 121.19,68.43 121.65,67.97 122.03,67.97 122.49,68.43 122.92,68.43 123.37,68.89 123.7,68.89 124.21,69.39 124.59,69.39 125.09,69.89 125.43,69.89 125.98,70.44 126.34,70.44 126.82,70.92 127.19,70.92 127.69,71.43 128.06,71.43 128.6,71.97 128.99,71.97 129.45,72.43 129.79,72.43 130.29,72.93 130.69,72.93 131.23,73.46 131.57,73.46 132.08,73.97 132.43,73.97 132.86,74.39 133.23,74.39 133.75,74.91 134.14,74.91 134.63,75.39 135.01,75.39 135.54,75.92 135.87,75.92 136.42,76.47 136.75,76.47 137.21,76.93 137.65,76.93 138.11,76.47 138.48,76.47 138.94,76.93 139.38,76.93
  BOTTOM w0.305: v1(116.34,17.97) 116.34,18.02 R71.2 ; v1(67.89,31.33) 69.48,31.33 R59.2 ; R23.2 v1(191.14,100.14) ; R5.2 191.7,91.44 191.99,91.73 v1(191.99,92.52) ; R6.2 191.21,96.15 v1(191.14,96.09)
  BOTTOM w0.381: v1(123.45,25.1) 122.82,25.73 R70.2 ; R73.2 67.94,23.76 v1(67.89,23.71) ; 140.85,105.87 140.85,102.5 R22.2 ; R65.1 v1(67.04,27.76) ; R56.2 117.69,28.51 117.69,27.76 R57.2 v1(116.34,25.61) ; R4.2 140.5,94.54 144.76,94.54 145.17,94.95 145.17,96.71 R3.2 145.04,97.98 145.04,99.27 143.52,100.79 143.52,104.05 144.83,105.36 ; R21.2 142.62,105.87 ; R79.1 v1(67.04,20.14) ; R14.1 v1(191.99,96.09) ; R30.1 192.6,103.52 192.18,103.52 v1(191.99,103.71)
  BOTTOM w0.508: v1(143.63,75.43) 143.99,75.8 143.99,77.77 145.8,79.58 145.8,86.95 149.18,90.33 152.92,90.33 155.34,92.75 183.54,92.75 v1(184.22,93.42)
  vias: v1(46.49,20.53) v1(47.25,20.53) v1(67.04,31.33) v1(67.04,23.71) v1(67.89,27.76) v1(67.89,20.14) v1(69.59,28.76) v1(69.59,27.76) v1(69.59,21.14) v1(69.59,20.14) v1(70.49,22.75) v1(74.06,29.44) v1(74.06,21.82) v1(74.69,30.44) v1(74.69,28.44) v1(74.69,22.82) v1(74.69,20.82) v1(124.98,107.72) v1(125.84,107.72) v1(131.33,107.72) v1(132.21,107.72) v1(151.52,21.1) v1(184.22,95.42) v1(184.34,103.04) v1(184.34,101.04) v1(184.85,94.42) v1(184.98,102.04) v1(189.44,103.71) v1(189.44,102.71) v1(189.44,96.09) v1(189.44,95.09) v1(191.14,103.71) v1(191.14,92.52) v1(191.99,100.14) v1(210.04,68.05) v1(210.04,66.78) v1(211.31,68.05) v1(211.31,66.78) v1(212.58,66.78) v2(207.45,68.58) v2(207.45,67.95) v2(207.37,66.32) v2(207.37,65.69) v3(208.74,65.64)
2P5V_AGND: length 2.4
  TOP w0.203: ST15.1 v1(213.85,70.59)
  TOP w0.305: C1976.1 213.25,71.19 v1(213.85,70.59) 214.07,70.59 R6059.1
  TOP w0.381: v1(215.81,66.33) 215.81,66.5 215.78,66.53 C1979.1
  vias: v1(213.88,64.79) v1(215.2,64.84)
2P5V_EN: length 73.5
  TOP w0.127: v1(216.95,68.71) 216.94,68.7 R6061.2
  L12_SIG4 w0.127: v1(239.15,62.18) 239.07,62.18 238.16,61.27 238.16,47.22 240.62,44.76 240.62,30.79 246.67,24.75 246.67,20.91 v1(247.17,20.4)
  L16_SIG6 w0.127: v1(216.95,68.71) 216.95,68.15 218.22,66.88 228.43,66.88 230.51,64.8 230.51,62.84 230.99,62.36 238.97,62.36 v1(239.15,62.18)
2P5V_PG: length 90.9
  L12_SIG4 w0.127: v1(255.75,25.06) 254.23,25.06 253.74,25.54 253.74,29.61 253.74,29.61 253.74,30.27 253.53,30.47 253.53,33.4 254.25,34.12 254.25,43.91 255.72,45.38 255.72,46.96 256,47.24 256,60.24 v1(256.42,60.66)
  L16_SIG6 w0.127: v1(212.58,68.05) 212.58,67.49 211.59,66.5 v1(211.59,65.95) 213.28,65.95 213.6,65.64 223.4,65.64 224.7,64.34 224.7,62.66 225.24,62.12 229.23,62.12 229.34,62 238.54,62 238.82,61.72 239.45,61.72 242.65,58.52 251.49,58.52 253.63,60.66 v1(256.42,60.66)
3P3V: length 19.3
  TOP w0.203: R6276.2 233.71,38.23 233.51,38.03 R6292.1
  TOP w0.381: v1(236.94,86.35) 236.42,86.35 236.24,86.17 v1(235.39,86.17) ; v1(60.26,54.49) 60.05,54.49 59.66,54.88 R6083.2 ; v2(209.05,17.99) 209.16,18.09 R654.1
  L07_SIG3 w0.508: v1(60.26,54.49) 60.08,54.49 59.93,54.63 59.36,54.63 58.91,54.18 58.91,53.67 57.01,51.77 v1(55.42,51.77)
  BOTTOM w0.254: U63.3 33.02,72.64 33.16,72.78
  BOTTOM w0.381: v1(73.47,69.65) 73.47,69.23 R6000.2 ; R788.2 208.83,49.24 v1(208.85,49.23) ; R6030.2 73.2,55.58 v1(73.44,55.83)
  vias: v1(31.06,68.91) v1(47.73,104.35) v1(61.22,57.23) v1(61.6,52.51) v1(61.63,51.64) v1(62.08,57.25) v1(63.31,70.92) v1(63.31,69.65) v1(63.28,57.1) v1(63.28,55.83) v1(63.35,64.54) v1(63.38,63.68) v1(65.01,71.53) v1(65.03,57.34) v1(65.85,70.92) v1(65.82,57.1) v1(67.12,70.92) v1(67.09,57.1) v1(68.39,70.92) v1(68.36,57.1) v1(70.93,70.92) v1(70.9,57.1) v1(72.2,72.19) v1(72.2,70.92) v1(72.2,69.65) v1(72.17,58.37) v1(72.17,57.1) v1(72.17,55.83) v1(72.4,39.14) v1(73.44,57.1) v1(73.47,70.92) v1(74.1,36.81) v1(195.52,55.81) v1(195.52,54.89) v1(198.15,54.9) v1(198.8,86.31) v1(202.71,83.24) v1(202.78,87.23) v1(203.51,59.39) v1(203.66,47.01) v1(204.48,32.34) v1(204.59,47.01) v1(205.09,58.79) v1(205.49,32.34) v1(206.51,32.34) v1(208.64,56.12) v1(210.56,47.13) v1(211.59,65.06) v1(212.45,51.48) v1(213.85,50.46) v1(214.36,50.46) v1(215.86,71.29) v1(217.02,19.89) v1(217.18,20.91) v1(217.49,76.3) v1(217.63,75.45) v1(219.01,73.24) v1(220.25,73.24) v1(220.31,69.3) v1(220.69,41.79) v1(220.69,40.64) v1(222.82,69.33) v1(227.74,50.08) v1(229.04,52.57) v1(229,49.87) v1(229.1,48.59) v1(230.27,49.85) v1(233.78,52.4) v1(239.85,66.88) v1(239.85,64.21) v1(239.85,63.32) v1(247.22,65.19) v1(248.26,67.47) v1(248.67,67.06) v1(249,65.23) v1(249.31,63.19) v2(36.71,71.71) v2(36.71,70.94) v2(37.73,71.71) v2(37.73,70.94) v2(38.74,71.71) v2(38.74,70.94) v2(40.52,73.21) v2(40.52,72.52) v2(40.52,71.83) v2(41.71,73.21) v2(41.71,72.52) v2(41.71,71.83) v2(49.28,107.52) v2(49.92,106.38) v2(209.94,17.35) v2(210.32,18.49) v2(227.9,43.28) v2(227.9,42.27) v2(227.9,41.25) v2(227.9,40.24) v2(228.91,43.28) v2(228.91,42.27) v2(228.91,41.25) v2(228.91,40.24) v2(229.93,43.28) v2(229.93,42.27) v2(229.93,41.25) v2(229.93,40.24) v2(230.94,43.28) v2(230.94,42.27) v2(230.94,41.25) v2(230.94,40.24) v2(231.96,43.28) v2(231.96,42.27) v2(231.96,41.25) v2(231.96,40.24) v2(232.98,43.28) v2(232.98,42.27) v2(232.98,41.25) v2(232.98,40.24) v2(233.99,43.28) v2(233.99,42.27) v2(233.99,41.25) v2(233.99,40.24) v2(236.1,44.02) v2(236.1,42.88) v2(238.01,42.75) v2(240.04,42.75) v2(242.07,42.75) v2(243.34,41.99) v2(243.47,43.77) v2(243.85,42.75) v2(244.03,40.08) v2(244.1,38.18) v2(244.48,43.77) v2(244.61,41.99) v3(223.78,44.27)
3P3V_AGND: length 1.7
  TOP w0.191: 233.51,17.3 ST32.1 233.51,18.37 233.43,18.44
  TOP w0.203: ST32.1 233.03,17.94
  vias: v1(228.45,18.06) v1(232.85,19.22)
3P3V_EN: length 21.5
  TOP w0.127: U46.2 234.51,23.92 234.86,23.57 235.19,23.57 v1(235.47,23.29)
  L16_SIG6 w0.127: v1(247.53,34.56) 245.98,33.01 245.98,31.17 241.23,26.42 236.99,26.42 236.51,25.94 236.51,24.34 v1(235.47,23.29)
  BOTTOM w0.127: R6265.1 v1(235.47,23.29) R6267.2
3P3V_PG: length 42.5
  TOP w0.127: v1(231.83,20.11) 231.83,20.6 232.13,20.9 U46.26
  L12_SIG4 w0.127: v1(231.83,20.11) 232.34,20.61 234.58,20.61 238.63,16.56 244.62,16.56 246.44,18.38 257.05,18.38 260.23,21.55 260.23,27.38 259.95,27.66 259.54,27.66 258.95,28.26 v1(258.95,28.26)
3P3V_STBY: length 46.3
  TOP w0.254: U32.15 v1(74.04,88.47) ; U32.17 v1(73.04,88.47)
  TOP w0.381: v1(246.13,81.18) 244.15,81.18 243.7,80.73 243.7,79.65 245.04,78.31 R419.2 ; R444.2 C458.2 258.22,38.43 257.97,38.18 257.44,38.18
  L12_SIG4 w0.508: v1(246.13,81.18) 246.13,85.91 244.74,87.3 244.74,88.98 242.68,91.04 242.68,93.07 242.91,93.3 242.91,97.64 243.31,98.05 244.41,98.05 245.52,99.16 v1(246.36,99.16)
  BOTTOM w0.203: U29.14 32.95,44.46 33.22,44.72
  BOTTOM w0.305: 73.03,88.47 73.03,89.3 R399.2
  BOTTOM w0.381: R360.2 254.64,37.29 255.09,37.73 255.09,38.12 v2(254.9,38.31) ; R423.2 v1(259.85,55.39) ; R424.2 v1(257.37,55.39) ; C361.1 31.67,24.47 v1(31.63,24.42) ; v1(251.21,21.35) 251.21,22 R784.2 ; R334.2 29.15,30.17 v1(28.85,29.86) ; 33.22,44.72 v1(33.22,45.16) ; R312.2 v1(268.23,41.23) ; R400.2 v1(71.13,89.23)
  vias: v1(2.8,48.02) v1(2.8,46.12) v1(2.8,44.21) v1(2.8,42.31) v1(7.25,18.62) v1(7.25,17.73) v1(8.14,18.62) v1(8.14,17.73) v1(14.23,72.02) v1(14.23,68.98) v1(16.28,37.04) v1(23.82,30.18) v1(23.82,29.29) v1(24.77,30.18) v1(24.77,29.29) v1(26.03,28.42) v1(26.03,26.82) v1(26.03,24.42) v1(26.03,22.82) v1(26.35,14.98) v1(27.36,14.98) v1(28.43,24.42) v1(28.43,23.62) v1(28.43,22.82) v1(28.38,14.98) v1(29.23,26.82) v1(30.03,26.82) v1(30.18,15.03) v1(30.83,23.62) v1(31.2,15.03) v1(31.63,26.82) v1(31.63,22.82) v1(31.88,29.28) v1(32.21,15.03) v1(32.43,27.62) v1(32.43,23.62) v1(33.69,15.03) v1(34.7,15.03) v1(34.83,24.42) v1(34.83,23.62) v1(34.83,22.82) v1(35.72,15.03) v1(36.3,29.31) v1(37.19,30.2) v1(37.23,28.42) v1(37.23,26.82) v1(37.23,25.22) v1(38.43,26.02) v1(38.43,24.42) v1(40.14,47.45) v1(40.47,19.62) v1(224.82,106.98) v1(227.61,107.87) v1(230.15,107.87) v1(232.69,107.87) v1(248.09,32.72) v1(248.1,24.59) v1(250.95,28.26) v1(250.95,27.46) v1(250.95,26.66) v1(251.75,30.66) v1(252.55,30.66) v1(252.55,24.26) v1(253.35,27.46) v1(253.35,24.26) v1(254.15,30.66) v1(254.15,28.26) v1(254.15,26.66) v1(254.15,24.26) v1(254.95,27.46) v1(254.95,24.26) v1(257.35,28.26) v1(257.35,27.46) v1(257.35,26.66) v1(259.79,29.29) v1(259.79,26.24) v1(260.67,30.3) v1(260.67,28.27) v1(260.67,27.26) v1(260.67,23.19) v1(265.18,56.02) v1(265.18,51.96) v2(21.34,46.18) v2(21.34,45.16) v2(21.98,46.18) v2(21.98,45.16) v2(255.09,39.7) v2(255.28,41.1) v2(255.28,20.02) v2(255.85,39.7) v2(255.99,19.01) v2(256.61,39.7) v2(257.06,21.41) v2(257.31,39.83) v2(262.29,30.3)
3P3V_STBY_PG: length 0.7
  TOP w0.254: U44.4 v1(255.4,43)
3P3V_USBPHY: length 11.9
  TOP w0.254: U28.17 v1(19.06,24.32) ; U28.3 v1(12.11,22) ; v1(16.11,21.92) U28.11 ; U28.7 14.11,22.21 v1(13.85,21.95) ; U28.55 v1(9.66,23.82) ; U28.32 v1(16.11,31.27) ; U28.27 v1(19.06,29.32) ; U28.43 v1(9.79,29.82)
  TOP w0.381: R331.2 v1(17.15,19.51) ; U25.4 v1(21.01,29.03) C340.2
  BOTTOM w0.381: v1(13.85,21.95) 14.36,22.46 C353.1 ; C354.1 12.07,22.04 v1(12.11,22) ; C349.1 v1(16.11,31.27)
  vias: v1(8.14,21.03) v1(8.14,20.14) v1(8.64,30.21) v1(9.91,21.03) v1(9.91,20.14)
24M_XTALIN: length 3.6
  TOP w0.149: Y4.1 13.11,19.62 13.11,20.37 C342.1 13.11,20.84 U28.5
24M_XTALOUT: length 5.2
  TOP w0.149: Y4.3 12.41,18.25 12.61,18.44 12.61,20.38 C343.1 12.61,20.82 U28.4
ACTIVITY_LED: length 22.3
  L16_SIG6 w0.508: J8.13 6.01,83.03 6.01,87.44 9.99,91.42 12.44,91.42 14.55,93.54 14.55,95.16 v1(17.41,98.01)
AS_CLK: length 71.4
  TOP w0.149: U6.B2 v1(208.01,30.99)
  L07_SIG3 w0.089: v1(208.01,30.99) 208.01,31.37 207.55,31.83 205.24,31.83 204.41,31 203.4,31 202.95,30.56 202.95,30.28 199.8,27.13 196.73,27.13 194.29,29.57 187.56,29.57 185.6,31.52 185.6,32.83 185.05,33.39 185.05,34.03 183.6,35.47 183.6,37.06 182.7,37.96 181.58,37.96 181.21,38.33 181.21,39.78 177.27,43.72 168.59,43.72 167.83,44.47 167.83,44.68 167.61,44.9 167.4,44.9 160.84,51.46 156.59,51.46 v1(154.62,53.43)
  BOTTOM w0.149: R115.2 v1(208.01,30.99)
AS_CLK_R: length 19.3
  L07_SIG3 w0.089: v1(153.62,53.43) 152.45,52.25 147.33,52.25 146.02,50.94 145.38,50.94 144.15,49.71 144.15,49.3 143.73,48.88 142.52,48.88 142.11,48.47 141.51,48.47 140.97,47.93 140.74,47.93 140.29,47.48 139.94,47.48 139.58,47.12 139.58,45.37 v1(140.03,44.93)
AS_CS0_MSEL0: length 102.3
  TOP w0.149: U6.C2 v1(207.01,30.99)
  L07_SIG3 w0.089: v1(207.01,30.99) 207.01,29.56 204.25,26.8 203.23,26.8 201.99,25.56 193.76,25.56 191.5,27.82 186.98,27.82 183.09,31.7 183.09,33.04 182.69,33.44 182.69,34.59 180.18,37.1 179.34,37.1 178.52,37.92 177.27,37.92 176.63,38.57 176.21,38.57 175.93,38.85 175.93,39.26 175.53,39.66 168.96,39.66 165.09,43.53 163.57,43.53 161.35,45.75 160.41,45.75 159.48,46.67 159.32,46.67 158.37,45.72 158.21,45.72 158.1,45.83 158.1,45.99 159.52,47.41 159.52,47.57 159.41,47.69 159.25,47.69 157.83,46.27 157.67,46.27 157.56,46.38 157.56,46.54 158.51,47.49 158.51,47.65 158.15,48.01 155.48,48.01 154.53,48.96 149.52,48.96 148.94,48.38 146.15,48.38 143.66,45.9 142.33,45.9 141.86,45.43 v1(140.89,45.43)
  L14_SIG5 w0.081: v1(215.4,26.05) 210.94,30.51 207.49,30.51 v1(207.01,30.99)
  BOTTOM w0.149: v1(215.4,26.05) 215.4,26.3 215.41,26.31 SW1.1
AS_DATA0: length 95.2
  TOP w0.149: v1(206.01,30.99) 206.01,29.99 U6.D3
  L07_SIG3 w0.089: v1(206.01,30.99) 206.01,29.04 204.92,27.96 203.65,27.96 201.61,25.91 196.76,25.91 193.77,28.9 186.51,28.9 183.88,31.53 183.88,32.99 183.16,33.7 183.16,34.81 180.35,37.62 179.87,37.62 177.55,39.93 176.03,39.93 174.73,41.23 168.97,41.23 167.83,42.37 167.83,42.4 167.61,42.62 167.58,42.62 163.89,46.3 163.61,46.3 163.05,45.75 162.87,45.75 162.72,45.9 162.72,46.08 163.28,46.63 163.28,46.81 163.13,46.97 162.95,46.97 162.39,46.41 162.21,46.41 162.06,46.56 162.06,46.74 162.61,47.3 162.61,47.48 162.46,47.63 162.28,47.63 161.72,47.07 161.55,47.07 161.39,47.23 161.39,47.41 161.95,47.96 161.95,48.14 161.04,49.05 155.2,49.05 154.13,50.12 149.33,50.12 149.06,49.85 149.06,49.03 148.95,48.92 148.79,48.92 148.68,49.03 148.68,49.85 148.56,49.96 148.41,49.96 148.29,49.85 148.29,49.03 148.18,48.92 148.02,48.92 147.91,49.03 147.91,50.45 147.79,50.57 147.63,50.57 147.52,50.45 147.52,49.03 147.41,48.92 147.25,48.92 147.13,49.03 147.13,49.85 147.02,49.96 146.78,49.96 143.75,46.94 142.42,46.94 141.91,46.43 v1(140.89,46.43)
AS_DATA1: length 89
  TOP w0.149: v1(205.01,30.99) U6.D2
  L07_SIG3 w0.089: v1(205.01,30.99) 205.44,31.42 207.12,31.42 207.47,31.07 207.47,28.5 204.2,25.22 193.56,25.22 192.82,25.96 189.67,25.96 188.18,27.45 186.68,27.45 182.2,31.93 182.2,33.32 178.18,37.34 176.89,37.34 176.44,37.8 175.9,37.8 174.53,39.17 168.69,39.17 164.7,43.16 163.15,43.16 161.14,45.16 160.1,45.16 159.98,45.05 159.98,44.34 159.87,44.22 159.71,44.22 159.59,44.34 159.59,45.05 159.47,45.16 157.49,45.16 156.04,46.61 156.04,46.77 156.57,47.3 156.57,47.46 156.46,47.57 156.3,47.57 155.77,47.04 155.61,47.04 154.72,47.93 146.48,47.93 143.42,44.87 142.34,44.87 141.89,44.43 v1(140.89,44.43)
AS_DATA2: length 94.6
  TOP w0.149: v1(207.02,26.75) 207.02,27.98 U6.C4
  L07_SIG3 w0.089: v1(207.02,26.75) 207.02,27.41 208.49,28.88 208.49,31.43 207.07,32.84 205.29,32.84 204.99,32.54 204.99,32.21 204.35,31.58 201.56,31.58 201.43,31.45 201.43,30.69 201.3,30.56 201.09,30.56 200.96,30.69 200.96,31.45 200.43,31.98 196.93,31.98 194.85,29.9 188.75,29.9 186.49,32.16 186.49,32.67 185.44,33.72 185.44,34.23 184.92,34.75 184.92,36.43 184.39,36.96 184.21,36.96 183.52,37.65 183.52,38 175.9,45.62 167.32,45.62 161.04,51.89 160.43,51.89 159.42,52.91 156.22,52.91 155.2,53.93 152.45,53.93 152.14,53.62 152.14,53.15 151.57,52.59 146.08,52.59 145.13,51.63 145.13,51.24 143.76,49.87 142.39,49.87 141.89,49.37 141.55,49.37 141.08,48.9 140.78,48.9 140.39,48.52 140.39,48.29 v1(140.03,47.93)
AS_DATA3: length 93.8
  TOP w0.149: U6.D4 205.01,28.99 205.01,29.69 204.71,29.99 204.01,29.99 v1(203.51,30.49)
  L07_SIG3 w0.089: v1(140.03,46.93) 141.06,46.93 141.55,47.42 141.92,47.42 142.33,47.82 143.81,47.82 145.09,49.1 145.09,49.57 145.45,49.93 145.8,49.93 146.8,50.93 147.29,50.93 147.4,51.04 147.4,51.78 147.52,51.89 147.68,51.89 147.79,51.78 147.79,51.04 147.9,50.93 148.06,50.93 148.18,51.04 148.18,51.78 148.29,51.89 148.45,51.89 148.56,51.78 148.56,50.48 148.67,50.37 148.83,50.37 148.95,50.48 148.95,51.78 149.06,51.89 149.22,51.89 149.33,51.78 149.33,50.61 149.45,50.5 149.61,50.5 149.72,50.61 149.72,51.78 149.83,51.89 149.99,51.89 150.11,51.78 150.11,51.04 150.22,50.93 154.19,50.93 155.18,49.93 158.15,49.93 158.43,49.66 161.5,49.66 167.82,43.34 175.83,43.34 176.01,43.15 176.01,42.76 176.29,42.48 176.68,42.48 176.96,42.76 177.34,42.76 180.6,39.5 180.6,38 184.21,34.39 184.21,32.73 184.82,32.12 184.82,31.37 186.96,29.23 194.02,29.23 197.01,26.24 201.46,26.24 204.1,28.88 204.1,29.91 v1(203.51,30.49)
BUFFER_DIF0_N: length 5.2
  BOTTOM w0.102: U72.11 201.52,102.81 201.38,102.67 201.06,102.67 200.82,102.92 200.82,103.66 200.59,103.89 200.59,104.17 200.41,104.35 200.13,104.35 200.01,104.47 200.01,104.75 199.82,104.94 199.54,104.94 199.35,105.13 199.35,105.37 R798.2
BUFFER_DIF0_P: length 5.2
  BOTTOM w0.102: U72.10 201.53,102.31 201.4,102.45 200.97,102.45 200.59,102.82 200.59,103.57 199.12,105.04 199.12,105.45 R797.2
BUFFER_DIF1_N: length 2
  BOTTOM w0.102: R800.2 202.94,105.41 202.94,104.49 203.09,104.33 U72.14
BUFFER_DIF1_P: length 2
  BOTTOM w0.102: U72.13 202.59,104.34 202.71,104.46 202.71,105.41 R799.2
CH01_RUN: length 12.1
  L12_SIG4 w0.089: v1(207.14,86.44) 207.63,86.92 210.47,86.92 v1(210.95,86.44) v1(212.22,87.71)
  BOTTOM w0.149: R6033.1 203.68,87.68 R6032.1 203.68,86.78 v1(203.33,86.44) 203.59,86.44 203.69,86.54 204.12,86.54 204.59,87.01 R6034.2 206.57,87.01 v1(207.14,86.44)
CH23_RUN: length 17.5
  L07_SIG3 w0.089: v1(205.5,47.01) 204.96,46.46 204.96,44.3 v1(205.49,43.77)
  L12_SIG4 w0.089: v1(210.57,45.04) v1(209.3,43.77) 208.87,44.2 205.92,44.2 v1(205.49,43.77) 205.06,44.2 202.19,44.2 201.76,43.77 v1(201.68,43.77)
  BOTTOM w0.149: R6040.1 211.46,45.93 v1(210.57,45.04) 210.56,45.05 R6039.1 ; v1(205.5,47.01) C1966.2
CLK125_NDO_LED_MODE: length 2
  TOP w0.149: v1(23.98,85.69) 24.11,85.56 R154.2
  BOTTOM w0.149: v1(23.98,85.69) 24.24,85.95 U7.41
CLK_DDR4_CH0_N: length 126.3
  L03_SIG1 w0.079: v1(125.31,83.43) 125.31,83.71 125.2,83.81 125.09,83.81 125.01,83.74 124.93,83.54 124.93,83.33 125.04,83.08 125.04,82.78 124.93,82.53 124.93,82.32 125.04,82.07 125.04,81.79 124.93,81.54 124.93,81.3 125.04,81.04 125.04,80.77 124.93,80.49 124.93,80.37 125.04,80.1 125.04,79.78 124.93,79.52 124.93,79.35 125.05,79.07 125.05,78.8 124.93,78.53 124.93,78.34 125.05,78.06 125.05,77.82 124.93,77.54 124.93,77.33 125.04,77.08 125.04,76.78 124.93,76.53 124.93,76.32 125.04,76.07 125.04,75.79 124.93,75.54 124.93,75.3 125.04,75.04 125.04,74.77 124.93,74.49 124.93,74.37 125.04,74.1 125.04,73.78 124.93,73.52 124.93,73.35 125.05,73.07 125.05,72.8 124.95,72.56 124.7,72.31 124.39,72.31 arc(124.3,72.3) 124.23,72.24 123.97,71.97 arc(123.8,71.85) 123.61,71.81 123.52,71.81 arc(123.43,71.8) 123.36,71.74 123.1,71.47 arc(122.94,71.35) 122.74,71.31 122.66,71.31 arc(122.57,71.3) 122.49,71.24 122.24,70.97 arc(122.07,70.85) 121.88,70.81 121.79,70.81 arc(121.7,70.8) 121.63,70.74 121.37,70.47 arc(121.21,70.35) 121.01,70.31 120.92,70.31 arc(120.75,70.35) 120.6,70.46 120.34,70.73 arc(120.25,70.79) 120.14,70.81 120.06,70.81 arc(119.97,70.8) 119.9,70.74 119.64,70.47 arc(119.47,70.35) 119.28,70.31 119.19,70.31 arc(119.01,70.35) 118.86,70.46 118.6,70.73 arc(118.52,70.79) 118.41,70.81 118.33,70.81 arc(118.24,70.8) 118.16,70.74 117.91,70.47 arc(117.74,70.35) 117.55,70.31 117.46,70.31 arc(117.28,70.35) 117.13,70.46 116.87,70.73 arc(116.78,70.79) 116.68,70.81 116.59,70.81 arc(116.51,70.8) 116.43,70.74 116.17,70.47 arc(116.01,70.35) 115.81,70.31 115.73,70.31 arc(115.64,70.3) 115.57,70.24 115.31,69.97 arc(115.14,69.85) 114.95,69.81 114.86,69.81 arc(114.77,69.8) 114.7,69.74 114.44,69.47 arc(114.28,69.35) 114.08,69.31 114.01,69.31 arc(113.82,69.35) 113.65,69.47 113.39,69.74 arc(113.32,69.8) 113.23,69.81 113.13,69.81 arc(113.04,69.8) 112.97,69.74 112.71,69.47 arc(112.55,69.35) 112.35,69.31 112.28,69.31 arc(112.08,69.35) 111.92,69.47 111.66,69.74 arc(111.59,69.8) 111.5,69.81 111.4,69.81 arc(111.31,69.8) 111.24,69.74 110.98,69.47 arc(110.81,69.35) 110.62,69.31 110.55,69.31 arc(110.35,69.35) 110.19,69.47 109.93,69.74 arc(109.86,69.8) 109.77,69.81 109.67,69.81 arc(109.58,69.8) 109.5,69.74 109.25,69.47 arc(109.08,69.35) 108.89,69.31 108.82,69.31 arc(108.62,69.35) 108.46,69.47 108.2,69.74 arc(108.12,69.8) 108.03,69.81 107.93,69.81 arc(107.85,69.8) 107.77,69.74 107.51,69.47 arc(107.35,69.35) 107.15,69.31 107.07,69.31 arc(106.89,69.35) 106.74,69.46 106.48,69.73 arc(106.39,69.79) 106.29,69.81 106.2,69.81 arc(106.11,69.8) 106.04,69.74 105.78,69.47 arc(105.62,69.35) 105.42,69.31 105.34,69.31 arc(105.25,69.3) 105.17,69.24 104.92,68.97 arc(104.75,68.85) 104.56,68.81 104.47,68.81 arc(104.38,68.8) 104.31,68.74 104.05,68.47 arc(103.89,68.35) 103.69,68.31 103.6,68.31 arc(103.52,68.3) 103.44,68.24 103.18,67.97 103.18,67.97 arc(103.02,67.85) 102.82,67.81 102.74,67.81 arc(102.65,67.8) 102.58,67.74 102.32,67.47 102.32,67.47 arc(102.15,67.35) 101.96,67.31 101.87,67.31 arc(101.78,67.3) 101.71,67.24 101.45,66.97 arc(101.29,66.85) 101.09,66.81 101.01,66.81 arc(100.92,66.8) 100.84,66.74 100.59,66.47 arc(100.42,66.35) 100.23,66.31 100.11,66.31 99.98,66.26 99.88,66.15 99.82,66.03 99.7,65.9 99.48,65.81 99.25,65.81 99.12,65.76 99.01,65.65 98.95,65.5 98.95,65.35 99.07,65.05 99.07,64.81 98.95,64.52 98.95,64.33 99.06,64.08 99.06,63.78 98.95,63.53 98.95,63.34 99.08,63.04 99.08,62.8 98.95,62.51 98.95,62.3 99.06,62.04 99.06,61.77 98.95,61.49 98.95,61.37 99.08,61.06 99.08,60.82 98.95,60.52 98.95,60.35 99.07,60.07 99.07,59.8 98.95,59.53 98.95,59.34 99.08,59.03 99.08,58.81 98.95,58.51 98.95,58.33 99.06,58.08 99.06,57.78 98.95,57.53 98.95,57.34 99.08,57.05 99.08,56.81 98.95,56.52 98.95,56.3 99.06,56.04 99.06,55.77 98.95,55.49 98.95,55.37 99.07,55.07 99.07,54.81 98.95,54.52 98.95,54.35 99.07,54.07 99.07,53.8 98.95,53.53 98.95,53.34 99.07,53.05 99.07,52.8 98.95,52.51 98.95,52.33 99.06,52.08 99.06,51.78 98.96,51.54 98.83,51.4 98.61,51.31 98.41,51.31 arc(98.32,51.3) 98.25,51.24 97.99,50.97 arc(97.82,50.85) 97.63,50.81 97.54,50.81 arc(97.45,50.8) 97.38,50.74 97.12,50.47 arc(96.96,50.35) 96.76,50.31 96.68,50.31 arc(96.59,50.3) 96.51,50.24 96.26,49.97 arc(96.09,49.85) 95.9,49.81 95.81,49.81 arc(95.72,49.8) 95.65,49.74 95.39,49.47 arc(95.23,49.35) 95.03,49.31 94.94,49.31 arc(94.86,49.3) 94.78,49.24 94.52,48.97 arc(94.36,48.85) 94.16,48.81 94.08,48.81 arc(93.99,48.8) 93.92,48.74 93.66,48.47 arc(93.49,48.35) 93.3,48.31 93.21,48.31 arc(93.12,48.3) 93.05,48.24 92.79,47.97 arc(92.63,47.85) 92.43,47.81 92.35,47.81 arc(92.26,47.8) 92.18,47.74 91.93,47.47 arc(91.76,47.35) 91.57,47.31 91.48,47.31 arc(91.39,47.3) 91.32,47.24 91.06,46.97 arc(90.9,46.85) 90.7,46.81 90.61,46.81 arc(90.53,46.8) 90.45,46.74 90.19,46.47 arc(90.03,46.35) 89.83,46.31 88.28,46.31 85.71,43.74 80.95,43.74 77.48,40.27 77.48,35.2 71.13,28.85 71.13,27.64 68.73,25.24 60.29,25.24 58.07,23.02 58.07,22.84 57.87,22.64 57.69,22.64 57.49,22.44 56.95,22.44 56.83,22.32 56.55,22.32 56.42,22.44 56.05,22.44 55.95,22.34 v1(55.95,22.05)
  BOTTOM w0.102: v1(123.57,76.43) 123.83,76.81 124.08,77.05 124.19,77.32 124.19,77.53 124.06,77.86 124.06,78 124.19,78.31 124.19,78.54 124.05,78.87 124.05,78.99 124.19,79.31 124.19,79.54 124.06,79.85 124.06,80 124.18,80.31 124.18,80.55 124.06,80.86 124.06,81 124.18,81.31 124.18,81.55 124.06,81.86 124.06,82 124.14,82.2 124.69,82.75 124.69,83.71 124.79,83.81 124.9,83.81 125.29,83.43 v1(125.31,83.43)
CLK_DDR4_CH0_P: length 126
  L03_SIG1 w0.079: v1(125.31,84.43) 125,84.04 124.82,83.87 124.7,83.59 124.7,83.28 124.81,83.03 124.81,82.82 124.71,82.57 124.71,82.27 124.81,82.02 124.81,81.83 124.71,81.58 124.71,81.26 124.81,81 124.81,80.81 124.7,80.54 124.7,80.32 124.81,80.05 124.81,79.83 124.7,79.56 124.7,79.31 124.82,79.02 124.82,78.85 124.7,78.57 124.7,78.29 124.82,78.01 124.82,77.87 124.7,77.58 124.7,77.28 124.81,77.03 124.81,76.82 124.71,76.57 124.71,76.27 124.81,76.02 124.81,75.83 124.71,75.58 124.71,75.26 124.81,75 124.81,74.81 124.7,74.54 124.7,74.32 124.81,74.05 124.81,73.83 124.7,73.56 124.7,73.31 124.82,73.02 124.82,72.85 124.75,72.69 124.61,72.54 124.39,72.54 arc(124.21,72.51) 124.06,72.4 123.8,72.13 arc(123.71,72.06) 123.61,72.04 123.52,72.04 arc(123.34,72.01) 123.19,71.9 122.93,71.63 arc(122.85,71.56) 122.74,71.54 122.66,71.54 arc(122.48,71.51) 122.33,71.4 122.07,71.13 arc(121.98,71.06) 121.88,71.04 121.79,71.04 arc(121.61,71.01) 121.46,70.9 121.2,70.63 arc(121.12,70.56) 121.01,70.54 120.92,70.54 arc(120.84,70.56) 120.76,70.61 120.5,70.89 arc(120.34,71) 120.14,71.04 120.06,71.04 arc(119.88,71.01) 119.73,70.9 119.47,70.63 arc(119.38,70.56) 119.28,70.54 119.19,70.54 arc(119.1,70.56) 119.03,70.61 118.77,70.89 arc(118.61,71) 118.41,71.04 118.33,71.04 arc(118.15,71.01) 118,70.9 117.74,70.63 arc(117.65,70.56) 117.55,70.54 117.46,70.54 arc(117.37,70.56) 117.3,70.61 117.04,70.89 arc(116.88,71) 116.68,71.04 116.59,71.04 arc(116.42,71.01) 116.27,70.9 116.01,70.63 arc(115.92,70.56) 115.81,70.54 115.73,70.54 arc(115.55,70.51) 115.4,70.4 115.14,70.13 arc(115.05,70.06) 114.95,70.04 114.86,70.04 arc(114.68,70.01) 114.53,69.9 114.27,69.63 arc(114.19,69.56) 114.08,69.54 114.01,69.54 arc(113.91,69.56) 113.82,69.63 113.56,69.9 arc(113.41,70.01) 113.23,70.04 113.13,70.04 arc(112.95,70.01) 112.8,69.9 112.54,69.63 arc(112.45,69.56) 112.35,69.54 112.28,69.54 arc(112.17,69.56) 112.09,69.63 111.83,69.9 arc(111.68,70.01) 111.5,70.04 111.4,70.04 arc(111.22,70.01) 111.07,69.9 110.81,69.63 arc(110.72,69.56) 110.62,69.54 110.55,69.54 arc(110.44,69.56) 110.35,69.63 110.1,69.9 arc(109.95,70.01) 109.77,70.04 109.67,70.04 arc(109.49,70.01) 109.34,69.9 109.08,69.63 arc(108.99,69.56) 108.89,69.54 108.82,69.54 arc(108.71,69.56) 108.62,69.63 108.36,69.9 arc(108.21,70.01) 108.03,70.04 107.93,70.04 arc(107.76,70.01) 107.61,69.9 107.35,69.63 arc(107.26,69.56) 107.15,69.54 107.07,69.54 arc(106.98,69.56) 106.91,69.61 106.65,69.89 arc(106.48,70) 106.29,70.04 106.2,70.04 arc(106.02,70.01) 105.87,69.9 105.61,69.63 arc(105.53,69.56) 105.42,69.54 105.34,69.54 arc(105.16,69.51) 105.01,69.4 104.75,69.13 arc(104.66,69.06) 104.56,69.04 104.47,69.04 arc(104.29,69.01) 104.14,68.9 103.88,68.63 arc(103.79,68.56) 103.69,68.54 103.6,68.54 arc(103.43,68.51) 103.28,68.4 103.02,68.13 arc(102.93,68.06) 102.82,68.04 102.74,68.04 arc(102.56,68.01) 102.41,67.9 102.15,67.63 arc(102.06,67.56) 101.96,67.54 101.87,67.54 arc(101.69,67.51) 101.54,67.4 101.28,67.13 arc(101.2,67.06) 101.09,67.04 101.01,67.04 arc(100.83,67.01) 100.68,66.9 100.42,66.63 arc(100.33,66.56) 100.23,66.54 100.07,66.54 99.85,66.45 99.68,66.28 99.63,66.16 99.57,66.1 99.44,66.04 99.21,66.04 98.99,65.95 98.82,65.78 98.72,65.55 98.72,65.3 98.84,65.01 98.84,64.85 98.72,64.56 98.72,64.28 98.83,64.03 98.83,63.82 98.73,63.57 98.73,63.29 98.85,63 98.85,62.85 98.73,62.55 98.73,62.26 98.83,62 98.83,61.81 98.72,61.54 98.72,61.32 98.85,61.01 98.85,60.87 98.72,60.56 98.72,60.31 98.84,60.02 98.84,59.85 98.72,59.57 98.72,59.29 98.85,58.99 98.85,58.86 98.72,58.56 98.72,58.28 98.83,58.03 98.83,57.82 98.73,57.57 98.73,57.29 98.85,57 98.85,56.86 98.73,56.56 98.73,56.26 98.83,56 98.83,55.81 98.72,55.54 98.72,55.32 98.84,55.02 98.84,54.86 98.72,54.56 98.72,54.31 98.84,54.02 98.84,53.85 98.72,53.57 98.72,53.3 98.85,53.01 98.85,52.85 98.72,52.56 98.72,52.28 98.83,52.03 98.83,51.82 98.76,51.67 98.7,51.6 98.56,51.54 98.41,51.54 arc(98.23,51.51) 98.08,51.4 97.82,51.13 arc(97.73,51.06) 97.63,51.04 97.54,51.04 arc(97.36,51.01) 97.21,50.9 96.95,50.63 arc(96.87,50.56) 96.76,50.54 96.68,50.54 arc(96.5,50.51) 96.35,50.4 96.09,50.13 arc(96,50.06) 95.9,50.04 95.81,50.04 arc(95.63,50.01) 95.48,49.9 95.22,49.63 arc(95.13,49.56) 95.03,49.54 94.94,49.54 arc(94.77,49.51) 94.62,49.4 94.36,49.13 arc(94.27,49.06) 94.16,49.04 94.08,49.04 arc(93.9,49.01) 93.75,48.9 93.49,48.63 arc(93.4,48.56) 93.3,48.54 93.21,48.54 arc(93.03,48.51) 92.88,48.4 92.62,48.13 arc(92.54,48.06) 92.43,48.04 92.35,48.04 arc(92.17,48.01) 92.02,47.9 91.76,47.63 arc(91.67,47.56) 91.57,47.54 91.48,47.54 arc(91.3,47.51) 91.15,47.4 90.89,47.13 arc(90.8,47.06) 90.7,47.04 90.61,47.04 arc(90.44,47.01) 90.29,46.9 90.03,46.63 arc(89.94,46.56) 89.83,46.54 88.18,46.54 85.61,43.97 80.86,43.97 77.25,40.36 77.25,35.3 70.9,28.95 70.9,27.73 68.63,25.47 60.19,25.47 57.4,22.67 56.05,22.67 55.95,22.77 v1(55.95,23.07)
  BOTTOM w0.102: v1(125.31,84.43) 125.28,84.43 124.89,84.04 124.7,84.04 124.46,83.81 124.46,82.85 123.95,82.33 123.83,82.04 123.83,81.81 123.95,81.5 123.95,81.35 123.83,81.04 123.83,80.81 123.95,80.5 123.95,80.35 123.83,80.05 123.83,79.81 123.96,79.5 123.96,79.36 123.82,79.03 123.82,78.82 123.96,78.5 123.96,78.36 123.83,78.04 123.83,77.81 123.96,77.49 123.96,77.37 123.88,77.18 123.79,77.09 123.67,77.09 123.57,77.19 v1(123.57,77.43)
CLK_DDR4_CH1_N: length 133.5
  L16_SIG6 w0.079: v1(49.68,18.81) 49.97,18.81 50.07,18.71 50.07,17.99 49.81,17.72 47.92,17.72 47.8,17.85 47.52,17.85 47.39,17.72 47.11,17.72 46.73,18.1 46.73,19.44 46.05,20.12 46.05,21.35 46.18,21.47 46.18,21.75 46.05,21.88 46.05,27.66 47.99,29.59 47.99,34.12 47.28,34.83 47.28,36.37 46.31,37.34 45.73,37.34 45.1,37.97 45.1,39.78 44.81,40.07 44.81,40.5 44.93,40.63 44.93,40.91 44.81,41.04 44.81,42.56 44.97,42.72 44.97,43.73 44.81,43.89 44.81,44.39 45.06,44.65 45.06,45.62 44.33,46.35 44.33,54.97 44.15,55.15 44.15,56.75 43.01,57.89 43.01,61.14 41.38,62.77 41.38,65.62 41.23,65.77 41.23,74.49 41.36,74.62 41.36,74.89 41.23,75.02 41.23,75.4 44.05,78.21 44.05,79.21 44.49,79.65 45.33,79.65 46.27,80.58 46.27,80.82 46.8,81.35 46.8,81.71 47.19,82.11 50.34,82.11 50.46,81.98 50.74,81.98 50.87,82.11 51.51,82.11 52.05,81.57 64.87,81.57 64.98,81.46 65.34,81.46 65.44,81.57 65.69,81.57 65.82,81.44 65.84,81.44 69.83,77.45 76.85,77.45 78.07,76.23 84.59,76.23 85.26,75.57 86.17,75.57 86.4,75.34 87.24,75.34 87.41,75.51 87.41,75.54 v1(87.8,75.93) 87.41,76.32 87.41,76.52 87.58,76.69 88.15,76.69 88.24,76.59 88.24,76.5 88.34,76.41 88.48,76.41 88.58,76.5 88.58,76.59 88.68,76.69 89.14,76.69 89.53,76.3 90.56,76.3 91.06,75.8 93.26,75.8 93.77,76.3 94.51,76.3 94.64,76.18 94.92,76.18 95.05,76.3 95.32,76.3 95.45,76.18 95.73,76.18 95.86,76.3 96.14,76.3 96.25,76.19 96.56,76.19 96.67,76.3 96.95,76.3 97.19,76.55 97.44,76.8 97.53,76.82 97.61,76.79 97.67,76.74 97.69,76.65 v1(97.59,76.43)
CLK_DDR4_CH1_P: length 133.3
  L16_SIG6 w0.079: v1(97.59,77.43) 97.34,77.03 97.3,76.99 97.05,76.73 97.03,76.7 96.86,76.53 93.67,76.53 93.17,76.03 91.16,76.03 90.65,76.53 89.62,76.53 89.24,76.91 87.49,76.91 87.18,76.61 87.18,76.32 v1(86.8,75.93) 87.08,75.93 87.18,75.84 87.18,75.6 87.15,75.57 86.49,75.57 86.27,75.8 85.35,75.8 84.69,76.46 78.16,76.46 76.94,77.68 69.92,77.68 65.93,81.67 65.91,81.67 65.78,81.8 52.14,81.8 51.6,82.34 47.1,82.34 46.57,81.81 46.57,81.45 46.04,80.92 46.04,80.68 45.24,79.88 44.39,79.88 43.82,79.3 43.82,78.31 41,75.49 41,65.67 41.15,65.53 41.15,62.68 42.78,61.04 42.78,57.79 43.92,56.65 43.92,55.05 44.1,54.87 44.1,46.26 44.84,45.52 44.84,44.74 44.58,44.49 44.58,43.8 44.74,43.63 44.74,42.82 44.58,42.65 44.58,39.98 44.87,39.69 44.87,37.87 45.63,37.11 46.22,37.11 47.05,36.28 47.05,34.73 47.76,34.03 47.76,29.69 45.82,27.75 45.82,20.02 46.5,19.34 46.5,18 47.01,17.5 49.91,17.5 50.3,17.89 50.3,18.71 50.4,18.81 v1(50.69,18.81)
CLK_DDR4_CH2_N: length 116.6
  L14_SIG5 w0.079: v1(55.95,24.08) 55.95,24.35 55.82,24.48 55.47,24.48 55.2,24.75 55.2,26.31 55.61,26.72 60.95,26.72 66.19,31.96 74.02,31.96 74.53,31.45 78.63,31.45 79.18,30.9 88.14,30.9 88.7,31.47 88.7,31.99 88.5,32.19 88.5,32.89 90.02,34.41 90.02,41.49 90.17,41.84 90.17,42.03 90.06,42.3 90.06,42.56 90.18,42.84 90.18,43.02 90.06,43.31 90.06,43.56 90.18,43.86 90.18,44.02 90.05,44.32 90.05,44.53 90.17,44.82 90.17,45.04 90.06,45.31 90.06,45.54 90.17,45.8 90.17,46.02 90.06,46.28 90.06,46.58 90.17,46.85 90.17,47.03 90.06,47.29 90.06,47.57 90.14,47.75 90.34,47.96 90.55,48.04 90.7,48.04 arc(90.81,48.07) 90.89,48.13 91.15,48.4 arc(91.3,48.51) 91.48,48.54 91.57,48.54 arc(91.67,48.57) 91.76,48.63 92.02,48.9 arc(92.17,49.01) 92.35,49.04 92.43,49.04 arc(92.54,49.07) 92.62,49.13 92.88,49.4 arc(93.03,49.51) 93.21,49.54 93.3,49.54 arc(93.4,49.57) 93.49,49.63 93.75,49.9 arc(93.9,50.01) 94.08,50.04 94.16,50.04 arc(94.27,50.07) 94.36,50.13 94.62,50.4 arc(94.77,50.51) 94.94,50.54 95.03,50.54 arc(95.13,50.57) 95.22,50.63 95.48,50.9 arc(95.63,51.01) 95.81,51.04 95.9,51.04 arc(96,51.07) 96.09,51.13 96.35,51.4 arc(96.5,51.51) 96.68,51.54 96.76,51.54 arc(96.87,51.57) 96.95,51.63 97.21,51.9 arc(97.36,52.01) 97.54,52.04 97.63,52.04 arc(97.73,52.07) 97.82,52.13 98.08,52.4 arc(98.23,52.51) 98.41,52.54 98.49,52.54 arc(98.69,52.5) 98.85,52.39 99.11,52.11 arc(99.19,52.06) 99.27,52.04 99.38,52.04 arc(99.46,52.06) 99.54,52.11 99.8,52.39 arc(99.96,52.5) 100.16,52.54 100.23,52.54 arc(100.42,52.5) 100.59,52.39 100.84,52.11 arc(100.92,52.06) 101.01,52.04 101.11,52.04 arc(101.2,52.06) 101.27,52.11 101.53,52.39 arc(101.69,52.5) 101.89,52.54 101.96,52.54 arc(102.15,52.5) 102.32,52.39 102.58,52.11 arc(102.65,52.06) 102.74,52.04 102.84,52.04 arc(102.93,52.06) 103,52.11 103.26,52.39 arc(103.42,52.5) 103.62,52.54 103.69,52.54 arc(103.89,52.5) 104.05,52.39 104.31,52.11 arc(104.38,52.06) 104.47,52.04 104.57,52.04 arc(104.66,52.06) 104.73,52.11 104.99,52.39 arc(105.16,52.5) 105.35,52.54 105.42,52.54 arc(105.62,52.5) 105.78,52.39 106.04,52.11 arc(106.11,52.06) 106.2,52.04 106.3,52.04 arc(106.39,52.06) 106.47,52.11 106.72,52.39 arc(106.89,52.5) 107.08,52.54 107.15,52.54 arc(107.35,52.5) 107.51,52.39 107.77,52.11 arc(107.85,52.06) 107.93,52.04 108.03,52.04 arc(108.12,52.06) 108.2,52.11 108.46,52.39 arc(108.62,52.5) 108.82,52.54 108.89,52.54 arc(109.08,52.5) 109.25,52.39 109.5,52.11 arc(109.58,52.06) 109.67,52.04 109.77,52.04 arc(109.86,52.06) 109.93,52.11 110.19,52.39 arc(110.35,52.5) 110.55,52.54 110.62,52.54 arc(110.81,52.5) 110.98,52.39 111.24,52.11 arc(111.31,52.06) 111.4,52.04 111.5,52.04 arc(111.59,52.06) 111.66,52.11 111.92,52.39 arc(112.08,52.5) 112.28,52.54 112.35,52.54 arc(112.55,52.5) 112.71,52.39 112.97,52.11 arc(113.04,52.06) 113.13,52.04 113.23,52.04 arc(113.32,52.06) 113.39,52.11 113.65,52.39 arc(113.82,52.5) 114.01,52.54 114.08,52.54 arc(114.28,52.5) 114.44,52.39 114.7,52.11 arc(114.77,52.06) 114.86,52.04 114.96,52.04 arc(115.05,52.06) 115.13,52.11 115.38,52.39 arc(115.55,52.5) 115.74,52.54 115.81,52.54 arc(116.01,52.5) 116.17,52.39 116.43,52.11 arc(116.51,52.06) 116.59,52.04 116.7,52.04 arc(116.78,52.06) 116.86,52.11 117.12,52.39 arc(117.28,52.5) 117.48,52.54 117.55,52.54 arc(117.74,52.5) 117.91,52.39 118.16,52.11 arc(118.24,52.06) 118.33,52.04 118.43,52.04 arc(118.52,52.06) 118.59,52.11 118.85,52.39 arc(119.01,52.5) 119.21,52.54 119.28,52.54 arc(119.47,52.5) 119.64,52.39 119.9,52.11 arc(119.97,52.06) 120.06,52.04 120.14,52.04 arc(120.34,52) 120.5,51.89 120.76,51.61 arc(120.84,51.56) 120.92,51.54 121.1,51.54 121.3,51.46 121.49,51.27 121.59,51.05 121.59,48.8 121.46,48.5 121.46,48.34 121.58,48.05 121.58,47.8 121.47,47.53 121.47,47.34 121.52,47.22 121.64,47.1 121.8,47.04 121.96,47.04 122.16,46.95 122.36,46.76 122.45,46.55 122.45,46.28 122.33,46.01 122.33,45.85 122.44,45.58 122.44,45.3 122.34,45.04 122.34,44.85 122.44,44.59 122.44,44.29 122.33,44.01 122.33,43.84 122.45,43.55 122.45,43.3 122.33,43.02 122.33,42.84 122.44,42.57 122.44,42.31 122.33,42.04 122.33,41.84 122.44,41.58 122.44,40.59 122.99,40.04 123.19,40.04 v1(123.57,40.43)
  BOTTOM w0.102: v1(121.84,47.43) 122.1,47.05 122.35,46.8 122.46,46.53 122.46,46.32 122.32,46 122.32,45.86 122.45,45.54 122.45,45.31 122.32,44.99 122.32,44.87 122.45,44.54 122.45,44.31 122.33,44 122.33,43.85 122.45,43.55 122.45,43.31 122.32,43 122.32,42.86 122.45,42.55 122.45,42.31 122.32,42 122.32,41.86 122.56,41.28 122.56,40.97 122.69,40.85 122.69,40.57 122.56,40.44 122.56,40.16 122.71,40.01 123.13,40.01 123.55,40.43 v1(123.57,40.43)
CLK_DDR4_CH2_P: length 116.4
  L14_SIG5 w0.079: v1(123.57,39.43) 123.19,39.81 122.89,39.81 122.21,40.5 122.21,41.53 122.1,41.79 122.1,42.09 122.21,42.35 122.21,42.53 122.1,42.79 122.1,43.06 122.22,43.34 122.22,43.51 122.1,43.8 122.1,44.05 122.21,44.33 122.21,44.54 122.11,44.8 122.11,45.09 122.21,45.34 122.21,45.53 122.1,45.8 122.1,46.05 122.22,46.33 122.22,46.5 122.16,46.63 122.04,46.76 121.92,46.81 121.75,46.81 121.51,46.91 121.32,47.09 121.24,47.29 121.24,47.57 121.35,47.84 121.35,48 121.23,48.3 121.23,48.55 121.36,48.85 121.36,51 121.3,51.14 121.17,51.27 121.06,51.31 120.92,51.31 arc(120.75,51.35) 120.6,51.46 120.34,51.73 arc(120.25,51.79) 120.14,51.81 120.06,51.81 arc(119.88,51.85) 119.73,51.96 119.47,52.23 arc(119.38,52.29) 119.28,52.31 119.21,52.31 arc(119.1,52.29) 119.02,52.23 118.76,51.96 arc(118.61,51.85) 118.43,51.81 118.33,51.81 arc(118.15,51.85) 118,51.96 117.74,52.23 arc(117.65,52.29) 117.55,52.31 117.48,52.31 arc(117.37,52.29) 117.28,52.23 117.02,51.96 arc(116.87,51.85) 116.7,51.81 116.59,51.81 arc(116.42,51.85) 116.27,51.96 116.01,52.23 arc(115.92,52.29) 115.81,52.31 115.74,52.31 arc(115.64,52.29) 115.55,52.23 115.29,51.96 arc(115.14,51.85) 114.96,51.81 114.86,51.81 arc(114.68,51.85) 114.53,51.96 114.27,52.23 arc(114.19,52.29) 114.08,52.31 114.01,52.31 arc(113.91,52.29) 113.82,52.23 113.56,51.96 arc(113.41,51.85) 113.23,51.81 113.13,51.81 arc(112.95,51.85) 112.8,51.96 112.54,52.23 arc(112.45,52.29) 112.35,52.31 112.28,52.31 arc(112.17,52.29) 112.09,52.23 111.83,51.96 arc(111.68,51.85) 111.5,51.81 111.4,51.81 arc(111.22,51.85) 111.07,51.96 110.81,52.23 arc(110.72,52.29) 110.62,52.31 110.55,52.31 arc(110.44,52.29) 110.35,52.23 110.1,51.96 arc(109.95,51.85) 109.77,51.81 109.67,51.81 arc(109.49,51.85) 109.34,51.96 109.08,52.23 arc(108.99,52.29) 108.89,52.31 108.82,52.31 arc(108.71,52.29) 108.62,52.23 108.36,51.96 arc(108.21,51.85) 108.03,51.81 107.93,51.81 arc(107.76,51.85) 107.61,51.96 107.35,52.23 arc(107.26,52.29) 107.15,52.31 107.08,52.31 arc(106.98,52.29) 106.89,52.23 106.63,51.96 arc(106.48,51.85) 106.3,51.81 106.2,51.81 arc(106.02,51.85) 105.87,51.96 105.61,52.23 arc(105.53,52.29) 105.42,52.31 105.35,52.31 arc(105.25,52.29) 105.16,52.23 104.9,51.96 arc(104.75,51.85) 104.57,51.81 104.47,51.81 arc(104.29,51.85) 104.14,51.96 103.88,52.23 arc(103.79,52.29) 103.69,52.31 103.62,52.31 arc(103.51,52.29) 103.43,52.23 103.17,51.96 arc(103.02,51.85) 102.84,51.81 102.74,51.81 arc(102.56,51.85) 102.41,51.96 102.15,52.23 arc(102.06,52.29) 101.96,52.31 101.89,52.31 arc(101.78,52.29) 101.69,52.23 101.44,51.96 arc(101.29,51.85) 101.11,51.81 101.01,51.81 arc(100.83,51.85) 100.68,51.96 100.42,52.23 arc(100.33,52.29) 100.23,52.31 100.16,52.31 arc(100.05,52.29) 99.96,52.23 99.7,51.96 arc(99.55,51.85) 99.38,51.81 99.27,51.81 arc(99.1,51.85) 98.95,51.96 98.69,52.23 arc(98.6,52.29) 98.49,52.31 98.41,52.31 arc(98.32,52.3) 98.25,52.24 97.99,51.97 arc(97.82,51.86) 97.63,51.81 97.54,51.81 arc(97.45,51.8) 97.38,51.74 97.12,51.47 arc(96.96,51.36) 96.76,51.31 96.68,51.31 arc(96.59,51.3) 96.51,51.24 96.25,50.97 arc(96.09,50.86) 95.9,50.81 95.81,50.81 arc(95.72,50.8) 95.65,50.74 95.39,50.47 arc(95.23,50.36) 95.03,50.31 94.94,50.31 arc(94.86,50.3) 94.78,50.24 94.52,49.97 arc(94.36,49.86) 94.16,49.81 94.08,49.81 arc(93.99,49.8) 93.92,49.74 93.66,49.47 arc(93.49,49.36) 93.3,49.31 93.21,49.31 arc(93.12,49.3) 93.05,49.24 92.79,48.97 arc(92.63,48.86) 92.43,48.81 92.35,48.81 arc(92.26,48.8) 92.18,48.74 91.92,48.47 arc(91.76,48.36) 91.57,48.31 91.48,48.31 arc(91.39,48.3) 91.32,48.24 91.06,47.97 arc(90.9,47.86) 90.7,47.81 90.59,47.81 90.47,47.77 90.33,47.62 90.29,47.53 90.29,47.33 90.4,47.08 90.4,46.8 90.29,46.54 90.29,46.33 90.4,46.06 90.4,45.76 90.29,45.49 90.29,45.35 90.4,45.09 90.4,44.77 90.28,44.49 90.28,44.37 90.41,44.06 90.41,43.81 90.29,43.52 90.29,43.36 90.41,43.07 90.41,42.8 90.29,42.52 90.29,42.34 90.4,42.07 90.4,41.79 90.25,41.44 90.25,41.16 90.38,41.03 90.38,40.75 90.25,40.63 90.25,40.35 90.38,40.22 90.38,39.94 90.25,39.81 90.25,34.32 88.73,32.79 88.73,32.29 88.93,32.08 88.93,31.37 88.24,30.67 79.08,30.67 78.54,31.22 74.44,31.22 73.92,31.73 66.29,31.73 66.09,31.54 66.09,31.36 65.89,31.16 65.71,31.16 61.05,26.49 56.99,26.49 56.86,26.37 56.59,26.37 56.46,26.49 55.71,26.49 55.43,26.22 55.43,25.87 55.56,25.75 55.56,25.47 55.43,25.34 55.43,24.84 55.57,24.7 55.85,24.7 55.95,24.81 v1(55.95,25.1)
  BOTTOM w0.102: v1(121.84,46.43) 121.84,46.67 121.94,46.77 122.06,46.77 122.15,46.67 122.23,46.49 122.23,46.37 122.09,46.04 122.09,45.81 122.22,45.5 122.22,45.36 122.09,45.03 122.09,44.82 122.22,44.5 122.22,44.36 122.1,44.05 122.1,43.81 122.22,43.5 122.22,43.35 122.09,43.04 122.09,42.81 122.22,42.5 122.22,42.35 122.1,42.05 122.1,41.81 122.33,41.24 122.33,40.07 122.62,39.78 123.2,39.78 123.55,39.43 v1(123.57,39.43)
CLK_DDR4_CH3_N: length 62.5
  L03_SIG1 w0.079: v1(51.71,18.81) 52,18.81 52.1,18.91 52.1,19.35 53.53,20.78 56.65,20.78 58.3,19.13 64.92,19.13 70.15,24.36 75.69,24.36 75.81,24.49 76.09,24.49 76.22,24.36 76.52,24.36 77.88,25.72 85.08,25.72 89.66,30.29 91.08,30.29 95.4,34.61 95.4,36.72 95.77,37.09 95.77,39.56 96.16,39.96 96.63,39.96 96.73,40.06 v1(96.73,40.43)
  BOTTOM w0.102: v1(96.73,40.43) 96.71,40.43 96.32,40.04 96.17,40.04 96.07,40.14 96.07,40.63 96.48,41.05 96.48,41.52 96.38,41.77 96.26,41.89 96.15,41.94 95.82,41.94 95.71,42.04 95.71,42.28 v1(95.86,42.43)
CLK_DDR4_CH3_P: length 62.3
  L03_SIG1 w0.079: v1(96.73,39.43) 96.73,39.63 96.63,39.73 96.25,39.73 95.99,39.47 95.99,39.1 96.09,39 96.22,39 96.32,38.9 96.32,38.77 96.22,38.67 96.09,38.67 95.99,38.57 95.99,37 95.63,36.63 95.63,34.52 91.17,30.06 89.75,30.06 85.18,25.49 77.98,25.49 76.62,24.13 70.25,24.13 65.02,18.9 58.21,18.9 56.55,20.55 53.63,20.55 53.01,19.93 53.01,19.79 53.09,19.71 53.09,19.58 52.99,19.48 52.85,19.48 52.77,19.56 52.63,19.56 52.33,19.26 52.33,18.91 52.43,18.81 v1(52.73,18.81)
  BOTTOM w0.102: v1(96.73,39.43) 96.7,39.43 96.32,39.81 96.08,39.81 95.84,40.05 95.84,40.72 96.26,41.14 96.26,41.47 96.18,41.64 96.13,41.7 96.1,41.71 95.94,41.71 95.86,41.63 v1(95.86,41.43)
CLK_PWR_M10: length 354.1
  L07_SIG3 w0.089: v1(33.47,38.43) 33,38.91 33,40.78 32.11,41.66 31.2,41.66 30.74,42.12 30.74,42.42 29.01,44.15 29.01,46.48 28.69,46.8 28.69,50.42 30.49,52.23 30.49,53.88 29.98,54.38 29.98,55.83 30.23,56.09 32.34,56.09 33.51,57.25 34.27,57.25 v1(34.68,56.85)
  L16_SIG6 w0.081: v1(253.35,28.26) 254.58,29.49 257.5,29.49 257.72,29.7 257.72,31.17 258.17,31.63 258.17,36.2 258.68,36.71 258.68,45.47 260.97,47.76 260.97,55.96 259.65,57.28 259.65,61.37 253.8,67.21 253.8,75.36 238.11,91.06 216.21,91.06 215.33,90.17 194.52,90.17 192.87,91.82 186.87,91.82 184.16,94.54 179.3,94.54 175.45,98.39 175.45,99.22 173.39,101.27 156.04,101.27 154.52,99.75 151.14,99.75 150.71,99.32 149.41,99.32 148.98,99.75 145.06,99.75 144.45,100.36 144.02,100.36 142.86,101.53 140.52,101.53 138.64,99.64 138.28,99.64 138.08,99.44 136.56,99.44 135.86,98.75 130.25,98.75 129.39,97.89 125.67,97.89 125.16,98.39 125.16,98.54 124.76,98.95 123.8,98.95 123.3,99.45 118.64,99.45 117.43,100.66 112.74,100.66 112.64,100.76 109.02,100.76 108.82,100.56 108.77,100.56 108.59,100.38 106.33,100.38 105.5,100.04 103.9,100.04 103.13,99.27 102.3,99.27 101.74,99.82 93.85,99.82 93.5,100.18 83.94,100.18 83.6,99.84 75.68,99.84 75.43,100.09 70.46,100.09 69.83,99.47 66.99,99.47 66.42,98.9 64.88,98.9 63.7,97.71 59.19,97.71 55.97,94.49 54.82,94.49 53.88,93.55 49.87,93.55 48.08,91.77 47.32,91.77 46.11,90.56 45.7,90.56 45.48,90.34 45.48,90.04 44.98,89.53 44.3,89.53 44.13,89.36 44.13,89.18 43.83,88.88 43.83,88.48 43.56,88.21 43.41,88.21 43.2,87.99 43.2,87.85 43.03,87.68 42.77,87.68 42.01,86.92 41.01,86.92 40.42,86.33 40.42,86.27 40.33,86.18 40.33,83.27 39.96,82.9 39.96,82.3 39.64,81.97 39.64,81.8 38.82,80.98 38.82,80.73 37.62,79.52 35.64,79.52 33.74,77.62 33.74,72.12 33.24,71.62 33.24,65.74 33.88,65.11 33.88,60.43 32.71,59.26 32.71,58.25 33.5,57.46 34.07,57.46 v1(34.68,56.85)
CLK_SYS_100M_N: length 89.1
  L07_SIG3 w0.085: v1(55.95,28.15) 55.95,28.44 55.85,28.54 55.42,28.54 55.1,28.86 55.1,30.38 55.53,30.81 56.78,30.81 59.54,33.58 68.04,33.58 69.64,35.18 70.31,35.18 70.46,35.33 70.46,35.73 70.83,36.1 71.79,36.1 72.37,36.68 72.37,38.53 72.93,39.09 72.93,44.19 77.15,48.42 83.11,48.42 84.71,50.02 85.92,50.02 87,51.1 87.84,51.1 88.29,51.54 89.87,51.54 arc(89.97,51.56) 90.05,51.63 90.19,51.82 arc(90.4,51.98) 90.66,52.04 arc(90.93,51.98) 91.14,51.81 91.24,51.68 arc(91.37,51.58) 91.53,51.54 91.6,51.54 arc(91.8,51.5) 91.96,51.37 92.11,51.18 arc(92.23,51.08) 92.39,51.04 arc(92.56,51.08) 92.69,51.19 92.79,51.32 arc(93,51.48) 93.26,51.54 93.33,51.54 arc(93.43,51.56) 93.51,51.63 93.65,51.82 arc(93.86,51.98) 94.12,52.04 94.13,52.04 arc(94.39,51.98) 94.6,51.81 94.7,51.68 arc(94.83,51.58) 94.99,51.54 95.06,51.54 arc(95.16,51.56) 95.24,51.63 95.38,51.82 arc(95.59,51.98) 95.85,52.04 95.87,52.04 arc(96.12,51.98) 96.32,51.82 96.43,51.68 arc(96.56,51.58) 96.72,51.54 96.77,51.54 arc(96.99,51.49) 97.17,51.34 97.32,51.16 arc(97.42,51.07) 97.55,51.04 97.65,51.04 arc(97.87,50.99) 98.04,50.86 98.18,50.67 arc(98.3,50.57) 98.44,50.54 98.45,50.54 arc(98.72,50.48) 98.93,50.31 99.03,50.18 arc(99.16,50.08) 99.31,50.04 99.36,50.04 arc(99.59,49.99) 99.78,49.84 99.93,49.65 arc(100.03,49.57) 100.14,49.54 100.26,49.54 arc(100.36,49.56) 100.44,49.63 100.59,49.82 arc(100.79,49.98) 101.05,50.04 101.08,50.04 arc(101.32,49.99) 101.51,49.84 101.65,49.65 arc(101.75,49.57) 101.88,49.54 101.98,49.54 arc(102.09,49.57) 102.19,49.64 102.33,49.83 arc(102.53,49.99) 102.77,50.04 102.82,50.04 arc(103.06,49.99) 103.25,49.83 103.37,49.68 arc(103.49,49.58) 103.65,49.54 103.68,49.54 arc(103.81,49.57) 103.92,49.66 104.03,49.8 arc(104.25,49.98) 104.53,50.04 104.59,50.04 arc(104.79,50) 104.94,49.87 105.1,49.68 arc(105.22,49.58) 105.37,49.54 105.41,49.54 arc(105.55,49.57) 105.65,49.66 105.79,49.83 arc(105.98,49.99) 106.23,50.04 106.29,50.04 arc(106.52,49.99) 106.69,49.85 106.83,49.68 arc(106.95,49.58) 107.11,49.54 107.25,49.54 107.43,49.47 107.63,49.27 107.73,49.03 107.73,48.82 107.61,48.52 107.61,48.34 107.73,48.05 107.73,47.81 107.61,47.53 107.61,47.34 107.72,47.06 107.72,46.8 107.6,46.51 107.6,46.36 107.74,46.04 107.74,45.82 107.6,45.49 107.6,45.37 107.72,45.08 107.72,44.77 107.61,44.51 107.61,44.33 107.73,44.04 107.73,43.83 107.61,43.52 107.61,43.36 107.73,43.06 107.73,42.82 107.61,42.53 107.61,42.34 107.73,42.06 107.73,41.81 107.6,41.51 107.6,40.16 107.72,40.04 107.88,40.04 107.99,40.14 v1(107.99,40.43)
  BOTTOM w0.102: v1(109.72,45.43) 109.23,44.83 109.1,44.53 109.1,44.32 109.23,44 109.23,43.86 109.1,43.54 109.1,43.31 109.24,42.99 109.24,42.87 109.1,42.54 109.1,42.31 109.23,42 109.23,41.85 108.78,40.77 108.78,40.24 108.6,40.06 108.37,40.06 108,40.43 v1(107.99,40.43)
