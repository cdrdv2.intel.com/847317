# Allegro board TS28247BC0_FM61_agilex_PCIe_DEVKIT_ADI_REVB1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_DIMM_CH2_DQ1: length 76.8
  L12_SIG4 w0.089: v1(188.59,26.42) 189.67,26.86 190.91,28.1 191.58,29.72 191.58,32.59 191.06,33.11 190.66,33.28 183.56,40.38 183,40.61 173.91,44.12 173.03,45.07 170.8,45.77 170.31,46.25 170.31,46.82 169.94,47.19 160.58,53.7 160.02,54.26 160.02,54.71 159.94,54.92 159.07,55.79 158.47,55.79 157.81,56.45 148.96,56.45 147.96,55.45 142.03,55.45 140.71,54.91 140.44,54.64 139.96,54.44 139.57,54.18 139.26,54.05 139.05,54.05 138.44,54.3 138.2,54.3 137.32,53.94 136.85,53.48 135.75,53.02 135.38,52.64 135.22,52.26 135.22,51.83 135.11,51.58 135.11,51.26 135.22,51.01 135.22,50.86 v1(134.83,49.93)
DDR4_DIMM_CH2_DQ2: length 77.3
  L12_SIG4 w0.089: v1(183.5,32.41) 183.03,31.95 182.58,31.95 182.48,31.85 182.48,29.67 182.38,29.57 182.24,29.57 182.14,29.67 182.14,31.85 182.04,31.95 181.91,31.95 181.81,31.85 181.81,30.12 181.71,30.03 181.57,30.03 181.47,30.12 181.47,31.85 181.37,31.95 181.23,31.95 181.14,31.85 181.14,29.75 181.04,29.65 180.9,29.65 180.8,29.75 180.8,31.85 180.7,31.95 180.56,31.95 180.47,31.85 180.47,29.75 180.37,29.65 180.23,29.65 180.13,29.75 180.13,31.85 180.03,31.95 177.28,31.95 176.44,32.79 175.66,32.79 174.68,33.77 173.75,33.77 169.73,37.79 169,37.79 165.28,41.5 165.28,42.19 163.38,44.09 161.11,44.09 157.15,48.06 157.15,48.53 156.76,48.92 156.29,48.92 155.68,49.53 154.85,49.53 154.06,50.32 148.82,50.32 148.39,49.88 144.45,49.88 144.1,49.53 144.1,49.27 143.75,48.92 142.57,48.92 142.17,49.32 141.57,49.32 141.11,48.86 140.71,48.86 140.25,49.32 139.76,49.32 139.38,48.93 139.04,48.93 138.66,49.31 138.04,49.31 137.65,48.92 137.37,48.92 136.88,48.44 136.36,48.44 135.86,48.93 135.42,48.93 135.05,49.31 134.09,49.31 v1(133.97,49.43)
DDR4_DIMM_CH2_DQ3: length 76.9
  L12_SIG4 w0.089: v1(134.83,48.93) 134.83,48.58 135.5,47.92 135.84,47.92 136.26,47.5 136.79,47.5 137.21,47.92 137.58,47.92 138.09,47.41 138.45,47.41 138.85,47.81 139.46,47.81 139.84,47.43 140.23,47.43 140.61,47.82 141.18,47.82 141.53,47.46 141.98,47.46 142.32,47.81 143.93,47.81 144.84,48.71 145.92,48.71 146.24,49.02 148.6,49.02 148.74,49.16 148.74,49.16 149.09,49.51 153.56,49.51 155.14,47.93 155.82,47.93 161.11,42.65 161.11,42.39 161.86,41.64 162.68,41.64 163.24,41.08 164.65,41.08 168.74,36.99 169.2,36.99 169.63,36.56 169.63,36.16 170.67,35.13 171.21,35.13 173.44,32.9 174.29,32.9 174.56,32.63 174.56,29.73 174.66,29.63 174.8,29.63 174.9,29.73 174.9,31.26 175,31.36 175.14,31.36 175.23,31.26 175.23,29.6 175.33,29.5 175.47,29.5 175.57,29.6 175.57,30.68 175.67,30.78 175.81,30.78 175.9,30.68 175.9,28.15 176.01,28.05 176.67,28.05 176.78,28.15 176.78,28.83 176.87,28.93 177.01,28.93 177.11,28.83 177.11,27.95 177.21,27.85 177.35,27.85 177.45,27.95 177.45,28.83 177.54,28.93 177.68,28.93 177.78,28.83 177.78,27.95 177.88,27.85 178.02,27.85 178.12,27.95 178.12,28.83 178.21,28.93 178.35,28.93 178.45,28.83 178.45,27.95 178.55,27.85 178.69,27.85 178.79,27.95 178.79,28.64 178.88,28.74 179.02,28.74 179.12,28.64 179.12,27.95 179.22,27.85 179.36,27.85 179.46,27.95 179.46,28.49 179.56,28.59 179.69,28.59 179.79,28.49 179.79,27.95 179.89,27.85 181.21,27.85 v1(182.64,26.42)
DDR4_DIMM_CH2_DQ4: length 74.2
  L12_SIG4 w0.089: v1(137.43,50.43) 138.34,50.43 138.76,50.85 139.41,50.85 139.72,50.54 140.32,50.54 140.75,50.98 141.23,50.98 141.63,51.38 141.99,51.38 142.42,51.82 144.75,51.82 145.09,52.16 153.42,52.16 153.66,51.92 156.85,51.92 158.28,50.48 158.28,50.23 158.63,49.88 159.59,49.48 160.1,48.97 160.1,48.12 160.51,47.71 161.06,47.71 163.24,45.54 163.62,45.54 167.96,41.2 169.49,41.2 170.15,40.55 170.15,40.3 170.71,39.73 172.83,39.73 173.92,38.64 173.92,37.58 177.87,33.63 183.77,33.63 185.05,33.1 185.58,32.57 185.58,26.25 185.85,25.98 187.31,25.98 188.37,27.04 189.52,28.76 190.95,32.22 v1(191.14,32.41)
DDR4_DIMM_CH2_DQ5: length 74.4
  L12_SIG4 w0.089: v1(190.29,26.42) 189.5,25.62 185.67,25.62 184.81,26.49 184.81,28.42 184.71,28.52 184.56,28.52 184.46,28.42 184.46,27.32 184.36,27.22 184.2,27.22 184.09,27.32 184.09,28.47 183.99,28.57 183.76,28.57 183.66,28.47 183.66,27.7 183.56,27.6 183.42,27.6 183.32,27.7 183.32,28.47 182.92,28.87 182.92,31.28 183.92,32.29 183.92,32.58 183.67,32.83 177.19,32.83 176.77,33.26 175.68,33.26 173.89,35.04 173.35,35.04 170.13,38.26 170.13,38.61 169.49,39.26 168.88,39.26 163.62,44.52 161.44,44.52 158.21,47.75 158.21,48.52 157.8,48.93 157.46,48.93 157.14,49.26 157.14,49.58 156.76,49.96 154.98,49.96 154.08,50.86 145.42,50.86 145.01,50.45 144.22,50.45 143.68,49.91 142.39,49.91 142.03,49.55 141.58,49.55 141.31,49.81 140.63,49.81 140.36,49.55 139.73,49.55 139.47,49.81 138.83,49.81 138.57,49.55 137.92,49.55 137.79,49.43 v1(137.43,49.43)
DDR4_DIMM_CH2_DQ6: length 72.6
  L12_SIG4 w0.089: v1(138.29,49.93) 138.42,50.05 139.41,50.05 139.68,50.32 140.45,50.32 140.73,50.03 141.26,50.03 141.61,50.39 142,50.39 142.5,50.89 144.74,50.89 145.16,51.31 145.16,51.59 145.39,51.81 153,51.81 153.45,51.36 156.42,51.36 157.14,50.64 157.14,50.27 157.5,49.91 157.7,49.91 158.51,49.11 159.43,49.11 159.7,48.83 159.7,47.86 160.39,47.16 161.07,47.16 163.08,45.15 163.5,45.15 168.96,39.69 169.71,39.69 170.02,39.38 172.69,39.38 173.44,38.63 173.44,37.37 175.2,35.6 175.2,34.24 175.82,33.62 177.07,33.62 177.51,33.19 183.88,33.19 184.67,32.4 184.67,32.02 184.77,31.92 184.77,31.5 184.58,31.32 183.55,31.32 183.33,31.09 183.33,29.12 183.43,29.02 183.61,29.02 183.71,29.12 183.71,30.6 183.81,30.71 183.97,30.71 184.07,30.6 184.07,29.14 184.17,29.04 184.36,29.04 184.46,29.14 184.46,30.42 184.56,30.52 184.69,30.52 184.79,30.42 184.79,29.59 184.9,29.49 185.09,29.49 185.19,29.59 v1(185.19,32.42)
DDR4_DIMM_CH2_DQ7: length 73.1
  L12_SIG4 w0.089: v1(138.29,48.93) 138.29,48.67 138.94,48.03 139.29,48.03 139.64,48.38 140.36,48.38 140.7,48.04 141.13,48.04 141.51,48.42 142.05,48.42 142.43,48.04 142.94,48.04 143.29,48.38 143.95,48.38 144.62,49.05 145.78,49.05 146.1,49.37 148.39,49.37 148.92,49.9 153.85,49.9 154.83,48.92 155.76,48.92 156.17,48.52 156.17,48.19 160.84,43.52 162.23,43.52 164.2,41.55 164.71,41.55 168.84,37.43 169.4,37.43 170.15,36.69 170.15,36.23 170.87,35.51 171.39,35.51 173.58,33.33 174.64,33.33 175.42,32.54 175.42,32.09 176.35,31.16 176.35,29.29 176.45,29.19 176.59,29.19 176.69,29.29 176.69,30.82 176.78,30.92 176.92,30.92 177.02,30.82 177.02,29.39 177.12,29.3 177.26,29.3 177.36,29.39 177.36,30.82 177.46,30.92 177.59,30.92 177.69,30.82 177.69,29.39 177.79,29.3 177.93,29.3 178.03,29.39 178.03,31.03 178.13,31.13 178.26,31.13 178.36,31.03 178.36,29.39 178.46,29.3 178.6,29.3 178.7,29.39 178.7,30.34 178.8,30.43 178.94,30.43 179.03,30.34 179.03,29.39 179.13,29.3 179.27,29.3 179.37,29.39 179.37,30.31 179.47,30.41 179.61,30.41 179.7,30.31 179.7,29.39 179.8,29.3 180.92,29.3 183.41,26.81 183.95,26.81 v1(184.34,26.42)
DDR4_DIMM_CH2_DQ8: length 68.1
  L14_SIG5 w0.081: v1(133.97,45.43) 134.41,45.87 134.41,47.16 134.57,47.33 134.88,47.33 135.43,47.87 135.77,47.87 136.29,48.39 136.76,48.39 137.24,48.87 137.56,48.87 137.99,49.3 138.62,49.3 138.87,49.05 139.44,49.05 139.68,49.3 140.31,49.3 140.62,48.99 141.18,48.99 141.51,49.32 141.87,49.32 142.45,49.9 143.71,49.9 145.13,51.31 145.13,51.49 145.48,51.85 154.96,51.85 156.14,50.67 156.14,50.29 156.62,49.81 158,49.81 158.34,49.48 161.1,49.48 164.9,45.67 165.69,45.67 168.28,43.09 169.59,43.09 170.4,42.28 170.4,39.92 170.71,39.61 174.89,39.61 175,39.72 175,40.02 175.12,40.13 175.28,40.13 175.39,40.02 175.39,39.72 175.5,39.61 177.76,39.61 181.31,36.05 181.31,33.64 180.56,32.88 180.56,30.76 180.46,30.66 180.19,30.66 180.09,30.76 v1(180.09,32.42)
DDR4_DIMM_CH2_DQ9: length 67.2
  L14_SIG5 w0.081: v1(134.83,44.93) 135.27,45.37 135.27,46.59 135.59,46.91 135.97,46.91 136.44,47.38 136.7,47.38 137.19,47.88 137.54,47.88 138.02,48.35 138.52,48.35 138.86,48.02 139.39,48.02 139.75,48.38 140.23,48.38 140.65,47.96 141.11,47.96 141.49,48.34 141.86,48.34 142.43,48.91 143.76,48.91 144.12,49.27 144.12,49.68 145.25,50.81 154.63,50.81 156.4,49.05 160.89,49.05 164.83,45.11 165.61,45.11 168.59,42.13 168.59,41.95 168.28,41.65 168.28,41.47 168.43,41.32 168.61,41.32 168.92,41.63 169.1,41.63 169.95,40.77 169.95,39.84 170.57,39.22 175.57,39.22 176.21,38.57 176.91,38.57 180.75,34.72 180.75,33.95 179.7,32.9 179.7,27.33 179.24,26.87 v1(179.24,26.42)
DDR4_DIMM_CH2_DQ10: length 67.5
  L14_SIG5 w0.081: v1(133.97,44.43) 134.96,44.43 135.55,43.84 135.87,43.84 136.38,43.32 136.72,43.32 137.21,42.82 137.62,42.82 137.98,42.47 138.5,42.47 138.83,42.8 139.32,42.8 139.76,42.36 140.15,42.36 140.59,42.8 141.28,42.8 141.65,42.43 141.98,42.43 142.35,42.8 143.61,42.8 145.07,44.26 145.77,44.26 146.3,44.8 152.94,44.8 154.91,42.82 157.34,42.82 162.91,37.25 164.92,37.25 165.55,36.62 165.55,35.36 166.17,34.74 166.17,33.33 166.86,32.64 166.86,28.33 166.97,28.21 167.13,28.21 167.25,28.33 167.25,29.91 167.36,30.02 167.52,30.02 167.63,29.91 167.63,28.26 167.75,28.14 167.91,28.14 168.02,28.26 168.02,29.67 168.13,29.79 168.29,29.79 168.41,29.67 168.41,28.16 168.51,28.05 168.8,28.05 168.9,28.16 168.9,29.02 169.01,29.14 169.17,29.14 169.28,29.02 169.28,28.3 169.4,28.19 169.56,28.19 169.67,28.3 169.67,28.97 169.78,29.08 169.94,29.08 170.06,28.97 170.06,28.3 170.17,28.19 173.81,28.19 174.14,28.52 v1(174.14,32.42)
DDR4_DIMM_CH2_DQ11: length 66.9
  L14_SIG5 w0.081: v1(173.29,26.42) 172.89,26.82 171.63,26.82 171.52,26.92 171.52,27.12 171.63,27.23 174.19,27.23 174.29,27.33 174.29,27.59 174.19,27.69 170.82,27.69 170.7,27.57 170.7,26.99 170.59,26.87 170.43,26.87 170.32,26.99 170.32,27.57 170.2,27.69 170.04,27.69 169.93,27.57 169.93,26.99 169.82,26.87 169.66,26.87 169.54,26.99 169.54,27.57 169.43,27.69 168.67,27.69 168.55,27.57 168.55,27.02 168.44,26.9 168.28,26.9 168.17,27.02 168.17,27.57 168.05,27.69 167.89,27.69 167.78,27.57 167.78,27.02 167.67,26.9 167.51,26.9 167.4,27.02 167.4,27.57 167.28,27.69 166.62,27.69 166.4,27.91 166.4,29.88 166.29,29.98 165.9,29.98 165.8,29.88 165.8,28.8 165.7,28.69 165.24,28.69 165.14,28.8 165.14,31.94 165.64,32.44 165.64,34.61 163.42,36.83 162.71,36.83 157.1,42.45 154.82,42.45 152.8,44.46 147.83,44.46 147.2,43.83 145.19,43.83 142.91,41.55 141.56,41.55 141.27,41.84 140.63,41.84 140.33,41.54 139.79,41.54 139.53,41.81 138.81,41.81 138.56,41.55 138.11,41.55 137.71,41.95 137.23,41.95 136.73,42.45 136.31,42.45 135.84,42.92 135.53,42.92 134.83,43.62 v1(134.83,43.93)
DDR4_DIMM_CH2_DQ12: length 65.9
  L14_SIG5 w0.081: v1(137.43,45.43) 138.54,45.43 138.91,45.06 139.47,45.06 139.79,45.37 140.29,45.37 140.62,45.04 141.19,45.04 141.51,45.36 141.83,45.36 142.41,45.94 144.12,45.94 146.35,48.17 148.95,48.17 149.19,47.93 149.73,47.93 150.12,47.54 150.12,47.32 151.3,46.14 153.49,46.14 155.2,44.44 160.28,44.44 160.56,44.16 160.56,43.48 161.05,42.99 161.72,42.99 162.12,42.6 162.12,42.2 163.22,41.1 163.22,40.59 164.72,39.09 166.34,39.09 168.33,37.1 168.33,36.36 169.53,35.16 174.25,35.16 176.24,33.17 176.24,26.24 176.64,25.84 179.22,25.84 179.66,26.28 179.66,26.63 181.79,28.76 v1(181.79,32.42)
DDR4_DIMM_CH2_DQ13: length 66
  L14_SIG5 w0.081: v1(137.43,44.43) 138.33,44.43 138.85,43.91 139.32,43.91 139.72,44.3 140.23,44.3 140.61,43.93 141.12,43.93 141.49,44.3 142,44.3 142.41,43.9 143.52,43.9 146.56,46.94 148.74,46.94 149.32,46.36 149.77,46.36 150.66,45.47 153.21,45.47 155.12,43.56 158.21,43.56 160.12,41.65 160.72,41.65 161.15,41.22 161.15,40.64 163.65,38.14 166.05,38.14 167.26,36.94 168.79,33.23 169.49,32.53 169.49,30.01 169.65,29.84 172.71,29.84 172.87,30.01 172.87,32.57 173.53,33.23 174.9,33.23 175.45,32.69 175.45,26.1 176.2,25.34 179.93,25.34 180.94,26.35 v1(180.94,26.42)
DDR4_DIMM_CH2_DQ14: length 64.9
  L14_SIG5 w0.081: v1(175.84,32.42) 175.84,32.91 175.15,33.61 170.28,33.61 170.18,33.51 170.18,33.36 170.28,33.26 172.58,33.26 172.68,33.15 172.68,32.95 172.58,32.85 172.22,32.85 172.04,32.66 172.04,32.27 172.25,32.06 172.25,30.36 172.14,30.26 171.92,30.26 171.82,30.36 171.82,31.93 171.72,32.03 171.56,32.03 171.46,31.93 171.46,30.4 171.36,30.3 171.2,30.3 171.09,30.4 171.09,31.94 170.99,32.04 170.84,32.04 170.74,31.94 170.74,30.42 170.64,30.32 170.42,30.32 170.31,30.42 170.31,32.22 169.58,32.96 169.58,34.57 167.95,36.19 167.95,36.88 166.23,38.6 164.25,38.6 162.1,40.74 162.1,41.23 161.34,41.99 160.44,41.99 158.54,43.9 155.26,43.9 153.35,45.81 151.01,45.81 150.03,46.79 149.48,46.79 149.11,47.15 149.11,47.52 148.82,47.81 146.48,47.81 143.6,44.93 142.41,44.93 142.03,44.56 141.48,44.56 141.22,44.82 140.66,44.82 140.4,44.56 139.69,44.56 139.45,44.8 138.42,44.8 v1(138.29,44.93)
DDR4_DIMM_CH2_DQ15: length 64.7
  L14_SIG5 w0.081: v1(138.29,43.93) 138.29,43.67 138.91,43.05 139.52,43.05 139.87,43.4 140.22,43.4 140.57,43.05 141.11,43.05 141.48,43.42 142.09,43.42 142.45,43.05 143.33,43.05 144.97,44.69 145.3,44.69 146.56,45.95 149.67,45.95 150.48,45.14 153.07,45.14 154.98,43.22 157.61,43.22 163.05,37.78 164.87,37.78 166.07,36.59 166.07,36.05 167.47,34.64 167.47,31.97 167.86,31.58 167.86,30.22 167.96,30.12 168.3,30.12 168.4,30.22 168.4,31.91 168.52,32.02 168.82,32.02 168.94,31.91 168.94,29.84 169.34,29.44 172.09,29.44 172.19,29.33 172.19,28.72 172.3,28.62 172.55,28.62 172.66,28.72 172.66,29.38 172.76,29.48 173.07,29.48 173.18,29.38 173.18,28.66 173.28,28.56 173.58,28.56 173.68,28.66 173.68,32.64 173.92,32.88 174.29,32.88 174.55,32.62 174.55,28.32 174.99,27.87 v1(174.99,26.42)
DDR4_DIMM_CH2_DQ16: length 58.3
  L12_SIG4 w0.089: v1(170.74,32.42) 170.74,29.61 170.84,29.51 171.06,29.51 171.16,29.61 171.16,33.28 169.87,34.57 169.87,34.89 166.71,38.06 166.27,38.06 165.13,39.19 161.45,39.19 161.11,39.53 161.11,39.75 161.23,39.87 161.61,39.87 161.73,39.98 161.73,40.15 161.61,40.26 161.23,40.26 161.11,40.38 161.11,41.17 160.22,42.06 160.22,42.51 155.48,47.25 154.98,47.25 153.31,48.92 149.34,48.92 148.85,48.43 146.49,48.43 146.17,48.11 145.18,48.11 144.03,46.96 143.47,46.96 143.37,46.86 143.37,46.34 143.27,46.25 143.12,46.25 143.03,46.34 143.03,46.86 142.93,46.96 142.41,46.96 141.99,46.53 141.49,46.53 141.06,46.96 140.66,46.96 140.23,46.53 139.88,46.53 139.5,46.91 138.89,46.91 138.38,46.4 138.1,46.4 137.62,45.92 137.2,45.92 136.69,45.41 136.37,45.41 135.9,44.94 135.49,44.94 135,44.45 134.71,44.45 134.38,44.11 134.38,42.84 v1(133.97,42.43)
DDR4_DIMM_CH2_DQ17: length 58.5
  L12_SIG4 w0.089: v1(134.83,42.93) 135.13,43.22 135.13,43.51 135.51,43.9 135.96,43.9 136.38,44.32 136.66,44.32 137.27,44.93 137.6,44.93 138.09,45.41 138.44,45.41 138.94,45.91 139.44,45.91 139.84,46.31 140.25,46.31 140.59,45.97 141.13,45.97 141.47,46.31 142.18,46.31 142.7,45.8 143.65,45.8 143.75,45.89 143.75,46.53 143.85,46.62 143.99,46.62 144.09,46.53 144.09,45.89 144.18,45.8 144.5,45.8 144.59,45.89 144.59,47.03 145.33,47.77 146.31,47.77 146.52,47.98 149.28,47.98 149.45,47.81 153.79,47.81 154.08,47.52 154.08,47.26 154.46,46.88 155.29,46.88 159.86,42.32 159.86,39.59 160.78,38.66 164.98,38.66 166.06,37.58 166.68,37.58 169.53,34.74 169.53,34.4 170.31,33.63 170.31,29.3 170.18,29.17 169.76,29.17 169.66,29.07 169.66,28.93 169.76,28.83 170.53,28.83 170.63,28.73 170.63,28.59 170.53,28.49 169.79,28.49 169.69,28.39 169.69,28.26 169.79,28.16 170.18,28.16 170.31,28.03 170.31,27.39 169.89,26.97 v1(169.89,26.42)
DDR4_DIMM_CH2_DQ18: length 57.9
  L12_SIG4 w0.089: v1(134.83,41.93) 135.3,41.46 135.3,41.28 135.54,41.05 136.1,41.05 136.48,41.43 136.83,41.43 137.23,41.83 137.73,41.83 138.13,41.43 138.46,41.43 138.85,41.82 139.49,41.82 139.89,41.42 140.13,41.42 140.54,41.02 145.67,41.02 148.42,43.77 152.45,43.77 155.39,40.82 155.39,35.86 157.65,33.61 157.65,30.16 158.24,29.56 159.6,29.56 159.7,29.46 159.7,29.32 159.6,29.22 157.74,29.22 157.64,29.12 157.64,28.99 157.74,28.89 159.93,28.89 160.03,28.99 160.03,29.46 160.13,29.56 161.77,29.56 161.87,29.46 161.87,29.32 161.77,29.22 160.97,29.22 160.87,29.12 160.87,28.99 160.97,28.89 162.3,28.89 162.39,28.99 162.39,29.46 162.49,29.56 164.15,29.56 164.25,29.46 164.25,29.32 164.15,29.22 163.01,29.22 162.91,29.12 162.91,28.99 163.01,28.89 164.46,28.89 164.83,29.26 v1(164.83,32.39)
DDR4_DIMM_CH2_DQ19: length 57.7
  L12_SIG4 w0.089: v1(133.97,41.43) 134.82,41.43 135.42,40.83 137.39,40.83 137.61,40.61 139.81,40.61 140.13,40.28 145.95,40.28 148.65,42.98 152.13,42.98 154.57,40.54 154.57,34.02 154.47,33.92 154.33,33.92 154.23,34.02 154.23,37.09 154.13,37.19 154,37.19 153.9,37.09 153.9,34.59 153.8,34.49 153.66,34.49 153.56,34.59 153.56,36.27 153.46,36.37 153.33,36.37 153.23,36.27 153.23,34.33 155.01,32.55 155.01,27.76 155.25,27.52 163.39,27.52 163.94,26.97 v1(163.94,26.42)
DDR4_DIMM_CH2_DQ20: length 55.2
  L12_SIG4 w0.089: v1(138.29,42.93) 138.7,42.93 138.82,43.05 139.33,43.05 139.65,43.37 140.33,43.37 140.66,43.04 141.17,43.04 141.51,43.37 141.98,43.37 142.51,42.85 142.93,42.85 143.41,42.37 145.34,42.37 147.91,44.94 153.06,44.94 153.57,44.43 154.27,44.43 157.09,41.61 157.09,37.63 158.09,36.62 158.09,35.33 159.11,34.31 160.44,33.76 164.9,33.76 166.26,33.2 166.83,32.62 166.83,31.53 166.44,29.56 166.44,28.69 166.89,27.61 166.89,27 166.76,26.88 166.76,26.4 167.23,25.94 169.98,25.94 170.2,26.16 172.12,30.79 v1(172.44,32.42)
DDR4_DIMM_CH2_DQ21: length 54.8
  L12_SIG4 w0.089: v1(138.29,41.93) 138.41,42.05 139.47,42.05 139.73,42.31 140.27,42.31 140.68,41.91 141.06,41.91 141.43,41.53 145.69,41.53 148.3,44.14 152.6,44.14 155.76,40.98 155.76,36.09 158.5,33.36 158.5,30.97 159.4,30.07 164.08,30.07 164.35,30.34 164.35,32.55 164.61,32.82 165.1,32.82 165.37,32.56 165.37,32.17 165.18,31.98 165.18,31.48 165.44,31.21 165.44,30.82 165.54,30.72 165.86,30.72 165.96,30.62 165.96,30.47 165.86,30.37 165.54,30.37 165.44,30.27 165.44,27.17 167.07,25.54 170.72,25.54 v1(171.59,26.42)
DDR4_DIMM_CH2_DQ22: length 54.9
  L12_SIG4 w0.089: v1(137.43,42.43) 138.6,42.43 138.98,42.81 139.49,42.81 139.75,42.55 140.25,42.55 140.51,42.82 141.13,42.82 141.5,42.45 141.95,42.45 142.43,41.97 145.57,41.97 148.16,44.56 152.74,44.56 156.12,41.18 156.12,36.35 157.51,34.96 157.81,34.96 160.03,32.73 160.03,30.71 160.16,30.57 163.62,30.57 163.72,30.67 163.72,30.92 163.62,31.02 160.99,31.02 160.89,31.13 160.89,31.89 160.99,31.99 163.58,31.99 163.68,32.09 163.68,32.7 163.58,32.8 160.73,32.8 160.63,32.9 160.63,33.13 160.73,33.24 165.24,33.24 166.06,32.42 v1(166.44,32.42)
DDR4_DIMM_CH2_DQ23: length 54.7
  L12_SIG4 w0.089: v1(165.64,26.42) 164.13,27.93 155.53,27.93 155.42,28.03 155.42,28.17 155.53,28.27 157.32,28.27 157.42,28.37 157.42,28.5 157.32,28.6 155.54,28.6 155.43,28.7 155.43,28.84 155.54,28.94 157.15,28.94 157.25,29.04 157.25,29.17 157.15,29.27 155.53,29.27 155.43,29.38 155.43,29.51 155.53,29.61 157.17,29.61 157.28,29.71 157.28,29.84 157.17,29.94 155.64,29.94 155.5,30.09 155.5,31.77 155.9,32.18 155.9,32.67 155.01,33.57 155.01,40.6 152.25,43.35 148.49,43.35 145.8,40.66 140.27,40.66 139.96,40.97 137.88,40.97 v1(137.43,41.43)
DDR4_DIMM_CH2_DQ24: length 57.2
  L14_SIG5 w0.081: v1(128.77,42.43) 128.77,42.89 129.43,43.55 129.85,43.55 130.35,43.05 130.71,43.05 131.23,42.53 131.41,42.53 131.78,42.16 131.78,41.35 132.19,40.95 132.82,40.95 133.94,39.82 143.7,39.82 144.96,41.08 145.84,41.08 146.49,40.43 146.49,36.98 148.32,35.16 152.1,35.16 154.55,37.6 154.55,39 154.65,39.1 154.87,39.1 154.97,39 154.97,37.33 155.07,37.22 155.27,37.22 155.37,37.33 155.37,38.75 155.59,38.98 157.03,38.98 159.12,36.88 159.12,34.73 159.59,34.26 159.59,33.07 159.7,32.97 159.83,32.97 159.93,33.07 159.93,33.93 160.03,34.03 160.16,34.03 160.26,33.93 160.26,31.92 160.37,31.82 160.55,31.82 160.65,31.92 160.65,32.94 160.75,33.04 160.88,33.04 160.99,32.94 160.99,31.53 161.09,31.43 161.34,31.43 161.44,31.53 v1(161.44,32.41)
DDR4_DIMM_CH2_DQ25: length 56.6
  L14_SIG5 w0.081: v1(160.54,26.42) 160.95,26.82 161.14,26.82 161.29,26.67 161.29,26.46 160.66,25.83 159.82,25.83 159.72,25.93 159.72,26.62 159.62,26.72 159.48,26.72 159.39,26.62 159.39,25.93 159.29,25.83 157.79,25.83 156.43,27.2 156.43,29.34 156.33,29.45 156.2,29.45 156.1,29.34 156.1,27.31 155.99,27.21 155.86,27.21 155.76,27.31 155.76,29.35 155.66,29.45 155.51,29.45 155.41,29.35 155.41,27.56 155.31,27.46 155.17,27.46 155.07,27.56 155.07,30.26 154.29,31.05 150.36,31.05 150.28,31.12 148.05,31.12 146.38,32.79 145.85,32.79 144.44,34.2 141.28,34.2 140.48,35 135.55,35 134.29,36.25 131.91,36.25 131.12,37.04 130.34,37.04 129.67,37.71 129.67,38.94 127.48,41.13 127.48,42.14 127.76,42.42 128.06,42.42 128.77,41.7 v1(128.77,41.43)
DDR4_DIMM_CH2_DQ26: length 57.4
  L14_SIG5 w0.081: v1(155.51,32.42) 155.51,30.91 155.63,30.78 155.77,30.78 155.87,30.88 155.87,31.92 155.97,32.02 156.52,32.02 156.62,31.92 156.62,30.41 157.13,29.9 157.13,29.38 157.24,29.28 157.37,29.28 157.47,29.38 157.47,29.84 157.57,29.94 157.7,29.94 157.81,29.84 157.81,28.04 157.7,27.94 157.57,27.94 157.47,28.04 157.47,28.81 157.37,28.91 157.24,28.91 157.13,28.81 157.13,27.63 157.03,27.53 156.9,27.53 156.8,27.63 156.8,29.56 156.52,29.84 156.08,29.84 155.02,30.89 155.02,31.56 154.79,31.79 152.71,31.79 152.38,31.46 150.91,31.46 150.81,31.56 150.81,31.98 150.71,32.08 150.57,32.08 150.47,31.98 150.47,31.56 150.37,31.46 150.24,31.46 150.14,31.56 150.14,31.98 150.04,32.08 149.9,32.08 149.8,31.98 149.8,31.56 149.7,31.46 149.56,31.46 149.47,31.56 149.47,31.98 149.37,32.08 149.23,32.08 149.13,31.98 149.13,31.56 149.03,31.46 148.19,31.46 146.52,33.13 145.98,33.13 144.58,34.53 141.46,34.53 141.33,34.66 141.33,35.51 140.92,35.92 140.13,35.92 140.03,35.82 140.03,35.44 139.93,35.34 139.79,35.34 139.69,35.44 139.69,35.82 139.59,35.92 138.87,35.92 138.77,35.82 138.77,35.47 138.67,35.37 137.65,35.37 137.55,35.47 137.55,35.82 137.45,35.92 137.31,35.92 137.22,35.82 137.22,35.47 137.12,35.37 136.98,35.37 136.88,35.47 136.88,35.82 136.78,35.92 136.64,35.92 136.55,35.82 136.55,35.47 136.45,35.37 136.31,35.37 136.21,35.47 136.21,35.82 136.11,35.92 135.56,35.92 134.88,36.6 132.04,36.6 130.72,37.92 130.36,37.92 130.02,38.26 130.02,39.15 127.9,41.27 v1(127.9,41.93)
DDR4_DIMM_CH2_DQ27: length 57.5
  L14_SIG5 w0.081: v1(154.59,26.42) 154.59,26.76 154.49,26.86 154.09,26.86 153.99,26.76 153.99,26.15 154.09,26.05 154.45,26.05 154.59,25.91 154.59,25.51 154.69,25.41 154.83,25.41 154.93,25.51 154.93,26.15 155.03,26.25 155.16,26.25 155.26,26.15 155.26,25.24 155,24.98 155,23.33 155.1,23.23 155.24,23.23 155.34,23.33 155.34,24.31 155.44,24.41 155.57,24.41 155.67,24.31 155.67,23.67 155.77,23.57 157.42,23.57 157.53,23.67 157.53,24.24 157.39,24.37 156.81,24.37 156.67,24.52 156.09,24.52 155.98,24.62 155.98,24.75 156.09,24.85 156.66,24.85 156.76,24.95 156.76,25.09 156.66,25.19 155.92,25.19 155.6,25.51 155.6,26.43 154.59,27.43 154.59,30.2 154.13,30.66 150.06,30.66 149.93,30.79 147.12,30.79 145.41,32.49 145.41,32.75 144.34,33.82 141.18,33.82 140.35,34.65 135.37,34.65 134.15,35.86 131.79,35.86 130.95,36.7 130.2,36.7 129.32,37.59 129.32,38.79 127.18,40.92 127.01,40.92 126.63,41.3 126.63,42.67 126.89,42.93 v1(127.9,42.93)
DDR4_DIMM_CH2_DQ28: length 52.7
  L14_SIG5 w0.081: v1(163.15,32.41) 163.15,31.7 163.05,31.59 162.75,31.59 162.65,31.7 162.65,32.26 162.55,32.36 162.39,32.36 162.28,32.26 162.28,32.01 162.18,31.91 161.99,31.91 161.89,32.01 161.89,32.97 160.12,34.74 160.12,36.83 158.6,38.35 158.17,38.35 157.12,39.4 157.12,39.58 156.83,39.88 156.46,39.88 156.24,40.09 156.24,40.75 156.14,40.85 156.01,40.85 155.91,40.75 155.91,39.46 155.81,39.36 155.68,39.36 155.57,39.46 155.57,40.8 155.47,40.9 155.34,40.9 155.24,40.8 155.24,39.59 155.14,39.49 155.01,39.49 154.9,39.59 154.9,40.82 154.8,40.92 154.67,40.92 154.57,40.82 154.57,39.97 154.47,39.87 154.33,39.87 154.23,39.97 154.23,40.95 152.21,42.97 148.54,42.97 147.14,41.58 146.76,41.58 146.66,41.48 146.66,41.09 146.57,40.99 146.43,40.99 146.33,41.09 146.33,41.48 146.23,41.58 144.89,41.58 143.49,40.17 135.91,40.17 135.81,40.27 135.81,40.62 135.71,40.72 135.58,40.72 135.48,40.62 135.48,40.27 135.38,40.17 134.07,40.17 133.98,40.27 133.98,40.41 134.07,40.51 134.98,40.51 135.07,40.61 135.07,40.75 134.98,40.84 133.45,40.84 132.86,41.43 v1(132.23,41.43)
DDR4_DIMM_CH2_DQ29: length 52.5
  L14_SIG5 w0.081: v1(162.24,26.42) 162.24,26.95 163.54,28.25 163.54,32.65 162.57,33.63 162.57,34.28 162.46,34.38 162.27,34.38 162.17,34.28 162.17,33.84 162.07,33.73 161.93,33.73 161.82,33.84 161.82,34.83 161.72,34.93 161.58,34.93 161.48,34.83 161.48,34.27 161.38,34.16 161.22,34.16 161.12,34.27 161.12,36.56 156.67,41.01 156.47,41.01 156.2,41.28 154.51,41.28 152.39,43.41 148.38,43.41 147.71,42.74 145.46,42.74 145.36,42.64 145.36,42.5 145.46,42.4 147.13,42.4 147.23,42.3 147.23,42.16 147.13,42.07 144.83,42.07 143.27,40.51 136.71,40.51 136.2,41.02 135.54,41.02 135.05,41.5 134.6,41.5 134.24,41.86 133.74,41.86 133.3,42.3 132.66,42.3 132.54,42.43 v1(132.23,42.43)
DDR4_DIMM_CH2_DQ30: length 54.4
  L14_SIG5 w0.081: v1(131.37,41.93) 131.37,42.09 130.65,42.81 130.29,42.81 129.77,43.34 129.51,43.34 129.17,42.99 129.17,40.52 130.91,38.77 130.91,38.25 131.01,38.14 131.28,38.14 131.38,38.25 131.38,38.34 131.48,38.44 131.69,38.44 131.8,38.34 131.8,37.33 132.17,36.95 136.06,36.95 136.16,36.85 136.16,36.33 136.26,36.23 136.4,36.23 136.49,36.33 136.49,37.09 136.59,37.19 136.73,37.19 136.83,37.09 136.83,36.33 136.93,36.23 137.07,36.23 137.17,36.33 137.17,37.09 137.26,37.19 137.4,37.19 137.5,37.09 137.5,36.33 137.6,36.23 137.74,36.23 137.84,36.33 137.84,37.1 137.93,37.2 138.07,37.2 138.17,37.1 138.17,36.06 138.27,35.96 138.41,35.96 138.51,36.06 138.51,36.85 138.6,36.95 139.61,36.95 139.71,36.85 139.71,36.35 139.8,36.25 139.94,36.25 140.04,36.35 140.04,36.85 140.14,36.95 140.87,36.95 141.6,36.21 141.8,36.21 141.9,36.11 141.9,35.98 141.8,35.87 141.74,35.87 141.64,35.77 141.64,35.64 141.74,35.54 142.48,35.54 142.59,35.44 142.59,35.31 142.48,35.2 141.78,35.2 141.68,35.1 141.68,34.97 141.78,34.87 144.72,34.87 146.12,33.47 146.68,33.47 147.32,32.83 150.78,32.83 150.95,32.65 150.95,32.33 151.06,32.23 151.19,32.23 151.29,32.33 151.29,32.74 151.39,32.84 151.52,32.84 151.62,32.74 151.62,32.07 151.73,31.96 152.37,31.96 152.47,32.07 152.47,32.73 152.58,32.83 152.75,32.83 152.85,32.73 152.85,32.27 152.96,32.17 153.09,32.17 153.19,32.27 153.19,32.69 153.32,32.83 154.62,32.83 154.72,32.73 154.72,32.59 154.62,32.49 154.16,32.49 154.06,32.39 154.06,32.25 154.16,32.16 154.98,32.16 155.07,32.25 155.07,32.73 155.17,32.83 155.75,32.83 156.16,32.42 v1(157.09,32.42)
DDR4_DIMM_CH2_DQ31: length 54.7
  L14_SIG5 w0.081: v1(131.37,42.93) 132.41,42.93 132.79,42.56 133.39,42.56 133.64,42.8 134.21,42.8 134.62,42.39 135.05,42.39 135.55,41.9 135.79,41.9 136.15,41.53 136.62,41.53 137.31,40.84 143.04,40.84 145.34,43.15 147.35,43.15 148.07,43.87 152.56,43.87 154.59,41.84 156.77,41.84 162.1,36.51 162.19,36.29 162.55,35.93 162.77,35.84 163.04,35.57 164.4,33.53 164.4,29.04 163.54,26.96 162.72,26.14 161.1,25.47 157.7,25.47 156.91,25.8 v1(156.29,26.42)
DDR4_DIMM_CH2_DQ32: length 45.5
  L16_SIG6 w0.081: v1(106.12,32.42) 106.3,32.6 106.94,32.6 107.48,32.05 107.48,31.67 107.31,31.5 107.31,27.94 107.41,27.84 107.55,27.84 107.65,27.94 107.65,29.52 107.75,29.62 107.88,29.62 107.98,29.52 107.98,27.97 108.08,27.87 108.22,27.87 108.32,27.97 108.32,29.94 110.71,32.34 117.03,32.34 117.45,32.75 118.14,32.75 119.26,33.86 119.49,33.86 120.31,34.69 121.66,34.69 122.26,35.3 122.26,35.72 123.27,36.72 123.86,36.72 125.19,38.06 125.46,38.06 126.55,39.14 126.55,43.26 126.32,43.49 126.08,43.49 125.74,43.83 125.74,45.53 125.46,45.8 124.85,45.8 124.61,45.55 124.28,45.55 123.81,46.02 123.34,46.02 122.97,45.65 122.97,45.19 v1(122.71,44.93)
DDR4_DIMM_CH2_DQ33: length 45.4
  L16_SIG6 w0.081: v1(105.29,26.42) 104.69,25.82 104.69,25.67 104.79,25.57 108.49,25.57 109.91,26.99 109.91,27.84 112,29.92 116.77,29.92 117.76,30.91 118.15,30.91 118.92,31.68 119.39,31.68 121.32,33.61 122.28,33.61 124.93,36.26 125.87,36.26 128.34,38.73 128.34,44.09 127.9,44.53 127.77,44.53 127.24,45.06 126.83,45.06 126.38,45.5 126.07,45.5 125.26,46.31 122.53,46.31 122.27,46.06 122.27,44.83 122.71,44.4 v1(122.71,43.93)
DDR4_DIMM_CH2_DQ34: length 45.3
  L16_SIG6 w0.081: v1(121.84,44.43) 121.4,43.99 121.4,41.83 121.1,41.52 121.1,40.6 120.32,39.82 119.84,39.82 118.86,38.85 118.21,38.85 117.74,38.37 117.26,38.37 116.82,37.93 114.69,37.93 114.16,37.4 112.95,37.4 112.58,37.03 107.47,37.03 106.89,36.45 105.52,36.45 104.91,35.83 104.35,35.83 103.38,34.86 102.94,34.86 100.58,32.5 100.58,31.44 99.25,30.12 99.25,29.2 98.95,28.9 96.98,28.9 96.88,29 96.88,29.14 96.98,29.24 98.51,29.24 98.61,29.34 98.61,29.47 98.51,29.57 96.99,29.57 96.89,29.67 96.89,29.81 96.99,29.91 98.56,29.91 98.66,30.01 98.66,30.14 98.56,30.24 97.83,30.24 97.73,30.34 97.73,30.48 97.85,30.6 99.15,30.6 100.19,31.64 v1(100.19,32.42)
DDR4_DIMM_CH2_DQ35: length 45.4
  L16_SIG6 w0.081: v1(121.84,45.43) 121.84,44.96 122.24,44.56 122.24,42.3 122.07,42.13 122.07,42.01 121.94,41.88 121.76,41.88 121.46,41.58 121.46,40.25 120.13,38.92 119.8,38.92 118.82,37.94 117.33,37.94 117.03,37.63 117.03,37.25 116.81,37.04 113.12,37.04 112.77,36.68 107.6,36.68 107.03,36.11 105.84,36.11 103.76,34.03 102.66,34.03 101.35,32.71 101.35,30.89 101.09,30.63 100.4,30.63 99.7,29.94 99.7,29.02 99.21,28.52 97.4,28.52 97.3,28.42 97.3,28.28 97.4,28.18 99.03,28.18 99.14,28.08 99.14,27.94 99.03,27.84 97.9,27.84 97.8,27.74 97.8,27.61 97.9,27.51 99.11,27.51 99.21,27.41 99.21,27.27 99.11,27.17 97.91,27.17 97.81,27.07 97.81,26.94 97.91,26.84 98.92,26.84 v1(99.34,26.42)
DDR4_DIMM_CH2_DQ36: length 44.7
  L16_SIG6 w0.081: v1(125.31,44.43) 125.53,44.21 125.53,43.74 125.77,43.49 125.77,41.5 125.87,41.41 126.06,41.41 126.15,41.31 126.15,41.17 126.06,41.07 125.64,41.07 125.54,40.97 125.54,40.83 125.64,40.74 126.06,40.74 126.15,40.64 126.15,40.5 126.06,40.4 125.63,40.4 125.53,40.3 125.53,40.16 125.63,40.07 126.06,40.07 126.15,39.97 126.15,39.83 126.06,39.73 125.87,39.73 125.77,39.63 125.77,39.25 125.45,38.93 124.81,38.93 124.71,38.83 124.71,38.69 124.93,38.46 124.93,38.33 124.83,38.23 124.69,38.23 124.47,38.45 124.33,38.45 124.24,38.35 124.24,38.21 124.46,37.99 124.46,37.85 124.36,37.75 124.22,37.75 124,37.98 123.52,37.98 123.11,37.57 123.11,37.06 121.93,35.88 121.66,35.88 120.83,35.04 120.03,35.04 119.21,34.22 118.68,34.22 118.58,34.12 118.58,33.74 118.48,33.64 118.34,33.64 118.24,33.74 118.24,34.12 118.14,34.22 118.01,34.22 117.91,34.12 117.91,33.21 117.81,33.11 117.67,33.11 117.57,33.21 117.57,34.12 117.47,34.22 117.33,34.22 117.24,34.12 117.24,33.7 117.14,33.6 117,33.6 116.9,33.7 116.9,34.12 116.8,34.22 116.66,34.22 116.57,34.12 116.57,32.82 116.47,32.72 116.33,32.72 116.23,32.82 116.23,34.12 116.13,34.22 115.99,34.22 115.9,34.12 115.9,32.78 115.8,32.68 115.66,32.68 115.56,32.78 115.56,34.11 115.46,34.21 115.33,34.21 115.22,34.11 115.22,33.71 115.12,33.61 114.99,33.61 114.89,33.71 114.89,33.83 114.79,33.93 114.66,33.93 114.55,33.83 114.55,32.82 114.45,32.71 114.32,32.71 114.22,32.82 114.22,33.15 114.12,33.25 113.99,33.25 113.88,33.15 113.88,32.83 113.78,32.72 110.53,32.72 108.24,30.43 108.11,30.43 108.01,30.53 108.01,32.28 v1(107.87,32.42)
DDR4_DIMM_CH2_DQ37: length 42.5
  L16_SIG6 w0.081: v1(106.99,26.42) 107.58,27.01 107.99,27.01 109.15,28.17 109.15,29.91 109.25,30.01 109.39,30.01 109.49,29.91 109.49,28.75 109.58,28.65 109.72,28.65 109.82,28.75 109.82,30.72 109.92,30.82 110.06,30.82 110.16,30.72 110.16,29.43 110.25,29.33 110.39,29.33 110.49,29.43 110.49,30.78 111.67,31.96 112.4,31.96 112.5,31.86 112.5,30.75 112.6,30.65 112.74,30.65 112.83,30.75 112.83,31.86 112.93,31.96 114.41,31.96 114.51,31.86 114.51,31.46 114.61,31.36 114.75,31.36 114.84,31.46 114.84,31.86 114.94,31.96 117.14,31.96 117.55,32.38 118.98,32.38 120.94,34.34 121.97,34.34 122.62,35 122.62,35.56 123.4,36.33 123.99,36.33 124.69,37.03 125.57,37.03 126.47,37.93 126.47,38.44 126.91,38.88 127.09,38.88 127.41,39.2 127.41,41.6 127.25,41.76 127.25,42.11 127.42,42.28 127.42,42.58 127.26,42.74 127.26,43.12 127.42,43.29 127.42,43.58 127.07,43.93 v1(126.17,43.93)
DDR4_DIMM_CH2_DQ38: length 44.5
  L16_SIG6 w0.081: v1(101.89,32.42) 101.89,32.71 102.86,33.67 104.05,33.67 105.41,35.04 106.77,35.04 106.89,35.16 106.89,35.54 107,35.64 107.13,35.64 107.23,35.54 107.23,35.02 107.33,34.91 107.46,34.91 107.56,35.02 107.56,36.12 107.66,36.22 107.8,36.22 107.9,36.12 107.9,35.93 108,35.83 108.14,35.83 108.24,35.93 108.24,36.23 108.33,36.33 108.47,36.33 108.57,36.23 108.57,35.01 108.67,34.91 108.81,34.91 108.91,35.01 108.91,36.23 109,36.33 109.14,36.33 109.24,36.23 109.24,35.82 109.34,35.73 109.48,35.73 109.58,35.82 109.58,36.23 109.67,36.33 109.81,36.33 109.91,36.23 109.91,35.77 110.01,35.67 110.15,35.67 110.25,35.77 110.25,36.23 110.34,36.33 110.48,36.33 110.58,36.23 110.58,35.69 110.68,35.59 110.82,35.59 110.92,35.69 110.92,36.23 111.02,36.33 111.15,36.33 111.25,36.23 111.25,35.69 111.35,35.59 111.49,35.59 111.59,35.69 111.59,36.23 111.69,36.33 111.82,36.33 111.92,36.23 111.92,35.69 112.02,35.59 112.16,35.59 112.26,35.69 112.26,36.23 112.36,36.33 112.5,36.33 112.59,36.23 112.59,35.93 112.69,35.83 113.14,35.83 113.94,36.63 117.18,36.63 117.6,37.05 117.6,37.47 117.7,37.57 117.84,37.57 117.94,37.47 117.94,37.13 118.03,37.04 118.53,37.04 119.49,38 120.29,38 120.5,38.22 120.5,38.81 122.3,40.61 122.3,42.04 122.7,42.45 122.83,42.45 123.2,42.82 123.2,45.58 123.42,45.81 123.72,45.81 124.23,45.3 125.18,45.3 v1(125.31,45.43)
DDR4_DIMM_CH2_DQ39: length 42.8
  L16_SIG6 w0.081: v1(126.17,44.93) 126.29,44.81 127.18,44.81 127.5,44.49 127.5,43.81 127.68,43.63 127.68,43.24 127.53,43.08 127.53,42.78 127.68,42.62 127.68,42.24 127.52,42.09 127.52,41.78 127.87,41.43 127.87,38.74 125.79,36.66 124.85,36.66 124.11,35.92 123.47,35.92 122.96,35.41 122.96,34.82 122.13,34 121.08,34 119.1,32.01 117.83,32.01 116.65,30.84 113.59,30.84 113.06,30.31 111.9,30.31 108.18,26.59 107.83,26.59 107.17,25.92 106.57,25.92 105.62,26.88 105.04,26.88 104.16,26 101.65,26 101.45,25.8 101.45,25.27 101.35,25.17 101.14,25.17 101.04,25.27 v1(101.04,26.42)
DDR4_DIMM_CH2_DQ40: length 54
  L12_SIG4 w0.089: v1(96.79,32.41) 96.79,31.48 96.07,30.76 96.07,29.76 96.17,29.66 97.08,29.66 97.18,29.56 97.18,29.43 97.08,29.33 96.27,29.33 96.17,29.23 96.17,29.09 96.27,28.99 97.19,28.99 97.29,28.89 97.29,28.76 97.19,28.66 96.14,28.66 96.03,28.56 96.03,28.42 96.14,28.32 98.04,28.32 98.14,28.22 98.14,28.09 98.04,27.99 97.44,27.99 97.34,27.88 97.34,27.75 97.44,27.65 102.26,27.65 105.15,30.55 107.31,30.55 107.72,30.96 118.2,30.96 118.7,31.45 119.92,31.45 121.2,32.74 121.88,32.74 124.34,35.2 124.34,35.92 125.83,37.41 125.83,40 125.63,40.2 125.63,41.21 125.71,41.29 125.71,41.55 125.56,41.7 125.56,42.16 125.68,42.28 125.68,42.58 125.23,43.04 125.16,43.04 124.66,43.55 124.06,43.55 123.8,43.81 123.39,43.81 123.15,43.56 123.15,43.37 v1(122.71,42.93)
DDR4_DIMM_CH2_DQ41: length 53.3
  L12_SIG4 w0.089: v1(95.94,26.42) 94.93,25.4 94.78,25.4 94.48,25.7 94.48,25.84 96.09,27.45 97.08,27.45 97.32,27.21 102.3,27.21 105.25,30.16 107.58,30.16 107.77,30.35 108.84,30.35 109.16,30.04 111.61,30.04 111.84,30.27 113.32,30.27 113.62,29.98 118.18,29.98 119.16,30.96 120.69,30.96 121.72,31.98 122.45,31.98 122.89,32.42 122.89,33.15 124.83,35.09 124.83,35.83 126.19,37.19 126.19,40.15 125.92,40.42 125.92,41.12 126,41.19 126,41.56 125.79,41.77 125.79,42.08 125.91,42.2 125.91,42.65 125.76,42.81 125.76,43.51 125.38,43.89 125.11,43.89 124.69,44.31 124.12,44.31 123.86,44.05 123.24,44.05 122.99,44.3 122.55,44.3 122.33,44.08 122.33,43.77 122.49,43.61 122.49,43.25 122.33,43.08 122.33,42.77 122.47,42.64 122.47,42.64 122.71,42.4 v1(122.71,41.93)
DDR4_DIMM_CH2_DQ42: length 53.2
  L12_SIG4 w0.089: v1(121.84,41.43) 121.47,41.05 121.47,39.76 120.57,38.86 120.57,38.34 120.04,37.82 119.83,37.82 118.69,36.68 118.14,36.68 117.36,35.9 114.41,35.9 114.31,35.8 114.31,35.5 114.21,35.4 114,35.4 113.9,35.5 113.9,36.33 113.81,36.43 113.65,36.43 113.56,36.33 113.56,35.91 113.46,35.81 113.01,35.81 112.67,36.15 112.53,36.15 112.44,36.05 112.44,35.48 112.34,35.39 112.2,35.39 112.1,35.48 112.1,35.87 112,35.97 111.86,35.97 111.77,35.87 111.77,35.48 111.67,35.39 111.53,35.39 111.43,35.48 111.43,35.87 111.33,35.97 111.19,35.97 111.09,35.87 111.09,35.48 111,35.39 110.86,35.39 110.76,35.48 110.76,35.88 110.66,35.98 110.52,35.98 110.42,35.88 110.42,35.54 110.32,35.44 110.19,35.44 110.09,35.54 110.09,35.73 109.99,35.83 104.21,35.83 104.02,35.64 102.54,35.64 102.19,35.99 100.54,35.99 100.19,36.34 95.95,36.34 95.34,35.73 95.34,35.62 94.27,34.55 93.4,34.55 91.25,32.4 91.25,26.89 91.15,26.79 90.94,26.79 90.84,26.89 v1(90.84,32.42)
DDR4_DIMM_CH2_DQ43: length 53.6
  L12_SIG4 w0.089: v1(121.84,42.43) 121.84,42.12 121.08,41.36 121.08,39.87 120.15,38.94 120.01,38.94 119.58,38.5 119.58,38.09 118.52,37.04 118.01,37.04 117.31,36.34 114.57,36.34 114.04,36.87 112.41,36.87 111.9,36.36 103.62,36.36 103.28,36.01 102.67,36.01 102.33,36.34 100.73,36.34 100.4,36.68 95.6,36.68 95.21,36.3 95.21,36.11 95,35.89 95,35.77 94.13,34.9 93.06,34.9 90.98,32.81 90.69,32.81 90.41,32.54 90.41,26.1 90.64,25.87 93.89,25.87 94.07,25.69 94.07,25.48 93.89,25.3 90.24,25.3 89.99,25.55 v1(89.99,26.42)
DDR4_DIMM_CH2_DQ44: length 50.3
  L12_SIG4 w0.089: v1(98.49,32.41) 98.73,32.18 99.32,32.18 99.43,32.08 99.43,31.94 99.32,31.84 97.53,31.84 97.43,31.74 97.43,31.53 97.53,31.43 98.12,31.43 98.22,31.33 98.22,30.51 98.12,30.41 97.59,30.41 97.49,30.31 97.49,30.17 97.59,30.07 98.29,30.07 98.39,29.97 98.39,29.84 98.29,29.74 97.74,29.74 97.64,29.64 97.64,29.5 97.74,29.4 98.61,29.4 98.71,29.3 98.71,29.17 98.61,29.07 97.84,29.07 97.74,28.97 97.74,28.83 97.84,28.73 100.36,28.73 100.46,28.63 100.46,28.5 100.36,28.4 98.9,28.4 98.8,28.29 98.8,28.16 98.9,28.06 102.13,28.06 105.06,30.99 106.87,30.99 107.68,31.8 119.56,31.8 121.53,33.78 122.23,33.78 123.07,34.62 123.07,35.51 124.89,37.33 124.89,39.58 125.29,39.99 125.29,41.42 v1(125.31,41.43)
DDR4_DIMM_CH2_DQ45: length 49.9
  L12_SIG4 w0.089: v1(97.64,26.42) 98.06,26.83 103.22,26.83 103.54,27.15 103.54,27.87 103.64,27.97 103.78,27.97 103.88,27.87 103.88,27.35 103.98,27.25 104.11,27.25 104.21,27.35 104.21,28.62 104.32,28.72 104.45,28.72 104.55,28.62 104.55,27.41 104.65,27.31 104.78,27.31 104.88,27.41 104.88,29.16 105.43,29.71 107.66,29.71 107.83,29.88 108.82,29.88 109.05,29.66 111.76,29.66 111.91,29.81 113.13,29.81 113.35,29.59 118.97,29.59 119.12,29.74 119.12,30.42 119.22,30.52 119.36,30.52 119.46,30.42 119.46,29.74 119.56,29.64 119.69,29.64 119.79,29.74 119.79,30.42 119.89,30.52 120.03,30.52 120.13,30.42 120.13,29.74 120.23,29.64 120.75,29.64 121.3,30.19 121.3,30.33 121,30.63 121,30.77 121.09,30.87 121.23,30.87 121.59,30.51 121.73,30.51 121.82,30.61 121.82,30.75 121.47,31.11 121.47,31.24 121.57,31.34 121.71,31.34 122.01,31.04 122.15,31.04 123.36,32.25 123.36,32.89 125.78,35.31 125.78,36.14 126.55,36.91 126.55,40.27 126.24,40.58 126.24,41.86 v1(126.17,41.93)
DDR4_DIMM_CH2_DQ46: length 50.3
  L12_SIG4 w0.089: v1(92.54,32.42) 93.96,33.84 94.53,33.84 95.51,34.82 96.33,34.82 96.45,34.95 96.45,35.4 96.55,35.49 97.07,35.49 97.17,35.4 97.17,35.26 97.07,35.16 96.91,35.16 96.81,35.06 96.81,34.92 96.91,34.82 97.87,34.82 98,34.95 98,35.4 98.1,35.49 98.71,35.49 98.81,35.4 98.81,35.26 98.71,35.16 98.49,35.16 98.39,35.06 98.39,34.92 98.49,34.82 99.4,34.82 99.51,34.92 99.51,35.17 99.61,35.27 99.75,35.27 99.85,35.17 99.85,34.92 99.95,34.82 100.09,34.82 100.19,34.92 100.19,35.17 100.29,35.27 100.43,35.27 100.53,35.17 100.53,34.92 100.63,34.82 100.78,34.82 100.88,34.92 100.88,35.17 100.98,35.27 101.12,35.27 101.22,35.17 101.22,34.92 101.32,34.82 101.46,34.82 101.56,34.92 101.56,35.17 101.66,35.27 101.8,35.27 101.91,35.17 101.91,34.92 102.01,34.82 103.29,34.82 103.61,34.5 117.5,34.5 117.6,34.6 117.6,35.02 117.7,35.12 117.83,35.12 117.93,35.02 117.93,34.61 118.03,34.51 118.17,34.51 118.27,34.61 118.27,34.95 118.37,35.05 118.5,35.05 118.6,34.95 118.6,34.66 118.7,34.56 118.84,34.56 118.94,34.66 118.94,35.92 119.04,36.02 119.17,36.02 119.27,35.92 119.27,35.25 119.37,35.15 119.51,35.15 119.61,35.25 119.61,36.53 119.93,36.86 120.1,36.86 121.44,38.19 121.44,38.75 122.33,39.65 122.33,41.02 123.08,41.77 123.08,42.85 123.22,42.98 123.86,42.98 124.19,43.32 124.59,43.32 124.83,43.08 124.83,42.91 v1(125.31,42.43)
DDR4_DIMM_CH2_DQ47: length 50.9
  L12_SIG4 w0.089: v1(91.69,26.42) 92.11,30.63 92.11,32.44 92.18,32.62 93.65,34.09 93.87,34.18 94.39,34.18 95.68,35.48 95.68,35.58 95.98,35.88 100.01,35.88 100.25,35.63 102.05,35.63 102.49,35.18 103.73,35.18 104.4,34.91 116.88,34.91 118.23,36.26 118.78,36.26 119.88,37.35 120.11,37.35 121,38.25 121,38.8 121.86,39.66 121.86,40.9 122.26,41.29 122.26,42.55 122.08,42.73 122.08,43.13 122.23,43.29 122.23,43.57 122.06,43.74 122.06,44.12 122.5,44.55 123.02,44.55 123.3,44.83 123.82,44.83 124.1,44.55 124.67,44.55 124.97,44.84 125.42,44.84 125.75,44.52 125.75,43.82 126.17,43.4 v1(126.17,42.93)
DDR4_DIMM_CH2_DQ48: length 59.8
  L12_SIG4 w0.089: v1(87.52,32.42) 88.08,31.44 88.08,28.55 87.81,28.27 86.59,28.27 86.09,27.77 84.7,27.77 84.47,28 84.47,30.95 84.82,31.3 84.82,31.95 84.52,32.26 84.52,33.7 86.81,35.99 87.68,35.99 88.63,36.94 88.92,36.94 89.86,37.87 89.86,38.02 89.64,38.23 89.64,38.38 89.74,38.48 89.88,38.48 90.5,37.85 90.65,37.85 90.74,37.95 90.74,38.09 90.07,38.75 90.07,38.9 90.17,39 90.32,39 90.98,38.33 91.12,38.33 91.22,38.43 91.22,38.57 90.57,39.23 90.57,39.37 90.67,39.47 90.81,39.47 91.47,38.82 91.61,38.82 91.71,38.92 91.71,39.06 91.18,39.58 91.18,39.73 91.28,39.83 91.43,39.83 91.95,39.3 92.09,39.3 92.19,39.4 92.19,39.67 92.31,39.79 92.58,39.79 93.48,40.68 96.24,40.68 96.61,41.05 101.36,41.05 101.76,40.65 105.58,40.65 105.95,41.02 111.21,41.02 111.34,40.9 111.61,40.9 111.74,41.02 116.94,41.02 117.18,41.26 117.18,41.74 116.89,42.03 116.72,42.03 116.43,41.74 116.26,41.74 116.18,41.82 116.18,41.96 v1(116.65,42.43)
DDR4_DIMM_CH2_DQ49: length 59.4
  L12_SIG4 w0.089: v1(86.67,26.42) 87.86,25.22 87.86,23.31 86.82,22.27 83.92,22.27 82.74,23.44 82.74,25 83.58,25.84 83.58,26.87 84.06,28.02 84.06,31.13 84.45,31.52 84.45,31.84 84.17,32.12 84.17,33.85 87.26,36.93 87.7,36.93 87.91,37.14 87.91,37.24 90.86,40.2 92.27,40.2 93.1,41.03 95.99,41.03 96.44,41.48 97,41.48 97.34,41.82 97.83,41.82 98.18,41.46 98.6,41.46 99,41.86 99.57,41.86 99.97,41.46 100.41,41.46 100.75,41.81 101.37,41.81 102.12,41.05 105.16,41.05 105.92,41.81 106.53,41.81 106.85,41.49 107.33,41.49 107.64,41.8 108.32,41.8 108.66,41.46 109.07,41.46 109.42,41.81 110,41.81 110.35,41.46 110.75,41.46 111.1,41.82 111.75,41.82 112.07,41.5 112.58,41.5 112.96,41.87 113.42,41.87 113.83,41.46 114.35,41.46 114.69,41.8 115.1,41.8 115.48,41.43 v1(116.65,41.43)
DDR4_DIMM_CH2_DQ50: length 60.5
  L12_SIG4 w0.089: v1(81.49,32.42) 81.49,32.9 81.81,33.21 83.38,33.21 83.48,33.32 83.48,33.42 83.38,33.52 82.36,33.52 82.26,33.62 82.26,33.72 82.36,33.82 83.38,33.82 83.48,33.93 83.48,34.05 83.38,34.15 82.94,34.15 82.84,34.25 82.84,34.38 82.94,34.48 83.79,34.48 86.58,37.27 86.58,38.24 88.28,39.94 88.42,39.94 88.52,39.84 88.52,39.7 87.23,38.42 87.23,38.28 87.33,38.18 87.47,38.18 88.92,39.63 88.92,39.93 88.71,40.13 88.71,40.37 89.47,41.13 89.61,41.13 89.71,41.03 89.71,40.89 89.19,40.37 89.19,40.23 89.29,40.13 89.42,40.13 90.29,41 91.19,41 91.32,41.14 91.32,41.45 91.42,41.55 91.56,41.55 91.67,41.45 91.67,41.1 91.76,41 91.9,41 92,41.1 92,41.64 92.26,41.9 92.55,41.9 92.96,42.31 93.63,42.31 93.9,42.04 94.29,42.04 94.74,42.49 95.23,42.49 95.72,42.97 96.15,42.97 96.48,43.31 97.02,43.31 97.42,42.91 97.75,42.91 98.15,43.31 98.76,43.31 99.02,43.05 99.67,43.05 99.94,43.32 100.52,43.32 100.9,42.94 101.33,42.94 101.74,42.54 102.32,42.54 102.59,42.81 102.96,42.81 103.33,42.44 103.94,42.44 104.31,42.81 104.74,42.81 105.36,43.43 105.7,43.43 106.09,43.04 106.46,43.04 106.89,43.47 107.33,43.47 107.78,43.92 108.19,43.92 108.65,43.46 109.06,43.46 109.51,43.9 109.93,43.9 110.36,43.47 110.81,43.47 111.37,44.03 111.71,44.03 111.89,43.86 111.89,43.54 112.09,43.33 112.61,43.33 112.76,43.48 112.76,43.87 112.92,44.03 113.38,44.03 113.6,43.82 113.6,43.59 113.73,43.46 114.41,43.46 114.51,43.56 114.51,43.87 114.68,44.04 115.17,44.04 115.33,43.88 115.33,43.62 115.46,43.49 116.04,43.49 116.52,43.02 116.52,42.84 116.02,42.34 115.84,42.34 115.55,42.63 115.41,42.63 115.3,42.52 115.3,42.4 v1(115.78,41.93)
DDR4_DIMM_CH2_DQ51: length 60.4
  L12_SIG4 w0.089: v1(80.64,26.42) 80.64,27.28 80.74,27.39 80.96,27.39 81.06,27.28 81.06,25.96 80.96,25.86 79.58,25.86 79.48,25.75 79.48,25.61 79.58,25.51 80.96,25.51 81.06,25.41 81.06,23.14 81.16,23.04 81.81,23.04 81.91,23.14 81.91,25.31 82.79,26.19 82.79,26.43 82.98,26.88 83.68,28.2 83.68,30.95 83.67,31.08 83.67,31.88 83.83,32.04 83.83,33.99 87.05,37.21 87.05,37.61 87.26,37.82 87.99,37.82 90.84,40.67 92.19,40.67 93.03,41.51 93.59,41.51 93.88,41.81 94.36,41.81 94.63,41.54 95.21,41.54 95.6,41.93 96.03,41.93 96.45,42.35 97,42.35 97.32,42.03 97.88,42.03 98.28,42.44 98.66,42.44 99.04,42.82 99.51,42.82 99.89,42.45 100.39,42.45 100.79,42.05 101.35,42.05 101.61,42.31 102.15,42.31 102.52,41.94 102.92,41.94 103.33,41.52 103.92,41.52 104.33,41.93 104.73,41.93 105.25,42.45 105.62,42.45 105.97,42.8 106.53,42.8 106.88,42.46 107.36,42.46 107.81,42.91 108.15,42.91 108.62,42.44 109.06,42.44 109.54,42.91 109.85,42.91 110.34,42.42 110.75,42.42 111.27,42.94 111.59,42.94 112.1,42.43 112.51,42.43 113.01,42.94 113.34,42.94 113.83,42.44 114.26,42.44 114.75,42.93 v1(115.78,42.93)
DDR4_DIMM_CH2_DQ52: length 56.6
  L12_SIG4 w0.089: v1(120.11,42.43) 120.44,42.76 120.58,42.76 120.77,42.57 120.77,42.43 120.28,41.94 119.91,41.94 119.72,41.75 119.72,40.07 118.65,38.99 118.22,38.99 117.19,37.97 116.46,37.97 116.37,38.06 115.73,38.06 115.64,37.96 115.64,37.82 115.73,37.72 116.16,37.72 116.26,37.62 116.26,37.48 116.16,37.39 115.4,37.39 115.3,37.48 115.3,37.94 115.2,38.04 114.85,38.04 114.65,37.84 114.31,37.84 114.09,38.06 113.76,38.06 113.54,37.84 113.2,37.84 112.98,38.06 112.64,38.06 112.42,37.84 112.09,37.84 111.94,37.98 111.17,37.98 111.07,37.89 111.07,37.48 110.98,37.39 110.2,37.39 110.1,37.48 110.1,37.62 110.2,37.72 110.62,37.72 110.72,37.82 110.72,37.96 110.62,38.06 109.97,38.06 109.85,37.94 109.44,37.94 109.34,37.84 109.34,37.48 109.24,37.39 108.48,37.39 108.38,37.48 108.38,37.62 108.48,37.72 108.89,37.72 108.99,37.82 108.99,38.02 108.89,38.11 108.25,38.11 108.11,37.97 107.78,37.97 107.6,37.79 107.6,37.48 107.51,37.39 106.73,37.39 106.63,37.48 106.63,37.62 106.73,37.72 107.14,37.72 107.24,37.82 107.24,38 107.14,38.1 106.51,38.1 106.35,37.94 106.2,37.94 106.04,38.1 105.4,38.1 105.3,38 105.3,37.82 105.4,37.72 105.77,37.72 105.87,37.62 105.87,37.48 105.77,37.39 105.06,37.39 104.97,37.48 104.97,37.96 104.87,38.06 104.66,38.06 104.58,37.98 104.41,37.98 104.25,38.14 103.67,38.14 103.57,38.04 103.57,37.82 103.67,37.72 104.02,37.72 104.12,37.62 104.12,37.48 104.02,37.39 103.34,37.39 103.24,37.48 103.24,38.08 103.14,38.18 102.43,38.18 102.34,38.08 102.34,37.48 102.24,37.39 101.54,37.39 101.44,37.48 101.44,37.62 101.54,37.72 101.9,37.72 102,37.82 102,38.02 101.9,38.12 101.3,38.12 101.13,37.95 100.86,37.95 100.6,38.21 98.23,38.21 98.06,38.04 96.61,38.04 96.44,37.88 96.31,37.88 96.21,37.98 96.21,38.09 96.11,38.19 95.97,38.19 95.87,38.09 95.87,37.98 95.77,37.88 95.63,37.88 95.54,37.98 95.54,38.1 95.44,38.2 95.24,38.2 95.14,38.1 95.14,37.76 95.04,37.66 94.91,37.66 94.81,37.76 94.81,38.07 94.71,38.17 94.49,38.17 94.15,37.84 93.91,37.84 93.74,37.67 93.74,36.76 92.89,35.91 92.57,35.91 90.86,34.2 90.61,34.2 89.14,32.73 v1(89.14,32.42)
DDR4_DIMM_CH2_DQ53: length 56.7
  L12_SIG4 w0.089: v1(120.11,41.43) 120.49,41.05 120.49,40.18 120.25,39.95 120.09,39.95 118.84,38.69 118.84,38.32 118.47,37.95 117.93,37.95 116.93,36.95 114.82,36.95 114.28,37.49 112.07,37.49 111.54,36.96 100.99,36.96 100.18,37.77 99.19,37.77 99.1,37.68 97.11,37.68 96.88,37.45 95.47,37.45 94.62,36.59 94.62,36.35 94.1,35.83 93.81,35.83 93.55,35.57 92.71,35.57 90.55,33.41 90.42,33.41 89.68,32.67 89.61,32.5 89.61,27.18 89.3,26.87 89.01,26.87 88.73,26.59 88.73,25.88 89.53,25.08 89.53,24.58 89.74,24.37 92.76,24.37 92.86,24.26 92.86,23.77 92.76,23.67 89.03,23.67 88.71,24 88.71,25.12 88.29,25.53 v1(88.29,26.42)
DDR4_DIMM_CH2_DQ54: length 58.4
  L12_SIG4 w0.089: v1(83.11,32.42) 82.75,32.06 82.75,30.26 82.65,30.16 82.46,30.16 82.36,30.26 82.36,31.52 82.27,31.61 81.16,31.61 80.72,32.05 80.72,33.45 82.49,35.22 83.54,35.22 85.72,37.39 85.72,38.45 89.65,42.37 90.01,42.37 90.58,42.94 90.83,42.94 91.21,43.32 91.75,43.32 92.01,43.05 92.56,43.05 92.93,43.42 93.5,43.42 94.02,43.94 94.32,43.94 94.8,44.42 95.27,44.42 95.65,44.8 96.15,44.8 96.41,44.54 97.02,44.54 97.29,44.81 97.85,44.81 98.19,44.47 98.75,44.47 99.17,44.88 99.57,44.88 99.95,44.5 100.4,44.5 100.71,44.81 101.39,44.81 101.82,44.38 102.09,44.38 102.58,43.89 102.95,43.89 103.3,43.55 103.86,43.55 104.31,43.99 104.62,43.99 105.17,44.55 105.68,44.55 106.08,44.95 106.45,44.95 106.96,45.46 107.31,45.46 107.7,45.85 108.25,45.85 108.55,45.55 109.18,45.55 109.44,45.81 110.03,45.81 110.29,45.54 110.89,45.54 111.2,45.86 111.66,45.86 112.04,45.48 112.58,45.48 112.96,45.86 113.45,45.86 113.81,45.51 114.31,45.51 114.65,45.85 115.13,45.85 115.49,45.49 115.86,45.49 116.42,44.93 116.81,44.93 117.2,44.55 117.84,44.55 118.1,44.82 118.61,44.82 118.97,44.45 119.33,44.45 119.64,44.14 119.64,42.33 v1(119.24,41.93)
DDR4_DIMM_CH2_DQ55: length 58.8
  L12_SIG4 w0.089: v1(119.24,42.93) 119.24,43.11 118.55,43.81 118.03,43.81 117.71,43.49 117.21,43.49 116.75,43.94 116.48,43.94 115.97,44.46 115.45,44.46 115.06,44.85 114.69,44.85 114.32,44.48 113.78,44.48 113.44,44.82 112.84,44.82 112.55,44.54 111.97,44.54 111.66,44.85 111.18,44.85 110.87,44.54 110.29,44.54 109.96,44.87 109.42,44.87 109.11,44.55 108.54,44.55 108.26,44.83 107.76,44.83 107.35,44.41 106.84,44.41 106.47,44.05 106.01,44.05 105.76,44.3 105.23,44.3 104.93,44.01 104.93,43.31 104.65,43.03 104.3,43.03 104,43.32 103.32,43.32 103.04,43.05 102.52,43.05 102.18,43.39 101.74,43.39 101.32,43.81 100.74,43.81 100.47,43.53 99.92,43.53 99.61,43.85 99.14,43.85 98.83,43.54 98.2,43.54 97.91,43.82 97.31,43.82 97.03,43.54 96.57,43.54 96.27,43.84 95.61,43.84 95.2,43.43 94.82,43.43 94.33,42.95 93.87,42.95 93.48,42.55 93.06,42.55 92.8,42.81 92.14,42.81 91.72,42.39 91.29,42.39 90.87,41.97 90.59,41.97 90.17,41.54 89.39,41.54 86.14,38.3 86.14,37.33 83.67,34.86 82.82,34.86 81.11,33.15 81.11,32.16 81.24,32.03 81.77,32.03 81.92,32.18 81.92,32.55 82.19,32.82 83.28,32.82 83.49,32.61 83.49,32.19 83.23,31.93 83.23,31.42 83.32,30.59 83.32,28.36 83.26,28.24 82.82,27.58 v1(82.34,26.42)
DDR4_DIMM_CH2_DQ56: length 73.2
  L16_SIG6 w0.081: v1(116.65,45.43) 116.65,46.09 116.94,46.39 117.78,46.39 118.12,46.06 118.58,46.06 118.83,46.31 119.39,46.31 119.74,45.96 119.74,43.27 119.89,43.12 119.89,42.74 119.74,42.58 119.74,41.85 118.83,40.94 117.84,40.94 116.81,39.92 114.8,39.92 113.74,38.86 107.31,38.86 106.38,37.93 105.55,37.93 104.46,36.83 103.86,36.83 102.92,35.9 102.33,35.9 101.48,35.05 101.12,35.05 98.93,32.86 98.93,32.22 98.68,31.96 97.52,31.96 94.43,28.87 86.92,28.87 85.93,27.88 85.49,27.88 85.35,27.73 82.88,27.73 82.08,28.53 82.08,28.9 81.24,29.74 78.2,29.74 78.1,29.84 78.1,29.97 78.2,30.08 79.86,30.08 79.96,30.18 79.96,30.31 79.86,30.41 77.77,30.41 77.67,30.51 77.67,30.64 77.77,30.75 80.09,30.75 80.19,30.85 80.19,30.98 80.09,31.08 77.39,31.08 77.29,31.18 77.29,31.31 77.39,31.42 79.89,31.42 80,31.52 80,31.65 79.89,31.75 78.76,31.75 v1(78.09,32.42)
