# Allegro board TS28247BC0_FM61_agilex_PCIe_DEVKIT_ADI_REVB1.brd (continued)
## Nets (continued)
QSFPDD1_FPGA_LED0: R723.1 U2.G20 U68.2
QSFPDD1_FPGA_LED1: R722.1 U2.H21 U68.3
QSFPDD1_FPGA_LED2: R720.1 U2.F21 U68.4
QSFPDD1_LED0: Q27.1 R721.2 U68.13
QSFPDD1_LED1: Q29.1 R719.2 U68.12
QSFPDD1_LED2: Q28.1 R718.2 U68.11
QSFPDD1_RX0_N: J6.18 U2.BE8
QSFPDD1_RX0_P: J6.17 U2.BF7
QSFPDD1_RX1_N: J6.21 U2.BJ8
QSFPDD1_RX1_P: J6.22 U2.BK7
QSFPDD1_RX2_N: J6.15 U2.BH11
QSFPDD1_RX2_P: J6.14 U2.BG10
QSFPDD1_RX3_N: J6.24 U2.BM11
QSFPDD1_RX3_P: J6.25 U2.BL10
QSFPDD1_RX4_N: J6.56 U2.BN8
QSFPDD1_RX4_P: J6.55 U2.BP7
QSFPDD1_RX5_N: J6.59 U2.BU8
QSFPDD1_RX5_P: J6.60 U2.BV7
QSFPDD1_RX6_N: J6.53 U2.BT11
QSFPDD1_RX6_P: J6.52 U2.BR10
QSFPDD1_RX7_N: J6.62 U2.BY11
QSFPDD1_RX7_P: J6.63 U2.BW10
QSFPDD1_TX0_N: J6.37 U2.BE2
QSFPDD1_TX0_P: J6.36 U2.BF1
QSFPDD1_TX1_N: J6.2 U2.BJ2
QSFPDD1_TX1_P: J6.3 U2.BK1
QSFPDD1_TX2_N: J6.34 U2.BH5
QSFPDD1_TX2_P: J6.33 U2.BG4
QSFPDD1_TX3_N: J6.5 U2.BM5
QSFPDD1_TX3_P: J6.6 U2.BL4
QSFPDD1_TX4_N: J6.75 U2.BN2
QSFPDD1_TX4_P: J6.74 U2.BP1
QSFPDD1_TX5_N: J6.40 U2.BU2
QSFPDD1_TX5_P: J6.41 U2.BV1
QSFPDD1_TX6_N: J6.72 U2.BT5
QSFPDD1_TX6_P: J6.71 U2.BR4
QSFPDD1_TX7_N: J6.43 U2.BY5
QSFPDD1_TX7_P: J6.44 U2.BW4
QSFPDD1_VCC: C167.1 C168.2 C169.2 C170.2 J6.30 J6.68 L20.2
QSFPDD1_VCCR: C163.1 C164.2 C165.2 C166.2 J6.10 J6.48 L19.2
QSFPDD1_VCCT: C159.1 C160.2 C161.2 C162.2 J6.29 J6.67 L18.2
QSFPDD_FPGA_I2C_SCL: R46.1 U2.D29 U3.4
QSFPDD_FPGA_I2C_SDA: R47.1 U2.G28 U3.5
QSFPDD_I2C_SCL: J5.11 J6.11 R92.1 U3.11
QSFPDD_I2C_SDA: J5.12 J6.12 R93.1 U3.10
QSPI_RESETN: R5772.2 R5774.2 U2.CA58
REFCLK_156M_QSFPDD_N: C316.2 R811.1 U2.AN14
REFCLK_156M_QSFPDD_P: C315.2 R811.2 U2.AR14
REFCLK_322M_QSFPDD_N: C318.2 R810.1 U2.AP13
REFCLK_322M_QSFPDD_P: C317.2 R810.2 U2.AT13
REFCLK_PCIE_CH0_N: R798.1 R812.1 R824.1 U2.AH49
REFCLK_PCIE_CH0_P: R797.1 R812.2 R825.1 U2.AJ48
REFCLK_PCIE_CH2_N: R800.1 R813.2 R826.1 U2.AD49
REFCLK_PCIE_CH2_P: R799.1 R813.1 R827.1 U2.AE48
REFCLK_PCIE_EP_EDGE_N: J7.A14 R806.1 R824.2 U72.2
REFCLK_PCIE_EP_EDGE_P: J7.A13 R805.1 R825.2 U72.1
REFCLK_PCIE_EP_N: R264.1 R808.1 R826.2 U72.6
REFCLK_PCIE_EP_P: R262.1 R807.1 R827.2 U72.5
RSV_SD_RESETN: U2.AA2 U26.D9
RUN0: C1840.1 R5944.1 R6108.2 U76.30
RUN2: C1996.1 R6088.1 R6107.2 U78.30
RUN3: C1998.1 R6089.1 R6106.2 U79.30
RUN4: C1994.1 R6087.1 R6109.2 U77.30
SD_3.3V: C259.2 C261.1 C262.2 C263.2 J11.4 R180.2 R188.1 U15.A1(VOUT)
SD_CLK: R181.2 U2.AB9 U14.10
SD_CLK_3.3V: D6.1 J11.5 R195.1 U14.11
SD_CMD: R182.2 U2.V3 U14.9
SD_CMD_3.3V: D6.2(K2) J11.3 R194.1 U14.12
SD_DATA0: R183.2 U2.AD9 U14.5
SD_DATA0_3.3V: D5.1 J11.7 R189.1 U14.16
SD_DATA1: R184.2 U2.T3 U14.6
SD_DATA1_3.3V: D5.2(K2) J11.8 R191.1 U14.15
SD_DATA2: R185.2 U2.AC10 U14.7
SD_DATA2_3.3V: D4.1 J11.1 R192.1 U14.14
SD_DATA3: R186.2 U2.P3 U14.8
SD_DATA3_3.3V: D4.2(K2) J11.2 R193.1 R196.2 U14.13
SD_RSTN: R190.1 U15.B2 U26.F13
SH_CLK: R5931.1 U47.29
SI2202_OUT0N: R264.2 U18.13
SI2202_OUT0P: R262.2 U18.12
SI5341_1P8V_VDDO: C307.1 C308.1 C309.1 C310.1 C311.1 C312.1 C313.1 C314.1 FB22.1 U17.26 U17.29 U17.33 U17.36 U17.43 U17.49 U17.52 U17.57
SI5341_2P5V_VDDO: C302.1 C303.1 FB20.1 U17.22 U17.40
SI5341_A0: R241.1 U17.19
SI5341_A1: R242.1 U17.17
SI5341_ENN: R278.2 SW2.2 U17.11 U26.C9
SI5341_FDEC: U17.25 U26.D8
SI5341_FINC: U17.48 U26.N12
SI5341_I2C_SEL: R243.1 U17.39
SI5341_IN_SEL0: R245.1 U17.3
SI5341_IN_SEL1: R244.1 U17.4
SI5341_OUT0N: C316.1 U17.23
SI5341_OUT0P: C315.1 U17.24
SI5341_OUT1N: R250.2 U17.27
SI5341_OUT1P: R249.2 U17.28
SI5341_OUT2N: R254.2 U17.30
SI5341_OUT2P: R253.2 U17.31
SI5341_OUT3N: R248.2 U17.34
SI5341_OUT3P: R246.2 U17.35
SI5341_OUT4N: R252.2 U17.37
SI5341_OUT4P: R251.2 U17.38
SI5341_OUT5N: C318.1 U17.41
SI5341_OUT5P: C317.1 U17.42
SI5341_OUT6N: R256.2 U17.44
SI5341_OUT6P: R255.2 U17.45
SI5341_OUT7N: R258.2 U17.50
SI5341_OUT7P: R257.2 U17.51
SI5341_OUT8P: R259.2 U17.54
SI5341_OUT9P: R834.2 U17.59
SI5341_RSTN: R247.1 U17.6 U26.A9
SI5341_VDD: C298.1 C299.1 C300.1 C301.1 FB19.2 U17.32 U17.46 U17.60
SI5341_VDDA: C305.1 C306.1 FB21.2 U17.13
SI5341_X1: U17.7 Y2.2
SI5341_X2: U17.10 Y2.4
SI5341_XA: U17.8 Y2.3
SI5341_XB: U17.9(XB) Y2.1
SI52202_PWRDNB: R273.2 SW2.3 U18.1
SW_U76_FPGA_VCC: L23.1 U76.1 U76.2 U76.3 U76.4 U76.5 U76.6 U76.10 U76.11 U76.12 U76.13 U76.14 U76.15 U76.16 U76.42
SW_U77_FPGA_VCC: L24.1 U77.1 U77.2 U77.3 U77.4 U77.5 U77.6 U77.10 U77.11 U77.12 U77.13 U77.14 U77.15 U77.16 U77.42
SW_U78_FPGA_VCC: L25.1 U78.1 U78.2 U78.3 U78.4 U78.5 U78.6 U78.10 U78.11 U78.12 U78.13 U78.14 U78.15 U78.16 U78.42
SW_U79_FPGA_VCC: L26.1 U79.1 U79.2 U79.3 U79.4 U79.5 U79.6 U79.10 U79.11 U79.12 U79.13 U79.14 U79.15 U79.16 U79.42
SYNC: R5929.1 U47.14
TMON0: C2017.2 R5945.1 U76.22
TMON2: C2026.2 R5954.1 U78.22
TMON3: C2028.2 R5961.1 U79.22
TMON4: C2020.2 R5951.1 U77.22
TRACECTL: J12.36 R211.2
TSENSE_ALERTN: R400.1 U30.L12 U32.18
TSNS0: C1821.1 R5945.2 R5951.2 R5954.2 R5961.2 U47.8
UART_EN: R167.1 SW2.4 U9.1
UART_RESETN: R172.2 R175.2 U11.18
UART_RSTN: R174.1 U12.2 U26.G9
UART_RX: J9.1 R169.1 U2.F1
UART_RX_LED: R178.1 U11.21
UART_TX: J9.2 U2.AA6 U10.2
UART_TX_LED: R177.1 U11.22
UART_USB_PGND: C248.2 J10.6 J10.7 J10.8 J10.9 R176.2
UBII_M10_VCCA: C376.1 C377.1 C378.1 C379.1 C380.2 C381.1 FB28.1 U26.D3 U26.D4 U26.D10 U26.K4 U26.K9
USB_DISABLEN: R345.2 R346.2 U26.N2
USB_MAX_JTAGSEL: R279.2 SW2.1 U26.B2 U29.15
USB_MAX_TCK: U26.G2 U29.2
USB_MAX_TDI: U26.F5 U29.7
USB_MAX_TDO: U26.F6 U29.10
USB_MAX_TMS: U26.G1 U29.5
USB_T_CLK: R332.1 U26.H6
USB_UART_5V: C254.2 C255.1 L8.1 U11.19 U13.6(VBUS)
USB_UART_CON_5V: C256.2 C257.1 J10.1(VBUS) L8.2
USB_UART_DM: C245.1 J10.2 U11.15 U13.1
USB_UART_DP: C246.1 J10.3 U11.14 U13.2
VFB0: C2012.2 R5935.2 R5936.1 U47.12
VOSNS0_1P8V: R5963.2 U71.D7 U71.H7
VOSNS+: R5784.2 U125.B1
VOSNS-: R5786.2 R5787.1 U125.C2(VOUTS-)
VREF_B: C260.2 R180.1 R187.2 U14.19(VREF_B)
VTT_DDR4_CH01_EN: R377.2 R649.2
VTT_DDR4_CH23_EN: R379.2 R655.2
N17328275: J1.1 J1.145 R1.2 R2.2
N17329090: J1.288 R14.2
N22385889: R333.2 R334.1 U26.E5
N23293405: S5.1 U25.3
N31006327: J13.4 R327.2
N31014989: R337.2 U26.C5
N31015011: R338.2 U26.E7
N31015146: R335.2 U26.D7
N31015158: R336.2 U26.C4
N31093028: C355.1 R358.2
N31250983: J7.B11(WAKE_N) R101.1
N31253181: J7.B9 R104.2
N31257069: J7.B10 R100.1
N31314586: TP1.1 U43.B5
N31314601: TP2.1 U43.A5
N31314621: C444.2 R433.2 U43.C5
N31314744: R435.1 U43.B2
N31314754: C448.2 R434.1 U43.A1
N31314797: R436.1 R438.1 U43.C4
N31314853: R437.1 U43.A4
N31314899: C454.2 U43.A2
N31314949: R440.1 R442.1 U43.A3
N31314957: C453.1 C455.2 R439.2 R443.2 U43.B1
N31352894: R295.2 SW3.5(B4)
N31352897: R297.2 SW3.6
N31352900: R299.2 SW3.7
N31388806: D9.A R309.1
N31388830: D7.A R306.1
N31388866: D7.C(CATHODE) Q5.3
N31388880: D9.C(CATHODE) Q7.3
N31388890: D10.A R311.1
N31388919: D10.C(CATHODE) Q8.3
N31389008: D12.A R314.1
N31389082: D12.C(CATHODE) Q9.3
N31389304: D14.A R317.1
N31389320: D13.A R316.1
N31389364: D13.C(CATHODE) Q10.3
N31389378: D14.C(CATHODE) Q11.3
N31389867: Q11.1 R321.1
N31415897: Q12.4 R409.1
N31415950: C426.1 R409.2 U37.1
N31416024: Q13.3 R411.2 U37.5
N31416063: C427.2 R416.1 U37.6(VSS)
N31416065: C432.1 R412.2 R414.1 R415.2
N31416086: Q13.1 R415.1
N31872869: C383.1 R362.1 U30.D2
N31872899: C384.1 R369.1 U30.D1
N31873008: C385.1 R372.1 U30.C2
N31873022: R361.1 U30.L5
N31873048: R363.1 U30.M4
N31873076: C386.1 R375.1 U30.E3
N31873106: R364.1 U30.L4
N31873136: R365.1 U30.M5
N31873164: C387.1 R376.1 U30.E4
N31873212: R367.1 U30.N4
N31873240: C388.1 R381.1 U30.C1
N31873256: R368.1 U30.J5
N31873294: R370.1 U30.N5
N31873322: C389.1 R383.1 U30.B1
N31873334: R371.1 U30.N6
N31873366: C390.1 R384.1 U30.F1
N31873370: R373.1 U30.N7
N31873414: C391.1 R386.1 U30.E1
N31873418: R374.1 U30.M7
N31873454: R377.1 U30.N8
N31873498: R378.1 U30.J6
N31873524: R379.1 U30.M8
N31875898: R390.2 U30.E5
N31875914: R391.1 U30.G1
N31875930: R392.1 U30.G2
N31875950: R393.1 U30.F5
N31875960: R394.1 U30.F6
N31875982: R396.2 U30.E7
N31876004: R397.2 U30.C4
N31876008: R398.2 U30.C5
N32052935: C710.1 R401.1 U32.23
N32053041: C710.2 R402.1 U32.24
N32057804: C458.1 R444.1 R448.1 U44.3
N32057806: C466.1 U44.6
N32057886: R446.2 U44.7
N32121976: C459.1 R445.1 R449.2 U45.3
N32121978: C467.1 U45.6
N32122058: R447.2 U45.7
N32230321: R828.1 U34.4 U36.5
N32230341: R406.2 R410.2 U36.3
N32230392: R410.1 R413.1 U36.2
N32230759: U33.4 U35.3
N32232827: U38.4 U40.3
N32233406: R829.1 U39.4 U41.5
N32233436: R418.2 R421.2 U41.3
N32233467: R417.2 R420.1 U41.8
N32233496: R421.1 R422.1 U41.2
N32233958: R426.1 SW5.4
N32406903: R428.1 SW5.6
N32408103: R405.2 R408.1 U36.8
N32408438: R425.2 R427.2 U42.3
N32408441: R427.1 R430.1 U42.4
N32411757: R385.1 U30.M13
N32411786: C382.1 R360.1 U30.D3
N33149453: R395.2 U30.D7
N33771526: D8.C(CATHODE) Q6.3 R308.2
N33771550: D8.A R307.2
N34054433: D11.A R312.1
N34315909: C336.2 R322.2
N34315982: C337.2 R323.2
N34474357: R288.1 U21.2
N34474360: R289.1 U21.3
N34525726: C339.1 MTH1.1(GND) MTH4.1(GND) R325.2
N34626400: R332.2 U28.13
N34824147: MTH5.1(GND) MTH6.1(GND)
N35351327: J3.1 J3.145 R54.2 R55.2
N35351465: J3.288 R65.2
N35410578: J4.1 J4.145 R68.2 R69.2
N35410716: J4.288 R79.2
N35659314: R114.2 U2.CA54
N35660053: C209.1 R116.2 R814.1 U2.CC62 U52.1(VO)
N35951410: C210.1 J8.14 R126.2
N35951471: R128.1 U7.24
N35951814: C215.2 J8.16 R134.2
N35952167: L1.1 Q1.3
N35952169: Q1.1 Q2.3 R140.2
N35952204: L2.1 Q3.3
N35952206: Q3.1 Q4.3 R143.2
N35952591: R160.2 Y1.1
N35952937: C225.1 R164.2 R166.2 U8.3
N35952961: R163.1 U8.7
N35952969: R165.1 U8.4
N35953003: C235.2 U8.6
N35980126: R169.2 U9.4(Y)
N35980394: J10.4 R173.1
N35980546: R175.1 U12.4(Y)
N35980606: D2.C(CATHODE) R177.2
N35980632: D3.C(CATHODE) R178.2
N35982389: R188.2 R189.2 R191.2 R192.2 R193.2 R194.2 R195.2
N35984757: J12.6 R201.2
N35984782: J12.8 R203.2
N35984815: J12.10 R204.2
N35984874: J12.13 R206.1
N35984876: J12.14 R207.1
N36075384: J14.2 R346.1
N36077918: C319.1 U18.2 Y3.3
N36077948: C324.1 U18.3(XOUT) Y3.1
N36078275: R267.1 R268.1 U18.14
N36078278: R266.1 R269.1 U18.16
N36078643: R260.1 R265.1 U18.8
N36079166: C325.1 C326.1 FB24.2 R271.2 U19.6(VDD)
N36079197: R270.1 U19.4
N36079218: R271.1 U19.2
N36079220: R272.1 U19.5
N36112579: R112.2 SW1.6
N36112582: R111.2 SW1.7
N36112585: R110.2 SW1.8
N36194618: C1219.1 C1220.1 FB45.2 U2.BY43 U2.CB43
N36226098: C338.2 R324.2
N36227679: R86.1 U2.AN20
N36227711: R88.2 U2.BM43
N36227759: R87.2 U2.BH49
N36228605: R357.2 U26.D12
N36270051: R304.1 U23.13
N36270054: R305.1 U23.12
N36270110: R296.1 U22.2
N36270125: R298.1 U22.3
N36270340: R300.2 SW3.8
N36272215: R313.1 S1.2 U24.3
N36273391: R354.2 U26.B13
N36273529: R263.2 U18.6
N36273532: R261.2 U18.7
N36316045: R648.2 R649.1 R650.2 U59.7
N36316148: C660.1 R651.1 R652.1 U59.1
N36316465: R654.2 R655.1 R656.2 U60.7
N36316589: C673.1 R657.1 R658.1 U60.1
N36344563: R274.2 SW2.5(B4)
N36344586: R275.2 SW2.6
N36344607: R276.2 SW2.7
N36344628: R277.2 SW2.8
N36347895: R380.1 U30.K6
N36348634: R830.1 U62.4 U63.5
N36348657: R668.2 U63.4
N36348739: R669.1 R670.1 R671.2 U63.8
N36349829: R382.1 U30.M9
N36396769: U7.43 V1.1(TP)
N36398138: C683.1 R680.1 R682.2 U64.3
N36398140: C687.1 U64.6
N36398214: R681.2 U64.7
N36447575: R703.1 U30.J7
N36541668: D21.A R704.1
N36541743: D22.3 R705.1
N36541790: D22.1 R706.1
N36541991: D23.A R707.1
N36542034: D24.3 R708.1
N36542055: D24.1 R709.1
N36542312: D21.C(CATHODE) Q24.3
N36542538: D22.4 Q25.3
N36542543: D22.2 Q26.3
N36542635: D23.C(CATHODE) Q27.3
N36542846: D24.4 Q28.3
N36542851: D24.2 Q29.3
N36800975: R729.2 U32.14
N36803165: C711.1 R730.1 U32.1
N36803169: C711.2 R731.1 U32.2
N36803267: C395.2 R732.1 U32.3
N36803284: C395.1 R733.1 U32.4
N36803301: C709.2 R734.1 U32.5
N36803305: C709.1 R735.1 U32.7
N37269586: C555.1 FB33.2 U50.9 U50.10
N37269687: C557.1 R546.1 R548.1 U50.3
N37269689: C561.1 U50.6
N37651435: C1472.2 R773.2
N37651438: C1473.2 R774.2
N37651441: C1474.2 R775.2
N37651444: C1475.2 R776.2
N37651447: C1476.2 R777.2
N37651450: C1477.2 R778.2
N37651453: C1478.2 R779.2
N37651456: C1479.2 R780.2
N37651459: C1480.2 R781.2
N37651462: C1481.2 R782.2
N37651465: C1482.2 R783.2
N37761290: R802.1 U72.9
N37761293: R803.1 U72.12
N37761614: C1518.1 C1520.1 FB40.2 U72.3
N37761618: C1521.1 C1523.1 FB42.2 U72.4
N37761695: C1519.1 C1522.1 FB41.2 U72.16
N37762935: R801.1 R804.1 U72.8(VSW_MODE)
N37763666: R809.1 SW7.1 U72.23
N37820590: R815.2 R816.1 U73.3
N37820593: R817.2 R818.1 U73.2
N37820596: R819.2 R820.1 U73.1
N37820939: R821.2 R822.2 U73.7(WP)
N37847663: C1524.2 R823.2
N37925832: C420.2 R828.2
N37926031: C434.2 R829.2
N37926941: C1525.1 R831.2
N38179462: C1550.2 R873.1 R874.1 R875.1 R876.1 R877.1
N38301581: R5757.1 U2.AT19
N38301586: R5758.1 U2.AP17
N39014223: R5772.1 U6.A4
N39025445: R5773.1 U2.CC58
N39028460: C1654.1 U125.E2
N39028581: C1655.1 R5776.2 U125.B3
N39028605: TP19.1 U125.B7
N39028640: R5777.2 U125.A6
N39028644: C1656.2 R5780.1 U125.D1
N39028777: R5780.2 U125.F1
N39029145: C1665.1 R5785.1 R5787.2 U125.C1
N39047511: R5788.2 R6273.1 U125.B4
N39047662: R5789.1 U30.K5
N39053590: R978.1 U125.E1
N40859486: C2007.2 C2008.2 C2009.2 C2010.2 R5928.1 R5930.1 R5932.1 R5934.1 R6105.2
N40859780: C1818.2 U47.31
N40859787: C1820.1 U47.30
N40859815: C1819.1 U47.28
N40859909: R6100.2 U47.21
N40859911: R5939.2 U47.22
N40859913: R5940.2 U47.23
N40859915: R5941.2 U47.24
N40859917: R5942.2 U47.25
N40865174: R5946.2 U76.35
N40865834: R5952.2 U77.35
N40873145: R5955.2 U78.35
N40873851: R5962.2 U79.35
N40878568: U71.J3 U71.K3
N40878578: R5964.1 R6104.2 U71.H6
N40878702: R5964.2 U71.J6
N40878910: R5965.2 R5967.2 U71.F9
N40878945: R5966.1 U71.F7 U71.G7
N40878955: TP29.1(TP) U71.J5
N40879078: R5968.1 U71.E5
N40879082: R5970.1 U71.H5
N40879084: R5971.1 U71.F2
N40879086: R5969.1 R5974.1 U71.E3
N40879090: D25.2 R5972.1 U71.E2
N40879092: R5973.2 R5977.1 R5978.2 U71.F3 U71.F4
N40879148: U71.C3 U71.D3
N40879172: R5975.2 U71.K4(WP)
N40879270: R6102.1 U71.E7
N40879274: R5980.1 U71.G2
N40879310: R5981.2 U71.H2
N40879329: R5982.2 U71.G3 U71.G4
N40879333: R5983.2 U71.H3 U71.H4
N40882065: TP30.1 U51.B5
N40882112: TP31.1 U51.A5
N40882148: R5985.2 R5986.2 R5987.2 R6096.2
N40882229: C1902.2 R5985.1 U51.A1
N40882256: R5986.1 U51.B2
N40882276: R5987.1 U51.C4
N40882304: R5988.2 U51.A4
N40882322: C1904.2 U51.A2
N40882328: R5989.1 R5990.1 R5991.2 U51.A3
N40882423: C2032.1 R5992.2 U51.B1
N40882447: R5992.1 R5993.2
N40885340: R5995.2 R5997.2 R5998.1 U65.F1
N40885465: C1909.2 R5996.2 U65.E7
N40885526: TP32.1(TP) U65.B3
N40885555: TP33.1(TP) U65.F2
N40885593: R5999.2 U65.B5
N40894339: C1914.2 R6002.1 U55.K1
N40894341: C1914.1 R6003.1 U55.J1
N40894343: TP41.1(TP) U55.D12
N40894345: TP42.1(TP) U55.E8
N40894542: R6004.2 R6006.2 U55.H11
N40894561: R6005.2 U55.F12
N40894590: R6007.2 U55.D1
N40895169: U55.J8 U55.J11
N40895207: R6011.1 R6014.2 R6016.2 U55.F11 U55.G12
N40895215: U55.D8 U55.J10
N40895254: R6013.1 U55.E11 U55.E12
N40895294: R6015.2 U55.C12 U55.E10
N40895381: R6017.2 U55.F8
N40895450: R6022.2 U55.E9
N40895467: C1935.1 U55.D10 U55.J9
N40895475: R6018.2 U55.G11
N40895479: R6019.2 U55.H12
N40895481: R6020.2 U55.D11
N40895483: R6021.2 U55.K12
N40895485: C1940.1 U55.C10 U55.H9
N40895537: R6023.1 U55.C11(WP)
N40899627: R6027.2 R6028.1 R6097.2 U56.F1
N40899752: C1943.2 R6026.2 U56.E7
N40899813: TP34.1(TP) U56.B3
N40899850: TP35.1(TP) U56.F2
N40899884: R6029.2 U56.B5
N40903465: R6035.2 U57.A7 U57.D7 U57.G7 U57.J7
N40903501: U57.B7 U57.E7 U57.H7 U57.L7
N40903513: U57.B6 U57.C4
N40903517: C1957.2 U57.A6 U57.D6 U57.G6 U57.K6
N40903590: U57.E6 U57.F4
N40903670: U57.H6 U57.J4
N40903761: U57.K5 U57.L6
N40903799: R6035.1 R6036.1
N40903928: R6038.1 U57.F3
N40907421: R6042.2 U58.A7 U58.D7 U58.G7 U58.J7
N40907472: U58.B7 U58.E7 U58.H7 U58.L7
N40907476: U58.B6 U58.C4
N40907480: C1967.2 U58.A6 U58.D6 U58.G6 U58.K6
N40907555: U58.E6 U58.F4
N40907635: U58.H6 U58.J4
N40907725: U58.K5 U58.L6
N40907761: R6042.1 R6043.1
N40907881: R6044.1 U58.F3
N40909775: TP38.1 U61.B5
N40909802: TP39.1 U61.A5
N40909854: R6056.2 R6057.2 R6058.2 R6093.2
N40909931: C1978.2 R6056.1 U61.A1
N40909962: R6057.1 U61.B2
N40909984: R6058.1 U61.C4
N40910010: R6059.2 U61.A4
N40910028: C1979.2 U61.A2
N40910038: R6060.1 R6061.1 R6062.2 U61.A3
N40910129: C2033.1 R6063.2 U61.B1
N40968297: C2034.2 R6074.2 U70.C1
N40969501: R6075.1 R6076.1 R6077.2 U70.C3 U70.C5 U70.E3 U70.E5
N40980036: C2036.2 R6067.2 U66.C1
N40980113: R6083.1 R6084.1 R6085.2 U66.C3 U66.C5 U66.E3 U66.E5
N40987662: R5960.1 TP28.1 U124.B4 U124.D4
N40987771: U124.A5 U124.E5
N40987783: C2031.1 R6078.1 U124.A4 U124.E4
N40989537: R5957.1 U124.B2 U124.D2
N40990671: R5958.1 U124.C4
N40992497: C1874.2 U124.A3 U124.E3
N40993869: R5956.2 U124.C5
N41030357: R6086.2 U47.27
N41037858: R6090.2 U47.19
N41038344: R6026.1 R6092.1
N41419088: R5976.1 R6103.2 U71.E6
N41419100: R5976.2 U71.D6
N41577579: C2018.1 U76.36
N41579874: C2019.1 U77.36
N41584176: C2025.1 U78.36
N41584715: C2027.1 U79.36
N41681478: C2004.1 R6098.2
N41873307: R5996.1 R6091.1
N41930528: TP45.1(TP) U55.L2
N41930530: TP46.1(TP) U55.A1
N42039861: R6106.1 U79.32
N42039972: R6107.1 U78.32
N42040021: R6108.1 U76.32
N42040083: R6109.1 U77.32
N42040125: R6110.2 U77.34
N42040156: R6111.2 U76.34
N42040187: R6112.2 U78.34
N42040218: R6113.2 U79.34
N42120524: R6114.2 U47.6
N42120776: R6115.2 U47.7
N42308013: C7761.1 U46.25
N42308046: C7763.2 R6262.2 U46.24
N42308122: R6263.1 U46.27
N42308126: C7764.1 R6264.2 R6266.2 U46.23
N42308130: C7764.2 R6266.1 R6271.2
N42308290: TP1005.1 U46.1
N42308292: R6270.2 R6293.1 U46.22(VOUTM)
N42308326: C7765.1 R6268.1 U46.3
N42308549: L30.1 U46.9 U46.10 U46.11 U46.12 U46.13 U46.14
N42531609: C7778.1 R6291.2 U126.1
N42531612: C7778.2 R6292.2 U126.2
N42533175: R6287.2 R6289.2 U126.8
N42533585: R6288.2 R6290.2 U126.7
N42744699: J2.1 J2.145 R17.2 R18.2
N42745155: C37.1 C38.1 R19.2 R20.2 U3.14
N42745359: J2.234 R793.2
N42746504: J2.288 R30.2
N42837491: C7762.2 R6262.1
N43345615: R6264.1 R6293.2
N43346477: R6067.1 R6294.2
N359525652: R161.1 Y1.3
N359847316: J12.7 R202.1
N363486630: C681.1 R830.2

Pads without a net: J1 144 205 227; J2 93 144 205 227 235 237; J3 144 205 227; J4 144 205 227; J5 46 47 49 50 65 66 69 77 78; J6 46 47 49 50 65 66 69 77 78; J8 15; J12 1 2 3 4; J14 6 7 8; J15 3; MTH2 1; MTH3 1; NOREF#3 1; NOREF#4 1; NOREF#11 1; NOREF#18 1; NOREF#22 1; NOREF#23 1; NOREF#27 1; NOREF#31 1; NOREF#33 1; NOREF#38 1; NOREF#41 1; NOREF#52 1; NOREF#53 1; NOREF#56 1; NOREF#70 1; NOREF#74 1; NOREF#77 1; NOREF#80 1; NOREF#81 1; NOREF#82 1; NOREF#87 1; NOREF#93 1; NOREF#100 1; NOREF#101 1; NOREF#113 1; NOREF#114 1; NOREF#117 1; NOREF#118 1; NOREF#119 1; NOREF#120 1; NOREF#130 1; NOREF#131 1; NOREF#132 1; SW1 4 5; SW5 1 2 3; U1 6 9; U2 A22 AA10 AA12 AA14 AA16 AA18 AA20 AA42 AA44 AA46 AA48 AA52 AA56 AA62 AB11 AB13 AB15 AB17 AB19 AB43 AB45 AB47 AB55 AB61 AC12 AC14 AC16 AC18 AC42 AC44 AC46 AC56 AC62 AD7 AD15 AD17 AD19 AD43 AD45 AE44 AF3 AF19 AH19 AJ20 AJ46 AM19 AT17 B29 BK49 BL44 BL46 BL48 BL50 BM45 BM47 BM49 BN44 BN46 BN50 BP47 BR50 BT45 BT47 BT49 BT51 BT53 BT59 BU14 BU16 BU44 BU46 BU48 BU50 BU52 BU60 BV13 BV15 BV17 BV19 BV45 BV47 BV49 BV51 BV53 BV55 BW18 BY15 BY17 BY19 BY21 BY53 BY55 BY57 BY61 C22 C24 CA14 CA16 CA18 CA50 CA56 CB1 CB7 CB13 CB15 CB17 CB19 CB21 CB51 CB53 CB61 CC2 CC8 CC14 CC16 CC18 CC20 CC22 CC50 CC56 CE40 CE42 CE46 CE48 CE50 CF1 CF39 CF41 CF45 CF47 CF49 CF61 CG40 CG46 CG48 CG50 CH1 CH41 CH45 CH47 CH49 CH61 CK1 CK47 CK49 CK53 CK55 CK57 CK61 CL48 CL50 CL52 CL54 CL56 CL60 CM1 CM47 CM49 CM53 CM55 CM57 CM61 CN48 CN50 CN52 CN54 CN56 CR4 CR6 CR22 CR26 CR28 CT5 CT7 CT17 CT21 CT25 CT27 CT29 CU6 CU18 CU20 CU22 CU26 CU28 CV5 CV19 CV21 CV25 CV27 CV29 CY17 CY19 CY21 D23 DA18 DA20 DA22 DB17 DB19 DB21 DC18 DC20 DC22 F27 F29 G22 G24 G62 H1 H3 H23 H27 H29 J22 J24 J28 J62 L48 L50 L52 L54 L56 L58 L62 M3 M47 M49 M51 M55 M57 M59 M61 N2 N48 N50 N52 N54 N56 N58 N62 P47 P49 P51 P55 P57 P59 P61 T43 T47 T49 T51 T61 U42 U48 U50 U52 U62 V41 V43 V47 V49 V51 V61 W42 W44 W48 W50 W52 W62; U3 6 9; U4 6 9; U5 6 9; U6 A2 A3 A5 B1 B5 C1 C3 C5 D1 D5 E1 E2 E3 E4 E5; U7 13 45 47; U8 8; U10 1; U11 3 5 6 7 8 9 10 12 13 23 25 27 28 29 31 32; U12 1; U13 3 5; U14 3 4 17 18; U16 A7 A9 A10 A11 A12 A13 A14 B1 B8 B9 B10 B11 B12 B13 B14 C7 C8 C9 C10 C11 C12 C13 C14 D3 D12 D13 D14 E1 E2 E3 E5 E8 E9 E10 E12 E13 E14 F1 F2 F3 F10 F12 F13 F14 G1 G2 G3 G10 G12 G13 G14 H1 H2 H3 H5 H12 H13 H14 J1 J2 J3 J12 J13 J14 K1 K2 K3 K6 K7 K10 K12 K13 K14 L12 L13 L14 M1 M2 M3 M7 M8 M9 M10 M11 M12 M13 M14 N3 N6 N8 N9 N10 N11 N12 N13 N14 P1 P2 P8 P9 P10 P11 P12 P13 P14; U17 1 2 5 12 14 15 20 21 47 53 55 56 58 61 62 63 64; U18 17 18; U19 1; U23 4 5 6 9 10 11; U26 D13 F10 G5 H5; U28 54; U30 A2 A5 A8 A11 A12 B2 B3 B4 B7 B9 C9 C10 D6 D8 D11 D13 E13 F4 F9 F10 F13 G4 G5 G10 G12 G13 H1 H2 H3 H5 H8 H9 H10 H13 J1 J2 J8 J9 J10 J12 J13 K1 K2 K7 K8 K10 K13 L1 L2 L3 L10 L11 L13 M1 M2 M3 M10 M11 N2 N3 N10 N11; U32 6 8 9 10 11 12 13 22; U35 5; U37 3 7; U40 5; U44 8; U45 8; U46 21; U47 26 34 35 36 37 38 39 42 45 46 49; U50 8; U52 3; U55 A2 B2 M1 M2; U56 B4 B7 C3 C4 C5 E3 F6; U57 C2 C7 F2 J2 J3; U58 C2 C7 F2 J2 J3; U63 7; U64 8; U65 B4 B7 C3 C4 C5 E3 F6; U66 D1 D6 D7; U67 5 6 9 10; U68 5 6 9 10; U70 D1 D6 D7; U71 B8 D8 E8 J7 L8; U72 17 18 19 20 21 22; U76 23 24 25 26; U77 23 24 25 26; U78 23 24 25 26; U79 23 24 25 26; U125 D2 F2 G5

## Via types
v1: diameter 0.406, hole 0.203, TOP to BOTTOM, 8699 vias
v2: diameter 0.61, hole 0.305, TOP to BOTTOM, 917 vias
v3: diameter 0.813, hole 0.406, TOP to BOTTOM, 19 vias
v4: diameter 0.406, hole 0.254, TOP to L03_SIG1, 350 vias
v5: diameter 0.762, hole 0.508, TOP to BOTTOM, 33 vias
v6: diameter 0.406, hole 0.254, L16_SIG6 to BOTTOM, 32 vias
v7: diameter 0.406, hole 0.254, TOP to L02_GND1, 35 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
5V: length 29.5
  L07_SIG3 w0.508: v1(250.2,49.23) v1(251.47,49.23) v1(252.74,49.23) v1(254.01,49.23) 260.87,49.23 267.09,43 267.09,37.54 v1(268.23,36.4)
  BOTTOM w0.254: R5967.1 v1(230.26,56.12) R5966.2 229.45,56.05 v1(229.01,56.48)
  BOTTOM w0.381: R307.1 v1(268.23,36.4)
  vias: v1(35.06,71.52) v1(48.52,15.83) v1(48.52,14.94) v1(49.41,15.83) v1(49.41,14.94) v1(50.3,15.83) v1(50.3,14.94) v1(154.82,16.33) v1(154.82,15.45) v1(155.71,16.33) v1(155.71,15.45) v1(156.6,16.33) v1(156.6,15.45) v1(244.67,50.78) v1(245.88,52.02) v1(245.88,50.75) v1(246.51,49.74) v1(246.51,48.72) v1(247.15,52.02) v1(247.15,50.75) v1(247.53,49.74) v1(247.53,48.72) v1(248.42,49.74) v1(248.42,48.72) v2(29.6,46.18) v2(29.6,45.16) v2(30.23,46.18) v2(30.23,45.16) v2(249.97,45.1) v2(249.97,44.34) v2(249.97,43.58) v2(250.61,45.1) v2(250.61,44.34) v2(250.61,43.58) v3(256.06,49.33)
5V_AGND:
  vias: v1(240.04,54.82) v1(240.42,48.21) v1(240.93,54.82) v1(241.31,48.21) v1(241.43,49.84) v1(242.07,49.63) v1(243.34,54.56)
5V_LDO1: length 7.8
  BOTTOM w0.381: R785.1 252.57,43.93 252.05,43.41 252.05,40.8 251.66,40.4 v2(250.61,40.4)
  vias: v2(249.97,41.17) v2(249.97,40.4) v2(249.97,39.64) v2(250.61,41.17) v2(250.61,39.64)
5V_LDO2: length 9.3
  L03_SIG1 w0.508: v1(24.54,37.04) 24.52,37.04 23.8,37.76 23.8,41.9 24.77,42.88 26.42,42.88 v1(27.19,43.64)
5V_PG: length 61.5
  TOP w0.127: U43.C2 244.41,52.02 v1(243.95,51.56)
  L07_SIG3 w0.127: v1(243.95,51.56) 243.96,51.56 245.07,52.67 257.4,52.67 257.61,52.45 265.24,52.45 265.69,52.01 265.69,51.13 v1(266.33,50.5)
  L16_SIG6 w0.127: v1(266.33,50.5) 266.33,42.8 266.78,42.34 266.78,36.43 264.71,34.35 264.71,31.9 262.97,30.16 262.97,23.65 260.99,21.67 259.47,21.67 258.96,22.18 257.83,22.18 v1(257.35,22.66)
  BOTTOM w0.127: R431.1 244.04,51.01 243.95,51.11 243.95,51.55 R432.1
12V_AUX: length 1.6
  TOP w0.381: 256.8,98.02 U35.2
  vias: v2(255.02,89.56) v2(255.02,85.73) v2(255.28,94.03) v2(256.29,85.73) v2(258.25,92.41) v2(258.25,91.14) v2(259.87,98.1) v2(261.14,98.1) v2(264.12,91.85) v2(264.12,90.58) v2(264.14,88.09) v2(264.12,86.77) v2(264.14,85.78) v2(264.24,94.16)
12V_G1: length 47.6
  TOP w0.191: U47.32 202.15,59.84 C1817.2
  TOP w0.381: R425.1 259.91,59.83 262.14,57.61 262.14,40.38 266.22,36.29 266.22,33.23 264.95,31.96 264.95,28.1 266.05,27 J15.2
  BOTTOM w0.203: 200.08,52.15 199.04,52.15 ; 201.45,52.17 201.48,52.15 202.57,52.15 ; 197.44,52.15 196.4,52.15 ; 199.09,50.88 199.96,50.88
  BOTTOM w0.381: U36.6 v1(246.23,100.69)
  vias: v1(68.41,101.04) v1(68.41,95.46) v1(68.41,93.42) v1(68.46,103.08) v1(69.27,103.08) v1(69.27,101.04) v1(69.27,95.46) v1(69.27,93.42) v1(186.9,86.61) v1(186.9,86.1) v1(186.9,85.59) v1(186.95,70.74) v1(186.95,55.2) v1(187.03,78.27) v1(187.03,77.18) v1(187.1,37.8) v1(187.18,81.5) v1(187.18,80.9) v1(187.18,80.31) v1(187.18,73.82) v1(187.18,73.26) v1(187.18,72.63) v1(187.18,68.86) v1(187.18,68.25) v1(187.18,67.66) v1(187.18,58.28) v1(187.18,57.71) v1(187.18,57.08) v1(187.18,53.31) v1(187.18,52.68) v1(187.18,52.12) v1(187.26,42.24) v1(187.26,41.61) v1(187.26,41) v1(187.26,40.36) v1(187.51,37.47) v1(187.61,65.66) v1(189.76,30.43) v1(189.76,28.4) v1(189.76,22.81) v1(189.76,20.78) v1(190.62,30.43) v1(190.62,28.4) v1(190.62,22.81) v1(190.62,20.78) v1(193.1,74.17) v1(193.99,74.17) v1(193.99,73.69) v1(194.01,52.15) v1(194.85,52.15) v1(196.98,50.24) v1(197.59,74.96) v1(197.59,74.07) v1(198.25,51.51) v1(198.48,74.96) v1(198.48,74.07) v1(199.37,74.96) v1(199.37,74.07) v1(200.79,51.51) v1(202.06,50.24) v1(202.24,64.77) v1(202.32,65.48) v1(202.83,65.1) v1(202.8,64.47) v1(203.44,61.14) v1(203.38,51.41) v1(203.38,50.57) v1(203.79,51.01) v1(204.86,75.14) v1(204.86,74.25) v1(204.86,73.36) v1(205.75,75.14) v1(205.75,74.25) v1(205.75,73.36) v1(226.96,79.76) v1(232.42,80.34) v1(232.42,79.71) v1(233.18,81.23) v1(233.18,80.34) v1(233.18,79.45) v1(233.18,78.56) v1(233.18,77.93) v1(233.18,77.29) v1(233.81,81.87) v1(233.81,81.23) v1(233.81,80.34) v1(233.81,79.45) v1(233.81,78.56) v1(233.81,77.93) v1(233.81,77.29) v1(234.45,79.45) v1(234.45,78.56) v1(234.45,77.93) v1(234.45,77.29) v1(234.58,82.25) v1(234.58,81.23) v1(234.58,80.34) v1(235.21,80.34) v1(235.21,79.45) v1(235.21,78.56) v1(235.21,77.68) v1(235.21,77.04) v1(235.21,76.41) v1(235.34,82.12) v1(235.34,81.23) v1(236.1,82.12) v1(236.1,81.23) v1(236.1,80.34) v1(236.1,79.45) v1(236.1,78.56) v1(236.1,77.68) v1(236.1,77.04) v1(236.1,76.41) v1(236.99,82.12) v1(236.99,81.23) v1(236.99,80.34) v1(236.99,79.45) v1(236.99,78.56) v1(236.99,77.68) v1(236.99,77.04) v1(236.99,76.41) v1(237.88,82.12) v1(237.88,81.23) v1(237.88,80.34) v1(237.88,79.45) v1(237.88,78.56) v1(237.88,77.68) v1(237.88,77.04) v1(237.88,76.41) v1(238.51,97.36) v1(238.51,96.09) v1(238.51,94.82) v1(238.51,93.55) v1(238.51,92.28) v1(238.56,99.9) v1(238.56,98.63) v1(238.77,82.12) v1(238.77,81.23) v1(238.77,80.34) v1(238.77,79.45) v1(238.77,78.56) v1(238.77,77.68) v1(238.77,77.04) v1(238.77,76.41) v1(239.33,92.89) v1(239.33,91.62) v1(239.83,99.9) v1(239.83,98.63) v1(239.78,97.36) v1(239.78,96.09) v1(240.6,92.89) v1(240.6,91.62) v1(241.05,99.9) v1(241.05,98.63) v1(241.05,97.36) v1(241.05,96.09) v1(241.87,92.89) v1(241.87,91.62) v1(242.32,99.9) v1(242.32,98.63) v1(242.32,97.36) v1(242.32,96.09) v1(242.32,94.82) v1(242.32,93.55) v1(243.34,99.9) v1(243.59,98.63) v1(243.59,97.36) v1(243.59,96.09) v1(243.59,94.82) v1(243.59,93.55) v1(244.62,94.45) v1(244.62,93.8) v1(244.62,93.15) v1(244.86,97.03) v1(244.86,96.09) v1(258.2,59.9) v2(187.13,64.29) v2(187.13,63.66) v2(187.1,62.11) v2(187.1,61.47) v2(187.21,48.44) v2(187.21,47.81) v2(187.31,89.18) v2(187.31,88.55) v2(187.26,45.95) v2(187.26,45.32) v2(190.28,34.42) v2(191.83,80.52) v2(191.8,79.73) v2(191.8,78.08) v2(191.83,77.33) v2(192.01,44.53) v2(191.95,43.72) v3(191.5,47.22)
12V_G1_OV_PG: length 52.1
  L07_SIG3 w0.127: v1(266.33,51.77) 266.33,52.94 265.59,53.67 257.5,53.67 v1(256.67,54.5)
  L16_SIG6 w0.127: v1(256.55,23.46) 256.55,23.45 256.95,23.05 256.95,22.28 258.33,20.91 261.25,20.91 263.63,23.29 263.63,29.98 265.21,31.56 265.21,33.76 267.6,36.15 267.6,42.57 267.06,43.11 267.06,47.17 267.6,47.7 267.6,50.5 v1(266.33,51.77)
12V_G1_PG: length 126.5
  L16_SIG6 w0.203: 261.32,102.52 262.82,101.02 266.63,101.02
  L16_SIG6 w0.254: 261.32,102.52 247.28,102.52 246.34,101.58 245.42,101.58 245.07,101.22 245.07,100.51 245.58,99.99 v1(246.36,99.99) ; v1(254.95,23.46) 254.54,23.05 254.54,19 255.35,18.19 259.62,18.19 264.75,23.32 264.75,30.14 265.97,31.36 265.97,32.62 268.99,35.64 268.99,48.97 271.79,51.77 271.79,95.86 266.63,101.02
  BOTTOM w0.127: R407.2 246.3,100.04 245.8,100.54 245.8,101.17 U36.7
12V_G1_UV_PG: length 55.4
  L05_SIG2 w0.127: v1(269.12,56.97) 270.59,55.5 270.59,47.37 270.77,47.2 270.77,29.77 269.15,28.15 264.9,28.15 262.44,25.68 259.54,25.68 259.32,25.46 258.47,25.46 258.07,25.86 v1(256.55,25.86)
  L07_SIG3 w0.127: v1(259.21,54.5) 260.04,54.5 262.95,57.41 268.69,57.41 v1(269.12,56.97)
12V_G2: length 31.6
  TOP w0.381: v1(254.9,55.51) 256.38,55.51 U42.5
  L07_SIG3 w0.508: v1(247.02,56.85) v1(246.13,56.85)
  L12_SIG4 w0.508: v1(202.06,85.17) 202.75,84.48 205.19,84.48 v1(205.87,85.17) 206.56,84.48 209,84.48 v1(209.68,85.17) 210.34,84.51 212.83,84.51 v1(213.49,85.17) ; v1(211.84,42.5) 211.23,41.89 208.64,41.89 v1(208.03,42.5) 207.45,41.91 204.81,41.91 v1(204.22,42.5) 203.61,41.89 201,41.89 200.41,42.47 v1(200.41,42.5)
  BOTTOM w0.203: U41.6 248.11,78.59 248.47,78.23 v1(248.98,78.23)
  BOTTOM w0.305: 210.19,96.22 209.35,97.06 R5777.1
  vias: v1(50.07,55.88) v1(50.07,55.04) v1(54.53,57.38) v1(54.53,54.27) v1(68.59,43.77) v1(69.07,41.54) v1(69.07,40.74) v1(69.07,37.54) v1(69.07,36.74) v1(69.22,43.77) v1(69.22,43.13) v1(70.19,34.19) v1(70.7,34.55) v1(200.41,41.23) v1(200.41,39.96) v1(202.06,83.9) v1(202.06,82.63) v1(204.22,41.23) v1(204.22,39.96) v1(205.87,83.9) v1(205.87,82.63) v1(208.03,41.23) v1(208.03,39.96) v1(209.28,60.76) v1(209.68,83.9) v1(209.68,82.63) v1(210.04,71.86) v1(210.32,95.46) v1(210.32,94.66) v1(210.55,60.76) v1(211.12,95.46) v1(211.12,94.66) v1(211.31,71.86) v1(211.82,60.76) v1(211.84,41.23) v1(211.84,39.96) v1(211.92,95.46) v1(212.2,78.36) v1(212.63,78.72) v1(212.58,71.86) v1(212.72,95.46) v1(213.49,83.9) v1(213.49,82.63) v1(217.58,61.37) v1(217.58,60.73) v1(218.14,60.76) v1(218.17,61.37) v1(218.7,61.37) v1(218.65,60.76) v1(223.27,58.12) v1(224.54,58.12) v1(225.1,25.67) v1(225.1,25.08) v1(225.08,24.27) v1(225.08,23.69) v1(225.81,58.12) v1(225.79,25.48) v1(225.81,24.89) v1(225.89,24.3) v1(225.91,23.71) v1(226.55,25.48) v1(226.55,24.89) v1(226.65,24.3) v1(226.65,23.71) v1(227.08,58.12) v1(227.57,25.72) v1(227.59,25.13) v1(228.33,25.72) v1(228.33,25.13) v1(228.43,61.72) v1(228.45,61.17) v1(228.45,60.66) v1(229.06,61.72) v1(229.06,61.14) v1(229.06,60.61) v1(232.62,61.6) v1(232.65,61.04) v1(232.65,60.53) v1(233.26,61.6) v1(233.26,61.01) v1(233.26,60.48) v1(233.43,58.12) v1(234.7,58.12) v1(235.11,25.87) v1(235.13,25.29) v1(235.87,25.87) v1(235.87,25.29) v1(235.97,58.12) v1(237.01,25.89) v1(237.04,25.3) v1(237.24,58.12) v1(237.78,25.89) v1(237.78,25.3) v1(238.01,24.47) v1(238.03,23.89) v1(238.26,22.05) v1(238.26,21.41) v1(238.26,20.91) v1(238.26,20.4) v1(238.26,19.89) v1(238.26,19.38) v1(238.26,18.87) v1(238.26,18.37) v1(238.26,17.86) v1(238.39,23.19) v1(238.39,22.68) v1(238.82,25.82) v1(238.84,25.24) v1(238.77,24.47) v1(238.77,23.89) v1(238.77,22.05) v1(238.77,21.41) v1(238.77,20.91) v1(238.77,20.4) v1(238.77,19.89) v1(238.77,19.38) v1(238.77,18.87) v1(238.77,18.37) v1(238.77,17.86) v1(238.77,17.1) v1(239.02,23.19) v1(239.15,22.68) v1(239.28,22.05) v1(239.28,21.41) v1(239.28,20.91) v1(239.28,20.4) v1(239.28,19.89) v1(239.28,19.38) v1(239.28,18.87) v1(239.28,18.37) v1(239.28,17.86) v1(239.28,17.1) v1(239.53,24.47) v1(239.53,23.89) v1(239.53,23.19) v1(239.58,25.82) v1(239.61,25.24) v1(239.78,21.41) v1(239.78,20.91) v1(239.78,20.4) v1(239.78,19.89) v1(239.78,19.38) v1(239.78,18.87) v1(239.78,18.37) v1(239.78,17.86) v1(239.78,17.1) v1(240.29,21.41) v1(240.29,20.91) v1(240.29,20.4) v1(240.29,19.89) v1(240.29,19.38) v1(240.29,18.87) v1(240.29,18.37) v1(240.29,17.86) v1(240.29,17.1) v1(240.8,21.41) v1(240.8,20.91) v1(240.8,20.4) v1(240.8,19.89) v1(240.8,19.38) v1(240.8,18.87) v1(240.8,18.37) v1(240.8,17.86) v1(240.8,17.1) v1(241.31,18.37) v1(241.31,17.86) v1(241.31,17.1) v1(241.82,20.22) v1(241.82,19.71) v1(241.82,19.21) v1(241.82,18.37) v1(241.82,17.86) v1(241.82,17.22) v1(242.32,20.22) v1(242.32,19.71) v1(242.32,19.21) v1(242.32,18.37) v1(242.32,17.86) v1(242.32,17.22) v1(242.7,56.78) v1(242.83,18.37) v1(242.83,17.86) v1(243.34,24.46) v1(243.34,23.95) v1(243.34,23.45) v1(243.34,22.94) v1(243.34,22.43) v1(243.34,21.92) v1(243.34,21.41) v1(243.34,20.91) v1(243.34,20.4) v1(243.34,19.89) v1(243.34,19.38) v1(243.34,18.87) v1(243.34,18.37) v1(243.34,17.86) v1(243.85,24.46) v1(243.85,23.95) v1(243.85,23.45) v1(243.85,22.94) v1(243.85,22.43) v1(243.85,21.92) v1(243.85,21.41) v1(243.85,20.91) v1(243.85,20.4) v1(243.85,19.89) v1(243.85,19.38) v1(243.85,18.87) v1(243.85,18.37) v1(243.85,17.86) v1(244.36,17.86) v1(245.88,55.83) v1(246.13,57.48) v1(247.02,57.48) v1(247.15,55.83) v1(250.2,58.12) v1(250.2,57.1) v1(251.47,58.12) v1(251.47,57.1) v1(252.74,58.12) v1(252.74,57.1) v1(254.01,58.12) v1(254.01,57.1) v2(195.16,39.07) v2(195.16,38.43) v2(195.41,37.87) v2(195.79,39.07) v2(195.79,38.43) v2(196.1,37.87) v2(196.43,39.07) v2(196.43,38.43) v2(196.6,80.47) v2(196.78,37.85) v2(196.98,81.82) v2(196.98,81.18) v2(197.06,39.17) v2(197.06,38.48) v2(197.24,80.47) v2(197.62,81.82) v2(197.62,81.18) v2(197.87,80.47) v2(198.25,81.82) v2(198.25,81.18) v2(198.51,80.47) v2(199.02,81.87) v2(199.02,81.23) v2(208.01,73.08) v2(208.01,71.88) v2(208.11,74.15) v2(209.07,71.88) v2(209.15,73.1) v2(209.96,74.58) v2(210.8,74.63) v2(210.95,73.31) v2(211.16,64.09) v2(211.16,63.45) v2(211.16,62.82) v2(211.79,64.09) v2(211.79,63.45) v2(211.79,62.82) v2(214.71,95.38) v2(215.5,75.54) v2(215.53,74.53) v2(215.55,95.51) v2(215.78,94.57) v2(216.57,95.51) v2(216.8,94.57) v2(218.32,96.47) v2(218.32,94.95) v2(218.32,93.42) v2(240.8,75.77) v2(240.8,74.75) v2(240.8,73.74) v2(240.8,72.72) v2(242.32,75.77) v2(242.32,74.75) v2(242.32,73.74) v2(242.32,72.72) v2(243.85,75.77) v2(243.85,74.75) v2(243.85,73.74) v2(243.85,72.72) v2(245.37,75.77) v2(245.37,74.75) v2(245.37,73.74) v2(245.37,72.72) v2(246.9,74.75) v2(246.9,73.74) v2(246.9,72.72) v2(248.42,74.75) v2(248.42,73.74) v2(248.42,72.72) v2(249.94,74.75) v2(249.94,73.74) v2(249.94,72.72) v2(251.47,74.75) v2(251.47,73.74) v2(251.47,72.72) v2(252.99,74.75) v2(252.99,73.74) v2(252.99,72.72) v2(254.52,73.74) v2(254.52,72.72) v3(216.59,92.2)
12V_G2_PG: length 83.9
  TOP w0.254: R419.1 247.46,78.31 247.53,78.24 v1(247.82,78.24)
  L07_SIG3 w0.127: v1(255.75,23.46) 255.75,22.02 257.12,20.65 260.84,20.65 263.28,23.09 263.28,30.19 266.15,33.06 266.15,41.48 259.43,48.2 v1(253.99,48.2)
  L16_SIG6 w0.127: v1(253.99,48.2) 254.46,48.67 254.46,56.53 256.03,58.09 256.03,59.3 257.11,60.38 257.11,61.75 252.69,66.17 249,66.17 247.86,67.31 247.86,77.8 247.82,77.84 v1(247.82,78.24)
  BOTTOM w0.254: v1(247.82,78.24) 247.61,78.45 U41.7
12V_GROUP1: length 10.7
  BOTTOM w0.254: U36.4 246.73,104.08 247.14,104.49 R406.1
  BOTTOM w0.381: v2(246.36,94.26) 246.36,94.88 246.03,95.21 246.03,97.61 245.46,98.18 R405.1 ; v2(248.01,101.93) 248.01,102.56 248.19,102.73 248.19,104.47 247.94,104.73 247.38,104.73 247.33,104.68 R406.1
  vias: v1(244.62,80.37) v1(262.77,76.34) v2(246.36,93.5) v2(246.36,92.74) v2(247.12,94.26) v2(247.12,93.5) v2(247.12,92.74) v2(248.01,100.92) v2(248.14,99.93) v2(249.03,101.93) v2(249.03,100.92) v2(249.03,99.9) v2(249.03,98.88) v2(249.66,90.08) v2(250.04,101.93) v2(250.04,100.92) v2(250.04,99.9) v2(250.04,98.88) v2(250.04,97.87) v2(250.04,96.85) v2(250.68,94.31) v2(250.68,93.55) v2(250.68,92.79) v2(250.93,90.08) v2(251.06,101.93) v2(251.06,100.92) v2(251.09,99.9) v2(251.06,98.88) v2(251.06,97.87) v2(251.06,96.85) v2(251.44,94.31) v2(251.44,93.55) v2(251.44,92.79) v2(252.08,101.93) v2(252.08,100.92) v2(252.08,99.9) v2(252.08,98.88) v2(252.08,97.87) v2(252.08,96.85) v2(252.2,90.08) v2(252.99,99.9) v2(252.99,98.88) v2(253.09,101.93) v2(253.09,100.92) v2(253.09,97.87) v2(253.83,101.42) v2(253.83,99.39) v2(253.85,100.43) v2(254.85,100.41) v2(254.85,99.39)
12V_GROUP2: length 8.6
  L12_SIG4 w0.508: v1(245.35,79.39) 247.14,77.6 249.23,77.6 251.34,79.71 v2(251.34,80.72)
  vias: v1(246.82,87.81) v1(246.82,86.54) v1(246.82,85.27) v1(246.79,82.93) v1(246.92,84.05) v1(248.09,87.81) v1(248.09,86.54) v1(248.09,85.27) v1(248.09,84) v1(248.06,82.93) v1(249.26,83.95) v1(249.33,82.93) v1(249.36,87.81) v1(249.36,86.54) v1(249.36,85.27) v1(249.36,81.46) v1(250.63,87.81) v1(250.63,86.54) v1(250.63,85.27) v1(250.63,84) v1(250.6,82.93) v1(250.63,81.46) v1(251.47,83.06) v1(251.75,87.84) v1(251.75,86.57) v1(251.75,85.3) v1(251.75,84.03) v1(252.61,87.79) v1(252.61,86.52) v1(252.61,85.25) v1(252.61,83.98) v1(252.58,83.09) v1(254.34,81.33) v1(254.31,80.22) v1(255.02,79.96) v2(251.34,81.49) v2(252.1,81.49) v2(252.1,80.72) v2(252.86,81.49) v2(252.86,80.72) v2(256.34,79.91) v2(256.34,79.15) v2(257.11,79.91) v2(257.11,79.15) v2(257.87,79.91) v2(257.87,79.15)
GND: length 945.1
  TOP w0.203: U77.9 U77.8 U77.7 ; U76.27 188.83,82.39 189.14,82.08 189.14,81.67 189.45,81.36 190.01,81.36 v1(190.56,81.91) ; U77.27 188.85,69.74 189.82,68.77 190.09,68.77 ; U78.31 189.05,56.2 189.44,55.81 189.75,55.81 ; U79.27 188.89,38.02 189.49,37.42 v1(189.64,37.42) ; U77.31 188.91,71.74 189.29,71.37 189.29,71.22 189.54,70.97 189.92,70.97 189.92,70.98 ; U76.9 U76.8 U76.7 ; 216.01,78.82 216.01,79.27 v1(216,79.28) ; U18.9 210.43,104.58 v1(210.19,104.35) ; U78.9 U78.8 U78.7 ; U79.31 189.05,40.02 189.36,39.7 v1(189.64,39.7) ; v1(209.28,104.98) U18.11 ; 234.42,17.94 ST32.2 ; U18.5 212.52,104.51 v1(212.99,104.98) ; U79.9 U79.8 U79.7 ; ST15.2 v1(212.58,69.32) ; v1(211.86,101.44) 211.63,101.68 U18.20 ; 190.06,83.59 189.67,83.59 188.87,84.39 U76.31
  TOP w0.254: U28.6 13.61,23.64 v1(13.09,24.16) ; U28.56 10.3,23.32 v1(9.66,22.68) ; U28.26 16.93,28.82 v1(16.77,28.98) ; U28.12 16.61,24 v1(16.77,24.16) ; U32.21 71.4,85.93 v1(71.01,85.54) ; U28.10 15.61,24.14 v1(15.63,24.16) ; U28.28 v1(18.26,30.25) ; v1(12.07,29.11) 11.61,29.58 U28.41 ; U28.53 9.74,24.82 9.65,24.73 v1(9.53,24.73) ; U13.4 v1(16.94,103.54) ; U28.14 v1(17.61,21.92)
  TOP w0.279: v1(17.15,105.87) 16.85,105.87 16.61,106.1 J10.5 v1(16.61,107.65) ; v1(3.41,24.46) J13.5 5.34,24.46 v1(5.6,24.21)
  TOP w0.356: v1(209.52,94.66) U125.B2 v1(208.32,93.46)
  TOP w0.381: U65.A6 v1(68.39,67.11) ; J7.B32 78.66,5.84 78.45,6.05 v1(78.19,6.05) ; 234.42,17.94 234.65,17.94 234.98,18.27 234.98,18.99 v1(234.78,19.19) ; J7.B61 107.66,5.83 107.88,6.05 v1(108.14,6.05) ; U65.B1 63.1,68 63.31,67.8 63.31,67.31 U65.A1 ; C1208.1 146.82,89.94 v1(146.13,90.62) ; Y4.4 14.21,18.25 14.23,18.23 ; J7.B77 123.66,5.8 123.92,6.05 v1(124.14,6.05) ; J7.B22 68.66,5.74 68.98,6.05 v1(69.14,6.05) ; v1(124.71,9.97) 124.59,10.08 R778.1 ; 14.23,18.23 14.23,17.65 14.01,17.43 11.31,17.43 10.98,17.76 10.98,19.46 ; 14.23,18.23 C342.2 14.23,20.87 13.87,21.24 v1(13.6,21.24) ; v1(83.14,6.05) 82.89,6.05 82.66,5.82 J7.B36 ; J7.B80 126.66,5.82 126.42,6.05 v1(126.19,6.05) ; J7.A49 95.66,5.72 95.33,6.05 v1(95.14,6.05) ; v1(75.19,6.05) 75.42,6.05 75.66,5.81 J7.B29 ; J7.B35 81.66,5.8 81.4,6.05 v1(81.19,6.05) ; v1(116.14,6.05) 115.98,6.05 115.66,5.74 J7.B69 ; C232.1 30.17,89.47 v1(30.28,89.36) ; J7.A4 v1(48.66,6.43) ; v1(112.14,6.05) 111.98,6.05 111.66,5.74 J7.B65 ; v1(71.19,6.05) 71.41,6.05 71.66,5.8 J7.B25 ; v1(118.19,6.05) 118.37,6.05 118.66,5.77 J7.B72 ; v1(24.87,83.15) 24.93,83.15 C242.1 ; J7.B53 99.66,5.79 99.92,6.05 v1(100.14,6.05) ; v1(93.19,6.05) 93.36,6.05 93.66,5.76 J7.B47 ; J7.B64 110.66,5.75 110.36,6.05 v1(110.19,6.05) ; v1(102.19,6.05) 102.4,6.05 102.66,5.79 J7.B56 ; J7.B39 85.66,5.89 85.49,6.05 v1(85.19,6.05) ; Y4.2 11.04,19.4 10.98,19.46 ; J7.B40 86.66,5.78 86.93,6.05 v1(87.14,6.05) ; R5958.2 198.38,54.05 v1(198.25,54.05) ; C839.2 v1(146.63,47.43) ; v1(89.19,6.05) 89.39,6.05 89.66,5.78 J7.B43 ; 10.98,19.46 10.98,19.89 11.5,20.41 C343.2 11.5,20.88 11.86,21.24 v1(12.15,21.24) ; C857.2 v1(85.8,53.43) ; C466.2 253.04,44.73 v1(253.22,44.55) ; J7.B68 114.66,5.77 114.38,6.05 v1(114.19,6.05) ; v1(227.78,38.86) 228.7,38.86 228.84,38.99 v1(229.5,38.99) ; v1(67.19,6.05) 67.48,6.05 67.66,5.87 J7.B21 ; v1(106.19,6.05) 106.33,6.05 106.66,5.73 J7.B60 ; U6.B3 v1(208.01,29.99) ; U50.5 208.16,49.69 v1(208.16,49.46) ; v1(62.19,6.05) 62.39,6.05 62.66,5.78 J7.B16 ; v1(51.57,6.43) 51.57,3.65 J7.B7 ; J7.B73 119.66,5.77 119.95,6.05 v1(120.14,6.05) ; J7.A18 64.66,5.76 64.96,6.05 v1(65.14,6.05) ; v1(65.64,67.11) U65.A2 ; J7.B52 98.66,5.78 98.39,6.05 v1(98.19,6.05) ; J7.B57 103.66,5.82 103.89,6.05 v1(104.14,6.05) ; v1(188.65,88.43) 189.19,87.9 189.19,87.56 189.75,87 C1837.1 ; U35.7 257.3,101.52 U35.4 ; v1(122.19,6.05) 122.38,6.05 122.66,5.77 J7.B76 ; C1873.2 v1(199.52,50.24) ; J7.B26 72.66,5.75 72.97,6.05 v1(73.14,6.05) ; v1(59.32,6.05) 59.66,5.7 J7.B13 ; v1(91.14,6.05) 90.89,6.05 90.66,5.82 J7.B44 ; C2038.2 52.94,54.28 C1990.1
  L03_SIG1 w0.203: v1(146.63,72.45) 146.15,72.93 145.43,72.93 143.41,74.95 142.43,74.95 141.99,75.38 141.65,75.38 141.09,75.94 140.78,75.94 140.3,75.46 139.78,75.46 139.34,75.89 138.96,75.89 138.45,75.38 138.18,75.38 137.64,75.92 137.27,75.92 136.74,75.39 136.35,75.39 135.87,74.91 135.47,74.91 134.93,74.37 134.55,74.37 134.12,73.94 133.76,73.94 133.26,73.43 132.93,73.43 132.42,72.93 132.04,72.93 131.5,72.39 131.1,72.39 130.61,71.91 130.23,71.91 129.72,71.4 129.42,71.4 128.94,70.92 128.56,70.92 128.02,70.39 127.67,70.39 127.16,69.88 126.8,69.88 126.35,69.42 125.97,69.42 125.43,68.89 125.05,68.89 124.57,68.4 124.16,68.4 123.65,67.9 123.32,67.9 122.84,67.41 122.46,67.41 122.04,66.99 121.62,66.99 121.2,67.41 120.79,67.41 120.35,66.97 117.85,66.97 116.61,65.73 113.54,65.73 113.29,65.48 112.15,65.48 111.67,65.96 111.28,65.96 110.8,66.44 110.41,66.44 109.92,65.95 109.53,65.95 109.03,66.44 108.69,66.44 108.23,65.99 107.76,65.99 107.3,66.44 106.92,66.44 106.41,65.93 106.01,65.93 105.82,65.73 105.82,64.73 105.39,64.3 v1(105.39,63.93)
  L05_SIG2 w0.203: v1(207.47,69.65) 206.08,71.05 192.79,71.05 190.76,69.01 189.21,69.01 188.35,69.88 184.08,69.88 182.68,71.28 167.98,71.28 167.7,71 167.29,71 166.91,71.38 162.77,71.38 162.06,70.67 162.06,68.89 162.45,68.5 162.45,68.03 161.91,67.49 161.91,62.56 157.77,58.42 155.3,58.42 153.32,56.44 144.48,56.44 144.18,56.75 144.18,57.23 143.92,57.48 143.34,57.48 142.86,57 142.3,57 141.92,57.38 141.56,57.38 141.05,56.87 140.72,56.87 140.22,56.37 139.83,56.37 139.45,55.98 139,55.98 138.61,56.37 138.01,56.37 137.62,55.98 137.24,55.98 136.74,56.49 136.38,56.49 135.88,56.99 135.5,56.99 135.01,56.49 134.78,56.49 134.27,55.98 133.76,55.98 133.25,56.5 132.92,56.5 132.44,56.97 132.04,56.97 131.55,56.49 131.17,56.49 130.69,56.97 128.71,56.97 128.23,56.49 127.72,56.49 127.34,56.87 126.75,56.87 126.37,56.49 125.99,56.49 125.5,56.99 125.11,56.99 124.62,56.49 124.26,56.49 123.9,56.86 123.26,56.86 122.89,56.49 122.28,56.49 121.17,55.37 120.81,55.37 120.41,54.98 120.41,54.73 v1(120.11,54.43)
  L05_SIG2 w0.254: v1(116.65,73.43) 116.69,73.43 118.04,74.78 118.04,75.06 117.86,75.24 117.86,75.59 118.22,75.95 118.59,75.95 119.05,76.41 119.41,76.41 119.92,76.91 120.27,76.91 120.8,77.44 121.17,77.44 121.68,77.95 122.05,77.95 122.51,78.41 122.86,78.41 123.37,78.92 123.74,78.92 124.24,79.41 124.66,79.41 125.13,78.95 125.51,78.95 125.97,79.4 126.37,79.4 126.84,78.94 127.22,78.94 127.71,79.43 128.09,79.43 128.58,78.94 133.81,78.94 134.32,79.45 135.06,79.45 135.5,79.89 135.91,79.89 136.35,79.45 136.79,79.45 137.22,79.89 137.63,79.89 138.07,79.45 138.49,79.45 138.95,79.91 139.35,79.91 139.83,79.43 140.22,79.43 140.7,79.91 143.02,79.91 143.35,79.58 144.07,79.58 145.34,80.85 157.55,80.85 v1(157.61,80.91)
  L07_SIG3 w0.203: v1(196.32,79.1) 197.26,79.1 200.71,75.64 211.77,75.64 215.41,79.28 v1(216,79.28) ; v1(227.76,56.2) 222.5,56.2 221.62,57.08 217.63,57.08 216.06,58.65 208.13,58.65 207.55,59.24 207.55,61.62 193.5,75.67 v1(193.5,81.38)
  L14_SIG5 w0.203: v1(207.47,69.65) 208.57,68.56 208.57,65.23 207.98,64.65 207.98,62.89 208.06,62.82 208.06,61.88 207.58,61.39 207.58,60.56 209.48,58.65 215.25,58.65 216.87,57.03 222.46,57.03 223.07,56.42 226.02,56.42 226.34,56.74 227.22,56.74 v1(227.76,56.2)
  L14_SIG5 w0.254: v1(202.32,28.53) 202.09,28.3 201.13,28.3 199.74,26.9 196.64,26.9 194.85,28.7 194.85,31.12 190.64,35.33 184.79,35.33 184.01,36.11 184.01,37.55 179.29,42.28 174.08,42.28 172.16,44.2 172.16,44.99 171.52,45.62 170.97,45.62 169.92,46.67 169.92,46.69 169.55,47.06 169.53,47.06 166.96,49.63 165.49,49.63 161.52,53.61 158.41,53.61 158.12,53.9 149.33,53.9 148.75,53.32 144.2,53.32 143.79,52.91 143.32,52.91 142.84,52.43 v1(142.63,52.43)
  L16_SIG6 w0.203: v1(196.32,79.1) 195.94,79.48 195.94,85.63 191.7,89.87 186.14,89.87 184.51,88.24 168.87,88.24 161.73,81.1 158.86,81.1 157.18,79.43 157.18,75.34 156.83,74.98 156.7,74.98 154.64,72.93 154.64,72.49 154.06,71.91 147.17,71.91 v1(146.63,72.45)
  BOTTOM w0.191: ST16.2 68.54,74.83 v1(68.54,74.88) ; U16.P6 U16.N5 U16.P4 ; ST14.2 212.22,46.84 v1(212.38,46.99) ; ST12.2 68.71,60.56 v1(68.36,60.91) ; ST11.2 217.39,71.92 v1(217.39,72.49) ; ST19.2 231.32,47.53 v1(230.89,47.96) ; C1900.1 210.92,57.85 v1(210.55,58.22) ; ST13.2 207.91,85.68
  BOTTOM w0.203: v1(186.04,53.73) 186.34,54.03 186.6,54.03 186.62,54.02 C1997.1 ; v1(64.19,39.68) 63.89,39.37 63.86,39.37 63.71,39.22 ST20.2 ; v1(60.03,56.53) ST17.2 ; U29.13 32.55,44.49 32.33,44.72 ; v1(33.41,40.34) 33.35,40.39 U29.6 ; C1839.1 188.53,81.59 188.83,81.28 189.94,81.28 v1(190.56,81.91) ; ST3.2 v1(209.28,58.22) ; U16.P4 v1(33.28,101.91) ; U15.B1 v1(43.06,108.03)
  BOTTOM w0.216: U16.A6 v1(25.66,100.91) ; v1(32.22,103.96) U16.N1 U16.N2 ; v1(33.28,100.91) U16.P6
  BOTTOM w0.229: U16.J5 v1(30.22,100.92) ; v1(28.72,99.9) 28.72,100.14 28.46,100.41 U16.E7 ; U16.H10 v1(29.72,98.42) ; U16.G5 v1(29.22,101.89) ; U16.K8 v1(31.2,99.9) ; U16.C4 U16.D4 v1(28.2,101.91)
  BOTTOM w0.254: v1(18.04,47.45) 17.6,47.89 U21.4 ; R720.2 80.02,92.36 v1(79.79,92.14) ; ST31.1 v1(208.32,93.46) ; U72.7 201.32,100.81 v1(201.15,100.64) ; U63.1 32.02,72.61 v1(32.27,72.85) 32.52,72.59 U63.2 ; R217.1 v1(50.93,87.07) ; v1(29.19,84.04) 28.92,83.77 U7.29 ; v1(21.98,69.55) 21.96,69.53 U11.26 ; C1262.2 v1(105.39,63.93) ; v1(29.98,47.45) 29.54,47.89 U20.4 ; U40.7 261.25,79.31 U40.4 ; v1(21.98,70.82) 22.23,71.07 U11.20 ; R722.2 81.29,92.44 81.58,92.14 v1(82.34,92.14) 82.56,92.35 R723.2 ; U59.4 53.72,103.47 ; R201.1 v1(52.46,82.25) ; C278.2 v1(107.99,70.43) ; U11.4 v1(17.66,70.57) ; U72.24 205.09,100.81 v1(204.73,101.17) ; v1(52.46,87.84) 51.89,87.84 R202.2 ; v1(24.01,47.45) 23.57,47.89 U22.4 ; U72.15 v1(203.59,104.85) ; U11.24 v1(23.73,69.07) ; C1274.2 v1(106.25,62.43) ; U60.4 205.43,20.94 ; C291.2 v1(107.12,71.93) ; U11.17 v1(23.76,72.57) ; R206.2 v1(50.05,87.07)
  BOTTOM w0.255: v1(205.17,21.97) v1(205.17,21.2) 205.43,20.94 ; v1(53.98,102.44) v1(53.98,103.2) 53.72,103.47
  BOTTOM w0.305: C836.2 v1(123.57,54.43) ; C1216.2 v1(112.32,50.93) ; C1403.2 v1(109.72,52.43) ; C1389.2 v1(123.57,52.43) ; C1278.2 v1(104.52,54.43) ; R711.2 73.67,92.81 v1(72.99,92.14) 72.4,92.74 R710.2 ; C1283.2 v1(106.25,59.43) ; v1(71.26,31.36) 71.23,31.4 71.23,31.96 70.91,32.27 R58.1 ; C1436.2 v1(111.45,56.43) ; C1435.2 v1(109.72,67.43) ; C1306.2 v1(129.64,61.93) ; C1370.2 v1(120.11,52.43) ; R204.1 50.2,81.64 v1(49.31,81.64) ; C1251.2 v1(103.66,58.93) ; C1398.2 v1(114.91,52.43) ; v1(74.74,91.44) 74.94,91.63 R714.2 ; C1348.2 v1(109.72,71.43) ; C1225.2 v1(119.24,50.93) ; C1277.2 v1(104.52,57.43) ; C1355.2 v1(114.91,71.43) ; C737.2 v1(123.57,55.43) ; v1(191.14,93.52) 190.48,93.52 190.09,93.13 R7.1 ; R12.1 117.13,93.49 117.18,93.54 v1(117.19,93.54) ; C1400.2 v1(113.18,53.43) ; C1358.2 v1(111.45,71.43) ; C1371.2 v1(121.84,53.43) ; C1307.2 v1(132.23,65.43) ; R35.1 v1(116.65,84.43) R34.1 ; C1220.2 v1(125.31,51.43) ; C1356.2 v1(111.45,70.43) ; C1399.2 v1(113.18,52.43) ; C1325.2 v1(123.57,70.43) ; C1281.2 v1(127.9,60.93) ; v1(144.38,102.98) 144.79,102.57 R793.1 ; C1437.2 v1(113.18,56.43) ; C279.2 v1(108.85,72.93) ; C1383.2 v1(123.57,53.43) ; C1326.2 v1(121.84,70.43) ; C19.2 131.77,92.81 v1(131.79,92.79) ; C1308.2 v1(132.23,60.43) ; v1(92.54,96.74) 92.67,96.61 U3.7 ; C1223.2 v1(117.51,72.93) ; C1319.2 v1(112.32,72.93) ; C1328.2 v1(121.84,71.43) ; C1310.2 v1(132.23,62.43) ; C1422.2 v1(106.25,69.43) ; C73.2 151.93,19.8 v1(152.04,19.8) 152.12,19.8 C74.2 ; C1260.2 v1(104.52,55.43) ; C1340.2 v1(116.65,71.43) ; C1354.2 v1(118.38,71.43) ; C1397.2 v1(116.65,52.43) ; C29.2 131.77,91.54 v1(131.79,91.52) ; C283.2 v1(103.66,59.93) ; C1438.2 v1(121.84,55.43) ; C1279.2 v1(104.52,62.43) ; C1256.2 v1(105.39,56.93) ; R60.1 107.8,25.61 v1(106.99,24.8) ; C1285.2 v1(104.52,58.43) ; C1369.2 v1(120.11,53.43) ; C1338.2 v1(113.18,71.43) ; C1434.2 v1(113.18,67.43) ; R43.1 v1(118.38,84.43) ; C1305.2 v1(130.5,62.43) ; C1313.2 v1(132.23,64.43) ; C1237.2 v1(125.31,52.43) ; C1401.2 v1(111.45,53.43) ; R11.1 v1(113.79,91.44) ; C1327.2 v1(120.11,70.43) ; C1335.2 v1(115.78,72.93) ; C1273.2 v1(104.52,61.43) ; C1261.2 v1(104.52,60.43) ; C1524.1 255.12,30.44 C398.1 ; C282.2 v1(103.66,60.93) ; C1372.2 v1(121.84,52.43) ; C1396.2 v1(118.38,52.43) ; C1402.2 v1(111.45,52.43) ; R76.1 v1(145.24,24.18) ; C1282.2 v1(105.39,59.93) ; C1255.2 v1(102.79,61.43) ; C1224.2 v1(114.05,72.93) ; C1329.2 v1(120.11,71.43) ; R802.2 198.89,97.74 v1(199.4,97.23) 199.78,97.61 R804.2 ; R209.1 v1(45.47,80.72) ; C1353.2 v1(123.57,71.43) ; C1320.2 v1(115.78,50.93) ; R208.1 v1(46.11,81.61) ; C276.2 v1(127.04,59.43) ; C1252.2 v1(104.52,56.43) ; C275.2 v1(128.77,59.43) ; C1395.2 v1(117.51,50.93) ; C1217.2 v1(119.24,72.93) ; C1439.2 v1(121.84,69.43) ; C1525.2 v1(32.33,46.24) ; C1392.2 v1(109.72,53.43) ; C292.2 v1(107.12,72.93) ; C1347.2 v1(110.58,72.93) ; C1275.2 v1(106.25,54.43) ; C1346.2 v1(113.18,70.43) ; C1238.2 v1(123.57,51.43) ; C1218.2 v1(114.05,50.93)
  BOTTOM w0.381: v1(80.64,31.42) 81.03,31.03 C176.2 ; C1332.2 v1(123.57,88.3) ; J7.A38 84.66,5.83 84.89,6.05 v1(85.19,6.05) ; v1(112.14,6.05) 112.43,6.05 112.66,5.82 J7.A66 ; C705.1 83.7,104.55 v1(83.19,105.06) ; C1376.2 v1(116.65,38.43) C1393.2 ; C1404.2 v1(127.04,38.43) C1379.2 ; v1(204.3,57.18) C1820.2 ; C1254.2 88.67,60.17 v1(88.93,60.43) ; v1(47,104.47) 47,104.85 C264.2 45.98,104.85 v1(45.98,104.47) ; U68.7 79.34,97.05 v1(78.94,97.44) ; C1304.2 v1(130.5,64.43) ; v1(17.15,105.87) 17.15,106 17.72,106.57 C256.1 ; v1(117.19,98.48) 117.32,98.61 R28.1 ; C1259.2 v1(125.31,61.43) ; J7.A20 66.66,5.87 66.85,6.05 v1(67.19,6.05) ; v1(95.14,6.05) 95.42,6.05 95.66,5.81 J7.A49 ; C39.2 97.48,92.7 v1(96.79,92.01) ; C1229.2 v1(130.5,63.43) ; v1(158.05,31.42) 156.39,29.77 U4.7 ; J7.A71 117.66,5.78 117.93,6.05 v1(118.19,6.05) ; C75.2 152.61,31.13 v1(152.89,31.42) ; C1390.2 v1(114.91,39.43) ; C334.1 90.56,104.52 v1(90.02,105.06) ; J7.A31 77.66,5.8 77.91,6.05 v1(78.19,6.05) ; C2027.2 188.5,44.1 v2(190.41,46) ; v1(121.44,20.8) 121.39,20.74 C116.2 ; C1375.2 v1(132.23,38.43) C1373.2 ; v1(73.14,6.05) 73.38,6.05 73.66,5.77 J7.A27 ; C170.1 55.58,50.29 55.58,49.79 55.25,49.46 C169.1 ; v1(244.05,57.04) R438.2 ; U23.7 86.2,97.04 v1(86.59,97.44) ; v1(137.59,102.98) 137.65,103.04 C47.2 ; v1(124.14,6.05) 124.38,6.05 124.66,5.77 J7.A78 ; C420.1 247.25,96.12 v2(247.66,95.71) ; C333.2 91.51,92.19 v1(91.69,92.01) ; C98.2 139.35,30.47 v1(139.29,30.42) ; C1311.2 v1(129.64,66.93) ; 239.68,41.23 239.68,40.27 239.66,40.25 v1(239.66,39.32) ; v1(128.09,6.05) 128.32,6.05 128.51,5.87 128.51,3.72 J7.A82 ; R137.2 34.93,92.92 34.55,93.3 v1(34.04,93.3) ; v1(108.14,6.05) 108.41,6.05 108.66,5.8 J7.A62 ; C162.1 54.35,38.7 v1(54.96,38.7) ; v1(258.95,32.26) v1(259.75,32.26) ; C1272.2 v1(145.63,75.43) ; C1333.2 v1(133.97,84.43) ; 237.5,41.23 v1(237.5,39.45) ; J7.A67 113.66,5.86 113.86,6.05 v1(114.19,6.05) ; C1351.2 v1(111.45,85.43) C1336.2 ; C859.1 88.67,62.69 v1(88.93,62.43) ; C1257.2 v1(125.31,60.43) ; J7.A34 80.66,5.82 80.9,6.05 v1(81.19,6.05) ; C1266.2 v1(143.63,52.43) ; C1352.2 v1(132.23,85.43) C1337.2 ; v1(64.14,6.05) 64.41,6.05 64.66,5.81 J7.A18 ; R145.2 v1(26.17,79.07) ; C1345.2 121.72,85.43 v1(121.84,85.54) 121.96,85.43 C1334.2 ; v1(95.89,104.73) 95.7,104.54 C37.2 ; J7.A58 104.66,5.77 104.38,6.05 v1(104.14,6.05) ; C1264.2 v1(126.17,64.93) ; R8.1 v1(187.74,91.44) ; v1(88.93,65.43) 88.67,65.69 C1247.1 ; v1(110.19,6.05) 109.91,6.05 109.66,5.8 J7.A63 ; J7.A51 97.66,5.84 97.87,6.05 v1(98.19,6.05) ; R9.1 151.23,96.93 151.26,96.9 151.19,96.82 151.23,96.78 v1(151.19,96.74) ; J7.A70 116.66,5.82 116.43,6.05 v1(116.14,6.05) ; U10.3 v1(16.79,73.99) ; v1(79.79,19.5) 80.14,19.85 C173.2 ; v1(88.93,58.43) 88.67,58.69 C1253.2 ; C1331.2 130.5,84.4 v1(130.53,84.43) ; C704.2 83.95,92.23 v1(84.04,92.14) ; C1381.2 v1(127.04,39.43) ; v1(133.34,20.8) 133.35,20.79 C130.2 ; C159.2 55.75,41.48 C160.1 ; v1(106.19,6.05) 105.85,6.05 105.66,5.87 J7.A59 ; v1(145.3,31.7) 145.24,31.75 R62.1 ; C323.2 210.13,103.01 v1(210.19,103.08) ; C1318.2 v1(127.9,63.93) ; v1(75.19,6.05) 74.93,6.05 74.66,5.78 J7.A28 ; C96.2 121.39,28.36 v1(121.44,28.42) ; v1(59.32,6.05) 59.06,6.05 58.81,5.79 58.81,3.71 J7.A12 ; J7.A15 61.66,5.82 61.89,6.05 v1(62.19,6.05) ; C361.2 30.79,25.31 C377.2 ; C1349.2 v1(127.04,85.43) C1339.2 ; v1(105.29,105.06) 104.97,104.74 C1.2 C2.2 ; v1(107.84,19.5) 107.8,19.46 R74.1 ; C1449.2 v1(83.8,54.88) ; v1(69.14,6.05) 69.48,6.05 69.66,5.87 J7.A23 ; C1391.2 v1(121.84,38.43) C1394.2 ; R308.1 v1(268.23,37.29) ; C1219.2 v1(127.04,52.43) ; R63.1 141.84,32.85 142.09,33.1 143.39,33.1 v1(143.52,33.23) ; v1(75.54,104.36) 75.87,104.03 C703.1 ; v1(202.32,28.53) 204.83,28.53 U52.2 ; C280.2 v1(127.9,50.93) ; R24.1 v1(187.74,99.06) ; C1374.2 v1(118.38,39.43) ; C1330.2 v1(132.23,84.43) ; C837.2 v1(125.31,54.43) ; v1(189.64,37.42) 188.92,37.42 C1999.1 ; v1(212.99,104.98) 212.92,105.04 C322.2 ; C1380.2 135.85,37.58 v1(135.7,37.43) ; J7.A4 v1(48.66,6.43) ; J7.A42 88.66,5.8 88.91,6.05 v1(89.19,6.05) ; U67.7 71.72,96.32 v1(71.29,96.74) ; C1365.2 v1(121.84,84.43) ; C1314.2 v1(145.63,61.93) ; J7.A41 87.66,5.76 87.37,6.05 v1(87.14,6.05) ; v1(240.62,84.22) R414.2 ; C1368.2 v1(125.31,39.43) ; C286.2 C287.2 103.64,72.91 v1(103.66,72.93) ; C396.2 73.03,86.69 v1(72.91,86.57) ; C120.2 132.33,20.79 v1(132.33,20.8) ; v1(88.93,67.43) 88.67,67.17 C1430.1 ; C1317.2 v1(126.17,65.93) ; J7.A46 92.66,5.85 92.87,6.05 v1(93.19,6.05) ; J7.A75 121.66,5.86 121.86,6.05 v1(122.19,6.05) ; C1228.2 v1(128.77,62.43) ; v1(83.8,56.91) v1(83.8,57.93) ; v1(112.09,99.64) 111.27,100.46 111.16,100.46 110.39,99.69 v1(110.39,99.09) ; C1270.2 v1(126.17,61.93) ; C1312.2 v1(130.5,67.43) ; U1.7 101.94,96.82 v1(101.89,96.87) ; C702.2 76.33,91.5 v1(76.39,91.44) ; C1448.2 v1(82.8,54.88) ; v1(81.49,18.8) 81.03,19.26 C174.2 ; C1201.2 v1(126.17,55.93) ; v1(209.28,104.98) 209.37,104.89 C320.2 ; C24.2 67.06,98.94 v1(67.04,98.96) ; v1(244.85,41.1) 244.61,41.1 244.48,41.23 241.87,41.23 ; v1(52.03,45.5) 51.38,44.85 C163.2 ; v1(83.14,6.05) 83.4,6.05 83.66,5.79 J7.A37 ; J7.A74 120.66,5.78 120.39,6.05 v1(120.14,6.05) ; v1(100.14,6.05) 100.43,6.05 100.66,5.83 J7.A54 ; C1280.2 v1(81.8,54.88) ; v1(137.59,95.36) 137.65,95.42 C25.2 ; v1(190.58,69.46) 190.58,68.89 190.29,68.6 C1995.1 ; C1360.2 121.83,88.44 v1(121.84,88.43) ; C281.2 v1(128.77,53.43) ; U41.9 247.58,79.99 ; C1359.2 v1(116.65,85.43) C1366.2 ; v1(94.13,38.43) 95.1,39.4 R84.2 ; C1202.2 130.37,55.56 v1(130.5,55.43) ; J7.A24 70.66,5.82 70.89,6.05 v1(71.19,6.05) ; v1(210.02,51.16) 210.55,50.64 v1(210.55,50.48) ; C1382.2 v1(116.65,39.43) ; C1231.2 v1(127.9,64.93) ; Q1.2 16.13,104.03 v1(16.26,104.16) 16.58,104.47 C257.2 ; J7.A45 91.66,5.86 91.47,6.05 v1(91.14,6.05) ; C1230.2 v1(127.9,62.93) ; C838.2 v1(125.31,53.43) ; v1(102.19,6.05) 101.89,6.05 101.66,5.82 J7.A55 ; C1377.2 v1(120.11,39.43) ; R77.1 v1(141.84,25.61) ; v1(126.19,6.05) 125.9,6.05 125.66,5.81 J7.A79 ; C1357.2 v1(127.04,53.43) ; R650.1 C658.2 ; C1258.2 v1(125.31,59.43) ; C1284.2 v1(125.31,63.43) ; C1265.2 v1(125.31,64.43) ; 32.33,44.72 v1(32.33,45.16) ; C1263.2 v1(127.9,61.93) ; C1271.2 v1(144.63,60.93) ; C1309.2 v1(129.64,65.93) ; C1350.2 v1(123.57,84.43)
  BOTTOM w0.635: v1(199.52,48.97) v1(199.52,50.24)
  vias: v1(2.01,17.92) v1(2.67,72.15) v1(2.67,69.36) v1(3.03,17.92) v1(3.37,91.14) v1(3.37,88.47) v1(5.55,26.09) v1(5.82,92.68) v1(5.82,88.87) v1(7.12,75.9) v1(7.31,24.21) v1(7.73,26.9) v1(7.73,25.28) v1(7.75,76.28) v1(8.39,75.9) v1(9.66,18.87) v1(9.79,31.14) v1(10.17,18.37) v1(11.88,90.25) v1(11.88,89.23) v1(12.07,27.84) v1(12.07,26.57) v1(12.07,25.3) v1(12.07,24.16) v1(12.33,48.9) v1(12.33,47.63) v1(12.33,46.36) v1(12.33,45.09) v1(13.09,28.98) v1(13.09,27.84) v1(13.09,26.57) v1(13.09,25.3) v1(14.1,104.16) v1(14.23,75.83) v1(14.23,73.93) v1(14.23,68.09) v1(14.23,66.18) v1(14.23,64.28) v1(14.23,61.48) v1(14.36,28.98) v1(14.36,27.84) v1(14.36,26.57) v1(14.36,25.3) v1(14.36,24.16) v1(14.68,49.48) v1(15.12,104.16) v1(15.25,98.9) v1(15.25,68.09) v1(15.5,76.15) v1(15.5,69.99) v1(15.63,28.98) v1(15.63,27.84) v1(15.63,26.57) v1(15.63,25.3) v1(15.63,20.91) v1(15.82,68.91) v1(16.77,27.84) v1(16.77,26.57) v1(16.77,25.3) v1(17.66,79.96) v1(18.36,64.42) v1(19.16,105.39) v1(19.44,72.09) v1(19.44,70.82) v1(19.44,69.55) v1(19.57,66.75) v1(19.63,49.48) v1(20.01,80.6) v1(20.07,103.2) v1(20.31,74.63) v1(20.64,49.48) v1(20.71,72.09) v1(20.71,70.82) v1(20.71,69.55) v1(21.01,30.88) v1(21.22,26.45) v1(21.79,80.6) v1(21.91,29.03) v1(21.98,72.09) v1(22.04,64.42) v1(23.11,74.63) v1(24.14,75.83) v1(24.35,25.01) v1(24.9,100.03) v1(24.9,99.01) v1(24.9,94.44) v1(24.92,67.66) v1(24.94,24.42) v1(25.41,76.02) v1(25.46,93.23) v1(25.5,86.64) v1(25.47,71.07) v1(25.6,49.48) v1(25.72,64.42) v1(26.03,27.62) v1(26.03,25.22) v1(26.03,22.02) v1(26.29,91.63) v1(26.6,93.05) v1(26.61,49.48) v1(26.68,75.45) v1(26.83,28.42) v1(26.83,18.82) v1(26.9,87.97) v1(26.9,86.7) v1(26.9,85.43) v1(27.11,17.62) v1(27.16,91.03) v1(27.28,80.66) v1(27.33,29.86) v1(27.63,24.42) v1(28.17,87.97) v1(28.17,86.7) v1(28.17,85.43) v1(28.17,80.66) v1(28.33,108.73) v1(28.43,22.02) v1(28.65,92.41) v1(28.86,91.73) v1(29.31,86.7) v1(29.31,85.43) v1(29.34,69.93) v1(29.34,68.91) v1(29.28,66.37) v1(29.41,64.42) v1(29.6,74.25) v1(29.96,71.31) v1(30.03,26.02) v1(30.03,17.62) v1(30.42,60.4) v1(30.84,80.67) v1(30.83,19.62) v1(30.87,108.03) v1(31,30.17) v1(31.06,90.93) v1(31.06,67.13) v1(31.57,49.48) v1(31.63,23.62) v1(31.88,71.07) v1(31.88,30.17) v1(32.01,92.47) v1(32.43,26.82) v1(32.77,71.07) v1(32.77,30.17) v1(33.22,64.42) v1(33.23,27.62) v1(33.23,20.42) v1(33.66,71.07) v1(33.66,30.17) v1(34.04,91.58) v1(34.03,27.62) v1(34.03,25.22) v1(34.17,86.14) v1(34.17,85.63) v1(34.17,68.53) v1(34.49,80.6) v1(34.83,26.82) v1(35.06,81.87) v1(35.44,29.28) v1(35.63,22.82) v1(36.08,95.2) v1(36.08,63.71) v1(36.3,30.2) v1(36.43,28.42) v1(36.43,18.82) v1(36.96,91.58) v1(37.22,63.71) v1(37.23,22.82) v1(37.23,20.42) v1(38.11,81.87) v1(38.11,47.45) v1(38.36,63.71) v1(38.43,28.82) v1(38.43,19.62) v1(38.74,105.11) v1(38.68,104.22) v1(39,92.41) v1(39.12,47.45) v1(39.21,99.77) v1(39.19,98.5) v1(39.21,97.11) v1(39.19,95.96) v1(39.21,94.69) v1(39.76,108.41) v1(39.76,105.11) v1(39.76,64.34) v1(39.76,63.07) v1(39.89,92.41) v1(40.31,39.32) v1(40.52,97.36) v1(40.52,94.31) v1(40.77,63.71) v1(40.82,39.96) v1(41.16,108.09) v1(41.35,21.16) v1(41.79,64.34) v1(41.79,63.07) v1(42.3,87.84) v1(42.3,81.61) v1(42.43,102.12) v1(42.62,21.86) v1(42.93,88.72) v1(43.57,87.84) v1(44.08,66.82) v1(44.08,42.05) v1(44.2,88.72) v1(44.33,68.15) v1(44.33,43.39) v1(44.84,87.84) v1(45.47,88.72) v1(46.11,87.84) v1(46.11,69.67) v1(46.11,68.15) v1(46.11,44.91) v1(46.11,43.39) v1(46.11,18.81) v1(46.74,88.72) v1(46.74,80.72) v1(46.95,55.86) v1(46.95,55.02) v1(46.87,27.89) v1(46.87,26.62) v1(46.87,25.35) v1(46.87,24.08) v1(47.12,18.24) v1(47.25,90.19) v1(47.38,81.61) v1(47.43,55.86) v1(47.43,55.02) v1(47.89,93.02) v1(48.01,80.72) v1(48.14,27.89) v1(48.14,26.62) v1(48.14,25.35) v1(48.14,24.08) v1(48.65,81.61) v1(49.1,75.09) v1(49.1,72.69) v1(49.1,70.29) v1(49.1,65.49) v1(49.1,63.09) v1(49.1,60.69) v1(49.1,50.3) v1(49.1,47.9) v1(49.1,45.5) v1(49.1,40.7) v1(49.1,38.3) v1(49.1,35.9) v1(49.16,18.24) v1(49.41,27.89) v1(49.41,26.62) v1(49.41,25.35) v1(49.41,24.08) v1(50.24,98.12) v1(50.22,39.6) v1(50.68,27.89) v1(50.68,26.62) v1(50.68,25.35) v1(50.68,24.08) v1(51.06,107.39) v1(51.06,106.38) v1(51.06,104.73) v1(51.06,103.2) v1(51.06,101.55) v1(51.06,100.66) v1(51.19,18.24) v1(51.57,103.96) v1(51.82,79.05) v1(52.03,75.09) v1(52.03,72.69) v1(52.03,70.29) v1(52.03,65.49) v1(52.03,63.09) v1(52.03,60.69) v1(52.03,50.3) v1(52.03,47.9) v1(52.03,40.7) v1(52.03,38.3) v1(52.03,35.9) v1(52.08,106.38) v1(52.08,104.73) v1(52.08,103.2) v1(52.08,101.55) v1(52.08,100.66) v1(52.84,95.58) v1(52.84,94.82) v1(52.84,94.06) v1(52.93,56.67) v1(52.92,55.07) v1(52.93,54.27) v1(53.22,18.24) v1(53.35,95.2) v1(53.35,94.44) v1(53.73,54.27) v1(53.86,95.58) v1(53.86,94.82) v1(53.86,94.06) v1(54.96,75.49) v1(54.96,73.09) v1(54.96,70.69) v1(54.96,65.89) v1(54.96,63.49) v1(54.96,61.09) v1(54.96,50.7) v1(54.96,48.3) v1(54.96,45.9) v1(54.96,41.1) v1(54.96,36.3) v1(56.13,56.67) v1(56.13,54.27) v1(56.4,106.76) v1(56.4,105.11) v1(56.4,103.46) v1(56.4,101.86) v1(56.4,100.41) v1(56.59,31.7) v1(56.65,29.67) v1(56.65,27.64) v1(56.65,25.61) v1(56.65,23.57) v1(56.65,21.54) v1(57.41,45.86) v1(57.89,75.49) v1(57.89,73.09) v1(57.89,70.69) v1(57.89,65.89) v1(57.89,63.49) v1(57.89,61.09) v1(57.89,50.7) v1(57.89,48.3) v1(57.89,45.9) v1(57.89,41.1) v1(57.89,38.7) v1(57.89,36.3) v1(58.17,10.56) v1(59.32,9.1) v1(59.95,16.33) v1(60.59,10.56) v1(60.66,8.43) v1(61.66,8.43) v1(62.36,16.97) v1(62.66,12.43) v1(63.23,60.85) v1(63.31,67.11) v1(63.28,54.56) v1(63.28,53.29) v1(63.58,34.57) v1(63.66,12.43) v1(63.99,46.15) v1(64.09,34.22) v1(64.29,49.2) v1(64.5,46.54) v1(64.58,74.73) v1(64.55,60.91) v1(64.78,49.71) v1(65.14,97.44) v1(65.66,8.43) v1(65.85,74.73) v1(65.85,73.46) v1(65.82,60.91) v1(65.82,59.64) v1(65.82,53.29) v1(65.92,10.56) v1(66.38,64.59) v1(66.38,63.58) v1(66.66,8.43) v1(67.04,91.44) v1(66.96,34.95) v1(67.04,30.33) v1(67.04,22.71) v1(67.12,74.73) v1(67.12,67.11) v1(67.09,60.91) v1(67.09,53.29) v1(67.24,34.45) v1(67.47,41.54) v1(67.47,40.74) v1(67.47,39.94) v1(67.47,38.34) v1(67.47,37.54) v1(67.47,36.74) v1(67.57,43.77) v1(67.63,43.09) v1(67.57,42.24) v1(67.66,12.43) v1(67.89,104.81) v1(67.89,97.44) v1(67.89,30.33) v1(67.89,22.71) v1(68.21,35.89) v1(68.27,41.54) v1(68.27,40.74) v1(68.27,39.14) v1(68.27,37.54) v1(68.27,36.74) v1(68.36,53.29) v1(68.74,99.06) v1(68.66,12.43) v1(68.82,91.9) v1(69.07,39.14) v1(69.59,104.8) v1(69.59,97.44) v1(69.63,60.91) v1(69.63,53.29) v1(69.66,74.73) v1(69.66,8.43) v1(69.87,41.54) v1(69.87,40.74) v1(69.87,39.14) v1(69.87,37.54) v1(69.87,36.74) v1(70.44,99.06) v1(70.44,91.44) v1(70.44,26.42) v1(70.44,19.5) v1(70.67,41.54) v1(70.67,40.74) v1(70.67,39.94) v1(70.67,38.34) v1(70.67,37.54) v1(70.67,36.74) v1(70.66,8.43) v1(70.93,74.73) v1(70.9,60.91) v1(70.9,59.64) v1(70.9,53.29) v1(71,67.03) v1(71.29,104.8) v1(71.25,64.47) v1(71.25,63.58) v1(71.29,24.79) v1(71.25,23.7) v1(71.53,44.38) v1(71.53,43.61) v1(71.53,42.98) v1(71.66,12.43) v1(72.14,28.76) v1(72.14,27.76) v1(72.14,21.14) v1(72.14,20.14) v1(72.14,18.8) v1(72.2,74.73) v1(72.17,60.91) v1(72.17,59.64) v1(72.17,53.29) v1(72.66,12.43) v1(72.92,99.06) v1(72.91,85.68) v1(72.91,84.79) v1(72.99,32.42) v1(72.99,24.8) v1(73.44,54.56) v1(73.44,53.29) v1(73.47,68.38) v1(73.47,67.11) v1(73.67,10.56) v1(73.66,8.43) v1(73.84,104.81) v1(73.84,96.74) v1(73.79,86.57) v1(73.79,85.68) v1(73.79,84.79) v1(73.84,26.99) v1(73.84,18.8) v1(74.02,45.84) v1(74.1,37.7) v1(74.35,44.21) v1(74.69,99.64) v1(74.68,86.57) v1(74.68,85.68) v1(74.68,84.79) v1(74.74,67.11) v1(74.71,54.56) v1(74.71,53.29) v1(74.69,31.84) v1(74.69,24.8) v1(74.66,8.43) v1(74.86,43.87) v1(75.32,45.49) v1(75.54,96.74) v1(75.66,12.43) v1(76.01,68.38) v1(76.01,67.11) v1(75.98,54.56) v1(75.98,53.29) v1(76.33,27) v1(76.39,99.06) v1(76.39,18.8) v1(76.6,45.52) v1(76.66,12.43) v1(77.24,105.06) v1(77.24,97.44) v1(77.2,45.63) v1(77.24,31.84) v1(77.24,30.44) v1(77.24,28.44) v1(77.24,24.22) v1(77.24,22.82) v1(77.24,20.82) v1(77.3,44.71) v1(77.63,56.47) v1(77.65,70.31) v1(77.88,29.44) v1(77.88,21.82) v1(78.09,99.06) v1(78.09,91.44) v1(78.09,26.42) v1(78.09,18.8) v1(78.7,72.88) v1(78.67,66.93) v1(78.75,10.56) v1(78.8,47.43) v1(78.8,45.93) v1(78.94,105.06) v1(78.94,32.42) v1(78.94,24.8) v1(79.67,66.93) v1(79.66,8.43) v1(79.79,99.06) v1(79.8,78.03) v1(79.8,74.83) v1(79.8,65.43) v1(79.8,63.93) v1(79.8,47.43) v1(79.8,45.93) v1(79.79,26.42) v1(79.9,76.93) v1(79.93,72.88) v1(80.64,96.74) v1(80.64,24.8) v1(80.65,105.06) v1(80.66,8.43) v1(80.8,78.03) v1(80.8,76.93) v1(80.8,72.88) v1(80.8,65.43) v1(80.8,63.93) v1(80.8,47.43) v1(80.8,45.93) v1(80.78,10.56) v1(81.1,66.93) v1(81.49,26.42) v1(81.66,12.43) v1(81.8,78.03) v1(81.8,72.88) v1(81.8,65.43) v1(81.8,63.93) v1(82,76.93) v1(82.34,99.06) v1(82.34,32.42) v1(82.34,24.8) v1(82.6,66.93) v1(82.66,12.43) v1(82.8,78.03) v1(82.8,72.88) v1(83.19,96.74) v1(83.19,26.42) v1(83.19,18.8) v1(83.6,66.93) v1(83.66,8.43) v1(83.8,53.43) v1(84.04,99.76) v1(84.04,31.72) v1(84.04,24.1) v1(84.66,8.43) v1(84.8,77.85) v1(84.8,73.9) v1(84.8,65.43) v1(84.8,63.93) v1(84.8,62.93) v1(84.8,61.93) v1(84.8,56.91) v1(84.8,53.43) v1(84.8,44.43) v1(84.89,104.35) v1(84.89,97.44) v1(84.89,28.56) v1(85.74,99.06) v1(85.74,91.44) v1(85.71,74.97) v1(85.75,56.91) v1(85.74,26.99) v1(85.74,18.8) v1(85.66,12.43) v1(85.8,73.9) v1(85.8,65.43) v1(85.8,62.93) v1(85.8,61.93) v1(85.8,48.93) v1(86.59,31.72) v1(86.59,24.1) v1(86.66,105.02) v1(86.66,12.43) v1(86.8,74.97) v1(86.8,73.9) v1(86.8,65.43) v1(86.8,62.93) v1(87.44,99.06) v1(87.44,92.01) v1(87.44,27.03) v1(87.44,19.54) v1(87.66,8.43) v1(87.77,74.97) v1(87.8,57.93) v1(87.8,53.93) v1(87.8,50.43) v1(88.29,105.06) v1(88.29,97.44) v1(88.29,31.84) v1(88.29,24.8) v1(88.66,8.43) v1(88.8,71.43) v1(88.93,68.43) v1(88.93,66.43) v1(88.93,64.43) v1(88.93,63.43) v1(88.93,61.43) v1(88.93,59.43) v1(88.93,57.43) v1(88.93,56.43) v1(88.93,55.43) v1(88.93,54.43) v1(88.93,53.43) v1(89.14,99.06) v1(89.14,92.01) v1(89.14,26.42) v1(89.14,19.54) v1(89.66,12.43) v1(89.8,81.93) v1(89.8,80.93) v1(89.8,77.93) v1(89.8,72.93) v1(89.8,68.93) v1(89.8,66.93) v1(89.8,64.93) v1(89.8,62.93) v1(89.8,60.93) v1(89.8,58.93) v1(89.8,56.93) v1(89.8,54.93) v1(89.8,52.93) v1(89.8,50.93) v1(89.8,45.93) v1(89.8,42.93) v1(89.8,41.93) v1(89.99,97.44) v1(89.99,32.42) v1(89.99,24.8) v1(90.67,87.43) v1(90.67,86.43) v1(90.67,82.43) v1(90.67,81.43) v1(90.67,80.43) v1(90.67,75.43) v1(90.67,70.43) v1(90.67,69.43) v1(90.67,67.43) v1(90.67,65.43) v1(90.67,63.43) v1(90.67,61.43) v1(90.67,59.43) v1(90.67,57.43) v1(90.67,55.43) v1(90.67,53.43) v1(90.67,52.43) v1(90.67,50.43) v1(90.67,49.43) v1(90.67,48.43) v1(90.67,47.43) v1(90.67,46.43) v1(90.67,45.43) v1(90.67,44.43) v1(90.67,43.43) v1(90.67,42.43) v1(90.67,41.43) v1(90.66,12.43) v1(90.84,26.42) v1(90.84,19.43) v1(91.53,81.93) v1(91.53,80.93) v1(91.53,77.93) v1(91.53,72.93) v1(91.53,68.93) v1(91.53,67.93) v1(91.53,66.93) v1(91.53,65.93) v1(91.53,64.93) v1(91.53,63.93) v1(91.53,62.93) v1(91.53,61.93) v1(91.53,60.93) v1(91.53,59.93) v1(91.53,58.93) v1(91.53,57.93) v1(91.53,56.93) v1(91.53,55.93) v1(91.53,54.93) v1(91.53,53.93) v1(91.53,52.93) v1(91.53,51.93) v1(91.53,50.93) v1(91.53,41.93) v1(91.69,99.06) v1(91.69,31.8) v1(91.69,24.8) v1(91.66,8.43) v1(92.4,82.43) v1(92.4,81.43) v1(92.4,80.43) v1(92.4,79.43) v1(92.4,78.43) v1(92.4,77.43) v1(92.4,76.43) v1(92.4,75.43) v1(92.4,74.43) v1(92.4,73.43) v1(92.4,70.43) v1(92.4,68.43) v1(92.4,66.43) v1(92.4,64.43) v1(92.4,62.43) v1(92.4,60.43) v1(92.4,58.43) v1(92.4,56.43) v1(92.4,54.43) v1(92.4,52.43) v1(92.4,51.43) v1(92.4,48.43) v1(92.4,43.43) v1(92.4,41.43) v1(92.4,37.43) v1(92.54,104.5) v1(92.54,27.12) v1(92.54,19.54) v1(92.66,8.43) v1(92.87,106.53) v1(93.26,77.93) v1(93.26,72.93) v1(93.26,67.93) v1(93.26,65.93) v1(93.26,63.93) v1(93.26,61.93) v1(93.26,59.93) v1(93.26,57.93) v1(93.26,55.93) v1(93.26,53.93) v1(93.26,51.93) v1(93.26,50.93) v1(93.26,45.93) v1(93.35,106.45) v1(93.39,99.76) v1(93.39,91.44) v1(93.39,31.42) v1(93.39,24.1) v1(93.66,12.43) v1(94.13,89.43) v1(94.13,88.43) v1(94.13,87.43) v1(94.13,86.43) v1(94.13,80.43) v1(94.13,75.43) v1(94.13,70.43) v1(94.13,68.43) v1(94.11,67.41) v1(94.13,66.43) v1(94.13,65.43) v1(94.13,64.43) v1(94.13,63.43) v1(94.13,62.43) v1(94.13,61.43) v1(94.13,60.43) v1(94.13,59.43) v1(94.13,58.43) v1(94.13,57.43) v1(94.13,56.43) v1(94.13,55.43) v1(94.13,54.43) v1(94.13,53.43) v1(94.13,52.43) v1(94.13,51.43) v1(94.13,48.43) v1(94.13,43.43) v1(94.13,37.43) v1(94.13,36.43) v1(94.13,35.43) v1(94.24,105.06) v1(94.24,96.74) v1(94.66,12.43) v1(95,77.93) v1(95,72.93) v1(95,68.93) v1(95,66.93) v1(95,64.93) v1(95,62.93) v1(95,60.93) v1(95,58.93) v1(95,56.93) v1(95,54.93) v1(95,52.93) v1(95,50.93) v1(95,45.93) v1(95.09,99.07) v1(95.09,92.01) v1(95.09,27.03) v1(95.09,19.56) v1(95.7,103.08) v1(95.94,97.44) v1(95.86,89.43) v1(95.86,88.43) v1(95.86,87.52) v1(95.86,86.43) v1(95.86,80.43) v1(95.86,75.43) v1(95.86,70.43) v1(95.86,69.43) v1(95.86,67.43) v1(95.86,65.43) v1(95.86,63.43) v1(95.86,61.43) v1(95.86,59.43) v1(95.86,57.43) v1(95.86,55.43) v1(95.86,53.43) v1(95.86,52.43) v1(95.86,48.43) v1(95.86,43.43) v1(95.94,31.42) v1(95.94,24.1) v1(96.06,35.43) v1(96.06,34.43) v1(96.73,77.93) v1(96.73,72.93) v1(96.73,68.93) v1(96.73,67.93) v1(96.73,66.93) v1(96.73,65.93) v1(96.73,64.93) v1(96.73,63.93) v1(96.73,62.93) v1(96.73,61.93) v1(96.73,60.93) v1(96.73,59.93) v1(96.73,58.93) v1(96.73,57.93) v1(96.73,56.93) v1(96.73,55.93) v1(96.73,54.93) v1(96.73,53.93) v1(96.73,52.93) v1(96.73,51.93) v1(96.73,50.93) v1(96.73,49.93) v1(96.73,48.93) v1(96.73,47.93) v1(96.73,46.93) v1(96.73,45.93) v1(96.73,44.93) v1(96.73,43.93) v1(96.73,42.93) v1(96.73,41.93) v1(96.65,10.56) v1(96.66,8.43) v1(96.79,99.06) v1(96.79,27.03) v1(96.79,18.8) v1(96.86,87.52) v1(96.86,86.43) v1(97.64,105.06) v1(97.64,97.44) v1(97.59,80.43) v1(97.59,75.43) v1(97.59,70.43) v1(97.59,69.43) v1(97.59,68.43) v1(97.59,66.43) v1(97.59,64.43) v1(97.59,62.43) v1(97.59,60.43) v1(97.59,58.43) v1(97.59,56.43) v1(97.59,54.43) v1(97.59,52.43) v1(97.59,51.43) v1(97.59,48.43) v1(97.59,43.43) v1(97.59,35.43) v1(97.59,34.43) v1(97.64,31.01) v1(97.64,24.8) v1(97.66,8.43) v1(97.86,87.52) v1(97.86,86.43) v1(98.49,99.06) v1(98.49,92.14) v1(98.46,81.93) v1(98.46,80.93) v1(98.46,79.93) v1(98.46,78.93) v1(98.46,77.93) v1(98.46,76.93) v1(98.46,75.93) v1(98.46,74.93) v1(98.46,73.93) v1(98.46,72.93) v1(98.46,69.93) v1(98.46,68.93) v1(98.46,67.93) v1(98.46,65.93) v1(98.46,63.93) v1(98.46,61.93) v1(98.46,59.93) v1(98.46,57.93) v1(98.46,55.93) v1(98.46,53.93) v1(98.46,51.93) v1(98.46,50.93) v1(98.46,45.93) v1(98.49,26.42) v1(98.49,18.8) v1(98.66,12.43) v1(99.18,35.43) v1(99.18,34.43) v1(99.34,105.06) v1(99.34,96.74) v1(99.32,89.43) v1(99.32,84.43) v1(99.32,80.43) v1(99.32,75.43) v1(99.32,70.43) v1(99.32,69.43) v1(99.32,68.43) v1(99.32,67.43) v1(99.32,66.43) v1(99.32,65.43) v1(99.32,64.43) v1(99.32,63.43) v1(99.32,62.43) v1(99.32,61.43) v1(99.32,60.43) v1(99.32,59.43) v1(99.32,58.43) v1(99.32,57.43) v1(99.32,56.43) v1(99.32,55.43) v1(99.32,54.43) v1(99.32,53.43) v1(99.32,52.43) v1(99.32,51.43) v1(99.32,48.43) v1(99.32,43.43) v1(99.32,40.43) v1(99.32,39.43) v1(99.34,31.42) v1(99.34,24.8) v1(99.66,12.43) v1(100.19,77.93) v1(100.19,72.93) v1(100.19,69.93) v1(100.19,68.93) v1(100.19,67.93) v1(100.19,66.93) v1(100.19,63.93) v1(100.19,62.93) v1(100.19,61.93) v1(100.19,60.93) v1(100.19,59.93) v1(100.19,58.93) v1(100.19,57.93) v1(100.19,56.93) v1(100.19,55.93) v1(100.19,54.93) v1(100.19,52.93) v1(100.19,50.93) v1(100.19,45.93) v1(100.19,26.42) v1(100.19,18.8) v1(100.66,8.43) v1(101.04,99.06) v1(101.04,92.14) v1(100.97,31.8) v1(101.04,24.8) v1(101.06,89.43) v1(101.06,84.43) v1(101.06,80.43) v1(101.06,75.43) v1(101.06,70.43) v1(101.06,69.43) v1(101.06,68.43) v1(101.06,67.43) v1(101.06,64.43) v1(101.06,55.43) v1(101.06,53.43) v1(101.06,48.43) v1(101.06,43.43) v1(101.06,34.43) v1(101.66,8.43) v1(101.89,105.06) v1(101.92,77.93) v1(101.92,72.93) v1(101.92,69.93) v1(101.92,68.93) v1(101.92,67.93) v1(101.92,66.93) v1(101.92,65.93) v1(101.92,64.93) v1(101.92,60.93) v1(101.92,59.93) v1(101.92,58.93) v1(101.92,54.93) v1(101.92,50.93) v1(101.92,45.93) v1(101.89,26.42) v1(101.86,19.76) v1(102.05,18.37) v1(102.74,99.71) v1(102.74,92.09) v1(102.74,31.84) v1(102.74,24.8) v1(102.66,12.43) v1(102.79,89.43) v1(102.79,88.44) v1(102.79,80.43) v1(102.79,75.43) v1(102.79,70.43) v1(102.79,69.43) v1(102.79,68.43) v1(102.79,67.43) v1(102.79,66.43) v1(102.79,65.43) v1(102.79,64.43) v1(102.79,63.43) v1(102.79,62.43) v1(102.79,58.43) v1(102.79,57.43) v1(102.79,56.43) v1(102.79,55.43) v1(102.79,53.43) v1(102.79,50.43) v1(102.79,49.43) v1(102.79,48.43) v1(102.79,47.43) v1(102.79,46.43) v1(102.79,45.43) v1(102.79,44.43) v1(102.79,43.43) v1(102.79,42.43) v1(102.79,41.43) v1(102.79,36.43) v1(102.87,84.43) v1(103.06,34.43) v1(103.59,104.36) v1(103.59,97.44) v1(103.66,77.93) v1(103.66,69.93) v1(103.66,68.93) v1(103.66,67.93) v1(103.66,66.93) v1(103.66,63.93) v1(103.66,54.93) v1(103.66,50.93) v1(103.66,45.93) v1(103.66,12.43) v1(104.44,99.06) v1(104.44,91.44) v1(104.44,26.99) v1(104.44,18.8) v1(104.52,82.43) v1(104.52,81.43) v1(104.52,80.43) v1(104.52,79.43) v1(104.52,78.43) v1(104.52,77.43) v1(104.52,76.43) v1(104.52,75.43) v1(104.52,74.43) v1(104.52,73.43) v1(104.52,70.43) v1(104.52,69.43) v1(104.52,68.43) v1(104.52,67.43) v1(104.52,63.43) v1(104.52,59.43) v1(104.52,48.43) v1(104.52,43.43) v1(104.52,35.43) v1(104.66,8.43) v1(105.29,97.44) v1(105.29,31.84) v1(105.29,23.8) v1(105.39,77.93) v1(105.39,72.93) v1(105.39,67.93) v1(105.39,65.93) v1(105.39,50.93) v1(105.39,45.93) v1(105.56,89.43) v1(105.56,88.43) v1(105.66,8.43) v1(106.14,99.09) v1(106.14,91.44) v1(106.14,27.29) v1(106.14,18.8) v1(106.25,80.43) v1(106.25,75.43) v1(106.25,71.43) v1(106.25,70.43) v1(106.25,67.43) v1(106.25,56.43) v1(106.25,53.43) v1(106.25,52.43) v1(106.25,48.43) v1(106.25,43.43) v1(106.25,40.43) v1(106.25,39.43) v1(106.25,35.43) v1(106.66,12.43) v1(106.75,93.68) v1(106.99,105.06) v1(106.99,97.44) v1(106.99,31.72) v1(107.12,77.93) v1(107.12,50.93) v1(107.12,45.93) v1(107.38,89.43) v1(107.56,88.43) v1(107.66,12.43) v1(107.84,99.09) v1(107.84,92.14) v1(107.84,27.42) v1(107.99,80.43) v1(107.99,75.43) v1(107.99,69.43) v1(107.99,68.43) v1(107.99,67.43) v1(107.99,66.43) v1(107.99,65.43) v1(107.99,64.43) v1(107.99,63.43) v1(107.99,62.43) v1(107.99,61.43) v1(107.99,60.43) v1(107.99,59.43) v1(107.99,58.43) v1(107.99,57.43) v1(107.99,56.43) v1(107.99,55.43) v1(107.99,54.43) v1(107.99,53.43) v1(107.99,52.43) v1(107.99,48.43) v1(107.99,43.43) v1(107.99,35.43) v1(108.69,96.87) v1(108.69,32.42) v1(108.69,31.42) v1(108.69,29.42) v1(108.69,28.42) v1(108.69,23.8) v1(108.69,21.8) v1(108.69,20.8) v1(108.66,8.43) v1(108.79,105.06) v1(108.85,77.93) v1(108.85,52.93) v1(108.85,51.93) v1(108.85,50.93) v1(108.85,49.93) v1(108.85,48.93) v1(108.85,47.93) v1(108.85,46.93) v1(108.85,45.93) v1(108.85,44.93) v1(108.85,43.93) v1(108.85,42.93) v1(108.85,41.93) v1(109.33,30.42) v1(109.28,22.8) v1(109.35,102.06) v1(109.55,95.46) v1(109.55,93.46) v1(109.72,80.43) v1(109.72,75.43) v1(109.72,70.43) v1(109.72,69.43) v1(109.72,66.43) v1(109.72,65.43) v1(109.72,64.43) v1(109.72,63.43) v1(109.72,62.43) v1(109.72,61.43) v1(109.72,60.43) v1(109.72,59.43) v1(109.72,58.43) v1(109.72,57.43) v1(109.72,56.43) v1(109.72,54.43) v1(109.72,48.43) v1(109.72,43.43) v1(109.72,35.43) v1(109.66,8.43) v1(109.86,18.01) v1(110.12,102.06) v1(110.12,94.44) v1(110.33,92.23) v1(110.58,81.93) v1(110.58,80.93) v1(110.58,79.93) v1(110.58,78.93) v1(110.58,77.93) v1(110.58,76.93) v1(110.58,75.93) v1(110.58,74.93) v1(110.58,54.93) v1(110.58,53.93) v1(110.58,50.93) v1(110.58,45.93) v1(110.66,12.43) v1(110.88,25.61) v1(111.24,104.5) v1(111.24,96.87) v1(111.26,33.23) v1(111.45,87.43) v1(111.45,80.43) v1(111.45,75.43) v1(111.45,69.43) v1(111.45,67.43) v1(111.45,54.43) v1(111.45,48.43) v1(111.45,43.43) v1(111.64,17.99) v1(111.66,12.43) v1(112.09,92.14) v1(112.18,88.43) v1(112.32,77.93) v1(112.32,45.93) v1(112.42,63.93) v1(112.42,62.93) v1(112.42,61.93) v1(112.42,60.93) v1(112.42,59.93) v1(112.42,58.59) v1(112.53,25.61) v1(112.66,8.43) v1(112.94,105.06) v1(112.94,97.44) v1(112.94,33.23) v1(113.08,88.43) v1(113.18,84.43) v1(113.18,80.43) v1(113.18,75.43) v1(113.18,69.43) v1(113.18,66.43) v1(113.18,54.43) v1(113.18,48.43) v1(113.18,43.43) v1(113.18,40.43) v1(113.18,39.43) v1(113.18,36.43) v1(113.18,35.43) v1(113.66,8.43) v1(113.79,99.06) v1(113.8,65.26) v1(113.8,58.59) v1(113.79,30.42) v1(113.79,22.8) v1(114.05,77.93) v1(114.05,45.93) v1(114.43,17.99) v1(114.64,105.06) v1(114.64,103.98) v1(114.64,102.98) v1(114.61,97.44) v1(114.64,95.37) v1(114.64,28.42) v1(114.64,20.8) v1(114.66,12.43) v1(114.8,65.26) v1(114.8,58.59) v1(114.91,88.43) v1(114.91,80.43) v1(114.91,75.43) v1(114.91,70.43) v1(114.91,69.43) v1(114.91,67.43) v1(114.91,56.43) v1(114.91,54.43) v1(114.91,53.43) v1(114.91,50.43) v1(114.91,49.43) v1(114.91,48.43) v1(114.91,47.43) v1(114.91,46.43) v1(114.91,45.43) v1(114.91,44.43) v1(114.91,43.43) v1(114.91,42.43) v1(114.91,41.43) v1(114.91,35.43) v1(115.07,33.23) v1(115.07,25.61) v1(115.66,12.43) v1(115.78,77.93) v1(115.8,65.26) v1(115.8,58.59) v1(115.78,45.93) v1(116.34,30.42) v1(116.34,28.42) v1(116.34,22.8) v1(116.34,20.8) v1(116.65,88.43) v1(116.65,82.43) v1(116.65,81.43) v1(116.65,80.43) v1(116.65,79.43) v1(116.65,78.43) v1(116.65,77.43) v1(116.65,76.43) v1(116.65,75.43) v1(116.65,74.43) v1(116.65,70.43) v1(116.65,69.43) v1(116.65,67.43) v1(116.65,56.43) v1(116.65,54.43) v1(116.65,53.43) v1(116.65,48.43) v1(116.65,43.43) v1(116.65,35.43) v1(116.66,8.43) v1(116.8,65.26) v1(116.8,58.59) v1(117.19,101.14) v1(117.19,90.86) v1(117.19,33.23) v1(117.51,77.93) v1(117.51,45.93) v1(117.61,17.99) v1(117.74,25.61) v1(117.66,8.43) v1(117.8,65.26) v1(117.8,58.59) v1(118.04,30.42) v1(118.04,22.8) v1(118.38,86.43) v1(118.38,80.43) v1(118.38,75.43) v1(118.38,70.43) v1(118.38,69.43) v1(118.38,67.43) v1(118.38,56.43) v1(118.38,54.43) v1(118.38,53.43) v1(118.38,48.43) v1(118.38,43.43) v1(118.38,35.43) v1(118.66,12.43) v1(118.8,65.29) v1(118.89,28.42) v1(118.89,20.8) v1(119.24,77.93) v1(119.24,45.93) v1(119.26,105.87) v1(119.26,98.25) v1(119.26,33.23) v1(119.26,25.61) v1(119.74,101.14) v1(119.74,93.52) v1(119.66,12.43) v1(119.8,65.26) v1(119.9,63.93) v1(119.9,62.93) v1(119.9,61.93) v1(119.9,60.93) v1(119.9,59.93) v1(120.11,80.43) v1(120.11,75.43) v1(120.11,69.43) v1(120.11,67.43) v1(120.11,56.43) v1(120.11,48.43) v1(120.11,43.43) v1(120.15,17.99) v1(120.59,102.98) v1(120.59,95.36) v1(120.59,30.42) v1(120.59,22.8) v1(120.66,8.43) v1(120.78,25.61) v1(120.78,10.56) v1(120.98,77.93) v1(120.98,72.93) v1(120.98,50.93) v1(120.98,49.93) v1(120.98,48.93) v1(120.98,47.93) v1(120.98,46.93) v1(120.98,45.93) v1(120.98,44.93) v1(120.98,43.93) v1(120.98,42.93) v1(120.98,41.93) v1(121.66,8.43) v1(121.8,105.87) v1(121.8,98.25) v1(121.84,80.43) v1(121.84,75.43) v1(121.84,68.43) v1(121.84,67.43) v1(121.84,54.43) v1(121.84,48.43) v1(121.84,43.43) v1(121.8,33.23) v1(122.29,101.14) v1(122.29,93.52) v1(122.71,81.93) v1(122.71,80.93) v1(122.71,79.93) v1(122.71,78.93) v1(122.71,77.93) v1(122.71,76.93) v1(122.71,75.93) v1(122.71,74.93) v1(122.71,73.93) v1(122.71,72.93) v1(122.71,69.93) v1(122.71,68.93) v1(122.71,50.93) v1(122.71,45.93) v1(122.66,12.43) v1(123.14,102.98) v1(123.14,95.36) v1(123.2,18.57) v1(123.58,90.76) v1(123.57,80.43) v1(123.57,75.43) v1(123.57,72.43) v1(123.57,69.43) v1(123.57,68.43) v1(123.57,67.43) v1(123.57,66.43) v1(123.57,65.43) v1(123.57,64.43) v1(123.57,63.43) v1(123.57,62.43) v1(123.57,61.43) v1(123.57,60.43) v1(123.57,59.43) v1(123.57,58.43) v1(123.57,57.43) v1(123.57,56.43) v1(123.57,48.43) v1(123.57,43.43) v1(123.57,35.43) v1(123.66,12.43) v1(124.44,77.93) v1(124.44,72.93) v1(124.44,71.93) v1(124.44,70.93) v1(124.44,50.93) v1(124.44,45.93) v1(124.47,105.87) v1(124.47,98.25) v1(124.66,8.43) v1(124.84,101.14) v1(124.84,93.52) v1(125.31,80.43) v1(125.31,75.43) v1(125.31,70.43) v1(125.31,69.43) v1(125.31,68.43) v1(125.31,67.43) v1(125.31,66.43) v1(125.31,65.43) v1(125.31,62.43) v1(125.31,58.43) v1(125.31,57.43) v1(125.31,56.43) v1(125.31,55.43) v1(125.31,48.43) v1(125.31,43.43) v1(125.31,35.43) v1(125.69,102.98) v1(125.69,98.43) v1(125.69,95.36) v1(125.66,8.43) v1(126.12,90.76) v1(126.17,77.93) v1(126.17,72.93) v1(126.17,67.93) v1(126.17,66.93) v1(126.17,57.93) v1(126.17,50.93) v1(126.17,45.93) v1(126.54,105.87) v1(126.71,102.98) v1(126.66,12.43) v1(127.04,80.43) v1(127.04,75.43) v1(127.04,69.43) v1(127.04,68.43) v1(127.04,67.43) v1(127.04,66.43) v1(127.04,58.43) v1(127.04,51.43) v1(127.04,50.43) v1(127.04,49.43) v1(127.04,48.43) v1(127.04,47.43) v1(127.04,46.43) v1(127.04,45.43) v1(127.04,44.43) v1(127.04,43.43) v1(127.04,42.43) v1(127.04,41.43) v1(127.24,32.42) v1(127.24,31.42) v1(127.24,27.42) v1(127.24,26.42) v1(127.24,24.75) v1(127.24,23.8) v1(127.22,19.67) v1(127.39,101.04) v1(127.66,12.43) v1(127.85,105.87) v1(127.79,98.28) v1(127.77,90.76) v1(127.9,95.33) v1(127.9,77.93) v1(127.9,72.93) v1(127.9,69.93) v1(127.9,67.93) v1(127.9,66.93) v1(127.9,65.93) v1(127.9,59.93) v1(127.9,57.93) v1(127.9,55.93) v1(127.9,45.93) v1(128.77,88.43) v1(128.77,84.43) v1(128.77,83.43) v1(128.77,82.43) v1(128.77,81.43) v1(128.77,80.43) v1(128.77,79.43) v1(128.77,78.43) v1(128.77,77.43) v1(128.77,76.43) v1(128.77,75.43) v1(128.77,74.43) v1(128.77,73.43) v1(128.77,70.43) v1(128.77,67.43) v1(128.77,65.43) v1(128.77,58.43) v1(128.77,55.43) v1(128.77,52.43) v1(128.77,48.43) v1(128.77,43.43) v1(129.42,105.87) v1(129.42,95.33) v1(129.42,25.61) v1(129.55,90.76) v1(129.55,33.23) v1(129.55,18.12) v1(129.64,77.93) v1(129.64,72.93) v1(129.64,70.93) v1(129.64,69.93) v1(129.64,68.93) v1(129.64,67.93) v1(129.64,64.93) v1(129.64,60.93) v1(129.64,59.93) v1(129.64,57.93) v1(129.64,50.93) v1(129.64,45.93) v1(129.93,101.04) v1(130.5,88.43) v1(130.5,80.43) v1(130.5,75.43) v1(130.5,71.43) v1(130.5,69.43) v1(130.5,60.43) v1(130.5,59.43) v1(130.5,58.43) v1(130.5,56.43) v1(130.5,48.43) v1(130.5,43.43) v1(130.5,35.43) v1(131.07,33.23) v1(131.2,18.12) v1(131.37,77.93) v1(131.37,72.93) v1(131.37,71.93) v1(131.37,69.93) v1(131.37,67.93) v1(131.37,59.93) v1(131.37,55.93) v1(131.37,50.93) v1(131.37,45.93) v1(131.58,25.61) v1(131.79,104.98) v1(131.79,103.71) v1(131.79,100.41) v1(131.79,99.14) v1(131.79,97.36) v1(131.79,96.09) v1(132.23,89.43) v1(132.23,88.43) v1(132.23,80.43) v1(132.23,75.43) v1(132.23,72.43) v1(132.23,71.43) v1(132.23,70.43) v1(132.23,69.43) v1(132.23,68.43) v1(132.23,67.43) v1(132.23,66.43) v1(132.23,63.43) v1(132.23,61.43) v1(132.23,59.43) v1(132.23,58.43) v1(132.23,53.43) v1(132.23,48.43) v1(132.23,43.43) v1(132.23,35.43) v1(132.33,28.42) v1(132.85,33.23) v1(133.1,77.93) v1(133.1,72.93) v1(133.1,71.93) v1(133.1,70.93) v1(133.1,69.93) v1(133.1,68.93) v1(133.1,67.93) v1(133.1,66.93) v1(133.1,65.93) v1(133.1,64.93) v1(133.1,63.93) v1(133.1,62.93) v1(133.1,61.93) v1(133.1,60.93) v1(133.1,59.93) v1(133.1,58.93) v1(133.1,57.93) v1(133.1,56.93) v1(133.1,55.93) v1(133.1,52.93) v1(133.1,50.93) v1(133.1,49.93) v1(133.1,48.93) v1(133.1,47.93) v1(133.1,46.93) v1(133.1,45.93) v1(133.1,44.93) v1(133.1,43.93) v1(133.1,42.93) v1(133.1,41.93) v1(133.34,28.52) v1(133.36,18.12) v1(133.74,25.61) v1(133.93,89.43) v1(133.96,88.43) v1(133.96,87.43) v1(133.97,75.43) v1(133.97,71.43) v1(133.97,69.43) v1(133.97,67.43) v1(133.97,65.43) v1(133.97,63.43) v1(133.97,61.43) v1(133.97,59.43) v1(133.97,57.43) v1(133.97,55.43) v1(133.97,53.43) v1(133.97,48.43) v1(133.97,43.43) v1(133.97,35.43) v1(133.97,34.43) v1(134.17,30.42) v1(134.32,22.8) v1(134.83,81.93) v1(134.83,80.93) v1(134.83,79.93) v1(134.83,78.93) v1(134.83,77.93) v1(134.83,76.93) v1(134.83,75.93) v1(134.83,74.93) v1(134.83,73.93) v1(134.83,72.93) v1(134.83,71.93) v1(134.83,69.93) v1(134.83,67.93) v1(134.83,65.93) v1(134.83,63.93) v1(134.83,61.93) v1(134.83,59.93) v1(134.83,57.93) v1(134.83,55.93) v1(134.83,50.93) v1(134.83,45.93) v1(135.39,33.23) v1(135.59,25.61) v1(135.7,89.43) v1(135.7,88.43) v1(135.7,85.43) v1(135.7,80.43) v1(135.7,75.43) v1(135.7,72.43) v1(135.7,71.43) v1(135.7,70.43) v1(135.7,69.43) v1(135.7,68.43) v1(135.7,67.43) v1(135.7,66.43) v1(135.7,65.43) v1(135.7,64.43) v1(135.7,63.43) v1(135.7,62.43) v1(135.7,61.43) v1(135.7,60.43) v1(135.7,59.43) v1(135.7,58.43) v1(135.7,57.43) v1(135.7,56.43) v1(135.7,55.43) v1(135.7,54.43) v1(135.7,53.43) v1(135.7,51.43) v1(135.7,48.43) v1(135.7,43.43) v1(135.7,36.43) v1(135.7,35.43) v1(135.89,28.42) v1(135.9,18.06) v1(136.02,20.78) v1(136.56,77.93) v1(136.56,72.93) v1(136.56,70.93) v1(136.56,68.93) v1(136.56,66.93) v1(136.56,64.93) v1(136.56,62.93) v1(136.56,60.93) v1(136.56,58.93) v1(136.56,56.93) v1(136.56,54.93) v1(136.56,51.93) v1(136.56,50.93) v1(136.56,45.93) v1(136.74,105.87) v1(136.74,30.42) v1(136.74,22.8) v1(136.88,25.64) v1(137.17,98.38) v1(137.17,90.63) v1(137.43,89.43) v1(137.43,88.43) v1(137.43,85.43) v1(137.43,80.43) v1(137.43,75.43) v1(137.43,70.43) v1(137.43,68.43) v1(137.43,66.43) v1(137.43,64.43) v1(137.43,62.43) v1(137.43,60.43) v1(137.43,58.43) v1(137.43,56.43) v1(137.43,54.43) v1(137.43,53.43) v1(137.43,48.43) v1(137.43,43.43) v1(138.06,33.23) v1(138.29,77.93) v1(138.29,72.93) v1(138.29,71.93) v1(138.29,70.93) v1(138.29,69.93) v1(138.29,68.93) v1(138.29,67.93) v1(138.29,66.93) v1(138.29,65.93) v1(138.29,64.93) v1(138.29,63.93) v1(138.29,62.93) v1(138.29,61.93) v1(138.29,60.93) v1(138.29,59.93) v1(138.29,58.93) v1(138.29,57.93) v1(138.29,56.93) v1(138.29,55.93) v1(138.29,54.93) v1(138.29,53.93) v1(138.29,50.93) v1(138.29,45.93) v1(138.44,101.14) v1(138.44,93.52) v1(138.44,28.42) v1(138.44,20.8) v1(138.44,18.12) v1(138.56,25.61) v1(138.82,105.87) v1(138.82,98.12) v1(139.16,88.43) v1(139.16,87.43) v1(139.16,82.43) v1(139.16,80.43) v1(139.16,75.43) v1(139.16,72.43) v1(139.16,71.43) v1(139.16,69.43) v1(139.16,67.43) v1(139.16,65.43) v1(139.16,63.43) v1(139.16,61.43) v1(139.16,59.43) v1(139.16,57.43) v1(139.16,55.43) v1(139.16,53.43) v1(139.16,50.43) v1(139.16,49.43) v1(139.16,48.43) v1(139.16,47.43) v1(139.16,46.43) v1(139.16,45.43) v1(139.16,44.43) v1(139.16,43.43) v1(139.16,42.43) v1(139.16,41.43) v1(139.29,22.8) v1(139.71,98.38) v1(139.71,90.63) v1(140.03,81.93) v1(140.03,77.93) v1(140.03,72.93) v1(140.03,71.93) v1(140.03,69.93) v1(140.03,67.93) v1(140.03,65.93) v1(140.03,63.93) v1(140.03,61.93) v1(140.03,59.93) v1(140.03,57.93) v1(140.03,55.93) v1(140.03,53.93) v1(140.03,52.93) v1(140.03,50.93) v1(140.03,45.93) v1(140.03,41.93) v1(140.14,102.98) v1(140.14,95.42) v1(140.16,88.43) v1(140.16,87.43) v1(140.6,33.35) v1(140.7,25.61) v1(140.89,82.43) v1(140.89,81.43) v1(140.89,80.43) v1(140.89,79.43) v1(140.89,78.43) v1(140.89,77.43) v1(140.89,76.43) v1(140.89,75.43) v1(140.89,74.43) v1(140.89,73.43) v1(140.89,72.43) v1(140.89,71.43) v1(140.89,70.43) v1(140.89,69.43) v1(140.89,68.43) v1(140.89,67.43) v1(140.89,66.43) v1(140.89,65.43) v1(140.89,64.43) v1(140.89,63.43) v1(140.89,62.43) v1(140.89,61.43) v1(140.89,60.43) v1(140.89,59.43) v1(140.89,58.43) v1(140.89,57.43) v1(140.89,56.43) v1(140.89,55.43) v1(140.89,53.43) v1(140.89,48.43) v1(140.89,43.43) v1(140.89,42.43) v1(140.89,41.43) v1(140.89,39.43) v1(140.89,35.38) v1(140.99,101.14) v1(140.99,93.52) v1(140.98,18.12) v1(141.61,90.63) v1(141.84,105.87) v1(141.76,81.93) v1(141.76,80.93) v1(141.76,77.93) v1(141.76,72.93) v1(141.76,70.93) v1(141.76,68.93) v1(141.76,66.93) v1(141.76,64.93) v1(141.76,62.93) v1(141.76,60.93) v1(141.76,58.93) v1(141.76,56.93) v1(141.76,54.93) v1(141.76,53.93) v1(141.76,50.93) v1(141.76,45.93) v1(141.76,42.93) v1(141.76,41.93) v1(141.84,22.8) v1(141.87,98.25) v1(142.63,81.43) v1(142.63,80.43) v1(142.63,75.43) v1(142.63,70.43) v1(142.63,68.43) v1(142.63,66.43) v1(142.63,64.43) v1(142.63,62.43) v1(142.63,60.43) v1(142.63,58.43) v1(142.63,56.43) v1(142.63,54.43) v1(142.63,53.43) v1(142.63,50.43) v1(142.63,49.43) v1(142.63,48.43) v1(142.63,47.43) v1(142.63,46.43) v1(142.63,43.43) v1(142.63,42.43) v1(142.69,102.98) v1(142.69,101.14) v1(142.69,95.42) v1(142.69,93.52) v1(143.52,98.25) v1(143.63,69.93) v1(143.63,68.93) v1(143.63,67.93) v1(143.63,66.93) v1(143.63,65.93) v1(143.63,64.93) v1(143.63,63.93) v1(143.63,62.93) v1(143.63,61.93) v1(143.63,60.93) v1(143.63,59.93) v1(143.63,58.93) v1(143.63,57.93) v1(143.63,56.93) v1(143.63,55.93) v1(143.63,54.7) v1(144.4,95.42) v1(144.39,28.42) v1(144.39,27.42) v1(144.41,26.37) v1(144.39,20.8) v1(144.39,19.8) v1(144.41,18.8) v1(144.48,98.25) v1(144.66,90.63) v1(145.24,105.87) v1(145.24,101.14) v1(145.24,93.52) v1(145.89,35.43) v1(146.09,27.16) v1(146.09,19.8) v1(146.44,98.25) v1(146.63,74.43) v1(146.63,73.43) v1(146.63,44.35) v1(146.94,31.54) v1(146.95,23.83) v1(147.63,70.93) v1(147.63,69.93) v1(147.74,18.8) v1(147.84,98.25) v1(147.79,27.11) v1(148.63,73.43) v1(148.63,70.93) v1(148.63,69.93) v1(148.63,47.43) v1(148.64,24.05) v1(148.72,31.83) v1(148.76,90.78) v1(148.85,21.8) v1(149.49,30.42) v1(149.49,22.8) v1(149.49,20.8) v1(149.62,73.43) v1(149.62,62.93) v1(149.62,61.93) v1(149.69,102.14) v1(149.69,101.09) v1(149.71,93.52) v1(150.3,102.14) v1(150.34,100.07) v1(150.34,95.46) v1(150.34,94.52) v1(150.34,92.52) v1(150.34,91.44) v1(150.34,27.11) v1(150.39,18.8) v1(150.52,101.09) v1(150.6,70.93) v1(150.62,65.93) v1(150.62,56.93) v1(150.62,53.43) v1(150.62,51.43) v1(151.14,24.05) v1(151.19,31.84) v1(151.27,104.54) v1(151.62,69.93) v1(151.62,65.93) v1(151.62,56.93) v1(151.62,53.43) v1(151.62,51.43) v1(151.62,47.43) v1(151.81,70.93) v1(152.04,99.06) v1(152.04,92.14) v1(152.04,27.11) v1(152.62,69.93) v1(152.62,65.93) v1(152.62,60.93) v1(152.62,56.93) v1(152.62,53.43) v1(152.62,51.43) v1(152.62,47.43) v1(152.72,103.08) v1(152.89,105.06) v1(152.89,97.44) v1(152.89,23.8) v1(153.62,69.93) v1(153.62,60.93) v1(153.62,47.43) v1(153.74,99.06) v1(153.74,92.14) v1(153.74,27.11) v1(153.74,19.8) v1(154.59,105.06) v1(154.59,96.87) v1(154.62,69.93) v1(154.62,60.93) v1(154.59,31.42) v1(154.59,24.18) v1(155.44,27.11) v1(155.44,19.8) v1(155.62,75.43) v1(155.62,71.43) v1(155.62,69.93) v1(155.62,67.93) v1(155.62,65.93) v1(155.62,64.93) v1(155.62,62.93) v1(155.62,58.93) v1(155.62,57.93) v1(155.62,55.93) v1(155.62,54.93) v1(155.62,50.43) v1(155.62,48.43) v1(155.71,87.9) v1(155.71,84.98) v1(156.24,31.42) v1(156.29,99.06) v1(156.29,92.14) v1(156.37,24.13) v1(156.62,78.43) v1(156.62,77.43) v1(156.62,75.43) v1(156.62,73.43) v1(156.62,71.43) v1(156.62,69.93) v1(156.62,67.93) v1(156.62,65.93) v1(156.62,64.93) v1(156.62,62.93) v1(156.62,60.93) v1(156.62,58.93) v1(156.62,57.93) v1(156.62,55.93) v1(156.62,54.93) v1(156.62,53.43) v1(156.62,52.43) v1(156.62,50.43) v1(156.62,48.43) v1(157.14,104.5) v1(157.14,96.87) v1(157.09,27.11) v1(157.14,19.8) v1(157.62,78.43) v1(157.62,77.43) v1(157.62,75.43) v1(157.62,73.43) v1(157.62,72.43) v1(157.62,71.43) v1(157.62,69.93) v1(157.62,67.93) v1(157.62,65.93) v1(157.62,64.93) v1(157.62,62.93) v1(157.62,60.93) v1(157.62,58.93) v1(157.62,57.93) v1(157.62,55.93) v1(157.62,54.93) v1(157.62,53.43) v1(157.62,52.43) v1(157.62,50.43) v1(157.62,48.43) v1(157.99,99.76) v1(157.99,91.44) v1(157.99,24.1) v1(158.84,105.06) v1(158.84,97.44) v1(159.69,99.06) v1(159.69,91.44) v1(159.74,27.11) v1(159.69,19.8) v1(160.54,105.06) v1(160.54,97.44) v1(160.49,31.42) v1(160.54,24.1) v1(160.62,36.43) v1(160.62,35.43) v1(161.39,99.06) v1(161.39,91.44) v1(161.39,27.11) v1(161.39,18.8) v1(161.5,70.26) v1(161.63,40.85) v1(161.62,36.43) v1(161.62,35.43) v1(161.75,68.28) v1(162.24,105.06) v1(162.24,97.44) v1(162.24,24.18) v1(162.26,83.87) v1(162.31,55.7) v1(162.31,54.87) v1(162.32,31.42) v1(162.49,69.09) v1(162.62,36.43) v1(162.62,35.43) v1(162.72,84.43) v1(162.72,40.87) v1(163.09,99.06) v1(163.09,92.14) v1(163.1,54.23) v1(163.09,27.11) v1(163.09,18.8) v1(163.94,105.06) v1(163.94,96.87) v1(163.94,31.42) v1(163.94,23.4) v1(164.79,26.42) v1(164.79,18.8) v1(165.64,99.06) v1(165.64,91.44) v1(165.64,31.72) v1(165.64,23.4) v1(166.49,104.36) v1(166.49,96.74) v1(166.49,27.24) v1(166.49,18.8) v1(166.91,80.29) v1(166.89,72.89) v1(166.91,70.64) v1(166.91,55.5) v1(166.94,50.83) v1(166.96,60.07) v1(167.04,54.59) v1(167.19,78.34) v1(167.34,99.76) v1(167.34,91.44) v1(167.33,80.6) v1(167.33,66.37) v1(167.33,61.8) v1(167.33,59.51) v1(167.33,50.37) v1(167.33,48.08) v1(167.34,31.42) v1(167.34,24.8) v1(167.49,71.43) v1(167.55,66.88) v1(167.49,62.33) v1(167.45,44.53) v1(167.45,42.24) v1(167.75,81.16) v1(167.67,72.95) v1(167.8,78.62) v1(168.19,105.06) v1(168.19,97.44) v1(169.04,99.06) v1(169.04,91.44) v1(169.04,27.03) v1(169.04,18.8) v1(169.89,105.06) v1(169.89,97.44) v1(169.89,31.42) v1(169.89,24.1) v1(170.74,99.06) v1(170.74,91.44) v1(170.74,26.42) v1(170.74,18.8) v1(171.59,105.06) v1(171.59,97.44) v1(171.59,32.42) v1(171.59,24.8) v1(172.44,99.06) v1(172.44,92.14) v1(172.44,26.42) v1(172.44,18.8) v1(173.29,105.06) v1(173.29,96.36) v1(173.29,32.42) v1(173.29,24.8) v1(174.14,26.42) v1(174.14,18.8) v1(174.99,99.06) v1(174.99,92.14) v1(174.99,32.42) v1(174.99,24.8) v1(175.84,104.5) v1(175.84,96.87) v1(175.84,27.12) v1(175.84,18.8) v1(176.69,99.76) v1(176.69,91.44) v1(176.69,31.42) v1(176.69,24.8) v1(177.54,105.06) v1(177.54,97.44) v1(177.93,62.82) v1(178.06,48.08) v1(178.39,99.06) v1(178.39,91.44) v1(178.39,47.2) v1(178.39,27.12) v1(178.39,18.8) v1(179.24,105.06) v1(179.24,97.44) v1(179.24,31.42) v1(179.24,24.22) v1(180.09,99.06) v1(180.09,91.44) v1(180.09,26.42) v1(180.09,18.8) v1(180.4,89.44) v1(180.94,105.06) v1(180.94,97.44) v1(180.94,32.42) v1(180.94,24.8) v1(180.98,95.46) v1(180.98,94.06) v1(181.16,102.04) v1(181.79,103.04) v1(181.79,101.04) v1(181.79,99.06) v1(181.79,93.42) v1(181.79,92.14) v1(181.79,26.42) v1(181.79,18.8) v1(182.64,105.06) v1(182.64,96.87) v1(182.64,32.42) v1(182.64,24.8) v1(183.49,26.42) v1(183.49,18.8) v1(183.9,39.45) v1(184.16,83.67) v1(184.16,83.19) v1(184.16,71.05) v1(184.16,70.42) v1(184.16,55.51) v1(184.16,54.87) v1(184.34,99.06) v1(184.34,91.44) v1(184.28,39.09) v1(184.34,31.72) v1(184.34,24.67) v1(184.92,83.67) v1(184.92,83.19) v1(184.92,71.05) v1(184.92,70.42) v1(184.92,55.51) v1(184.92,54.87) v1(185.15,42.2) v1(185.15,41.28) v1(185.15,40.32) v1(185.1,39.42) v1(185.18,105.06) v1(185.19,96.87) v1(185.19,26.99) v1(185.19,19.05) v1(185.3,86.69) v1(185.3,85.93) v1(185.3,85.17) v1(185.27,81.92) v1(185.27,81.16) v1(185.27,80.39) v1(185.3,74.05) v1(185.3,73.29) v1(185.3,72.53) v1(185.27,69.27) v1(185.27,68.51) v1(185.27,67.75) v1(185.3,58.5) v1(185.3,57.74) v1(185.3,56.98) v1(185.27,53.73) v1(185.27,52.97) v1(185.27,52.21) v1(185.4,41.73) v1(185.35,40.8) v1(185.4,39.07) v1(185.45,42.67) v1(185.63,40.06) v1(185.58,35.89) v1(185.68,86.31) v1(185.68,85.55) v1(185.68,84.79) v1(185.68,83.67) v1(185.68,83.19) v1(185.66,81.54) v1(185.66,80.77) v1(185.66,80.01) v1(185.68,73.67) v1(185.68,72.91) v1(185.68,72.14) v1(185.68,71.05) v1(185.68,70.42) v1(185.66,68.89) v1(185.66,68.13) v1(185.66,67.37) v1(185.68,58.12) v1(185.68,57.36) v1(185.68,56.6) v1(185.68,55.51) v1(185.68,54.87) v1(185.66,53.35) v1(185.66,52.59) v1(185.66,51.82) v1(185.66,42.19) v1(185.66,41.25) v1(185.81,39.45) v1(185.76,38.74) v1(185.81,34.57) v1(186.04,99.76) v1(186.04,91.44) v1(186.04,81.92) v1(186.04,81.16) v1(186.04,80.39) v1(186.04,69.27) v1(186.04,68.51) v1(186.04,67.75) v1(186.04,52.97) v1(186.04,52.21) v1(186.04,31.72) v1(186.04,23.97) v1(186.06,86.69) v1(186.06,85.93) v1(186.06,85.17) v1(186.06,74.05) v1(186.06,73.29) v1(186.06,72.53) v1(186.06,58.5) v1(186.06,57.74) v1(186.06,56.98) v1(186.19,34.17) v1(186.89,103.71) v1(186.89,102.71) v1(186.89,97.44) v1(186.89,96.09) v1(186.89,95.09) v1(187.74,26.99) v1(187.74,19.05) v1(188.59,105.06) v1(188.59,97.44) v1(188.65,60.24) v1(188.59,31.72) v1(188.57,23.97) v1(189.24,49.98) v1(189.44,27.18) v1(189.44,18.8) v1(189.5,79.66) v1(189.47,65.5) v1(190.29,32.41) v1(190.29,24.16) v1(190.55,74.7) v1(190.55,36.73) v1(190.81,86.64) v1(191.04,87.23) v1(191.14,101.14) v1(191.14,26.42) v1(191.14,18.8) v1(191.22,38.28) v1(191.8,55.32) v1(191.85,54.16) v1(191.99,101.14) v1(191.99,93.52) v1(191.99,32.41) v1(191.99,24.79) v1(192.08,39.04) v1(192.42,64.54) v1(192.45,63.62) v1(192.79,55.3) v1(192.87,38.28) v1(193.1,62.46) v1(193.45,68.38) v1(193.81,49.1) v1(193.96,68.38) v1(194,26.42) v1(194,18.8) v1(194.24,53.16) v1(194.8,49.08) v1(194.88,53.16) v1(195.28,66.96) v1(196.03,51.51) v1(196.1,50.05) v1(196.86,68.35) v1(197.17,67.03) v1(197.75,64.09) v1(197.75,63.07) v1(197.75,62.31) v1(197.75,61.55) v1(197.75,60.53) v1(197.75,59.64) v1(197.75,58.88) v1(197.75,57.86) v1(198.13,107.14) v1(198.19,43.77) v1(198.74,46.59) v1(198.74,45.95) v1(198.76,67.11) v1(198.76,62.31) v1(198.76,59.64) v1(199.04,54.93) v1(199.14,42.5) v1(199.14,41.23) v1(199.65,62.31) v1(199.65,59.64) v1(200.11,54.54) v1(200.41,107.14) v1(200.41,38.69) v1(200.41,37.42) v1(200.72,66.96) v1(200.67,62.31) v1(200.67,59.64) v1(200.79,85.17) v1(200.79,83.9) v1(200.79,54.05) v1(201.35,54.77) v1(201.62,66.14) v1(201.68,107.14) v1(201.68,42.5) v1(201.94,97.55) v1(202.06,81.36) v1(202.06,80.09) v1(202.5,63.48) v1(202.64,88.72) v1(202.7,19.51) v1(202.7,17.48) v1(202.76,24) v1(202.76,22.55) v1(202.76,20.95) v1(202.95,102.95) v1(202.95,102.06) v1(202.95,101.17) v1(202.95,97.55) v1(203.02,52.78) v1(202.95,42.5) v1(202.95,41.23) v1(202.95,39.96) v1(203.33,85.17) v1(203.84,102.95) v1(203.84,102.06) v1(203.84,101.17) v1(203.97,107.14) v1(204.22,38.69) v1(204.22,37.42) v1(204.32,61.12) v1(204.35,60.18) v1(204.3,56.12) v1(204.3,55.23) v1(204.43,68.94) v1(204.43,67.92) v1(204.43,66.88) v1(204.43,65.86) v1(204.45,97.54) v1(204.6,85.17) v1(204.6,83.9) v1(204.6,82.63) v1(204.6,48.44) v1(204.73,102.95) v1(204.73,102.06) v1(205.04,53.42) v1(205.29,97.58) v1(205.49,42.5) v1(205.59,48.44) v1(205.87,81.36) v1(205.87,80.09) v1(206,58.79) v1(206.76,42.5) v1(206.76,41.23) v1(206.76,39.96) v1(206.95,105.23) v1(206.95,102.57) v1(207.14,85.17) v1(207.07,50.46) v1(207.07,24) v1(207.07,23.11) v1(207.07,21.2) v1(207.07,19.68) v1(207.07,18.03) v1(207.58,20.44) v1(208.01,58.22) v1(208.03,38.69) v1(208.03,37.42) v1(208.01,32.54) v1(208.09,24) v1(208.09,23.11) v1(208.09,21.2) v1(208.09,19.68) v1(208.09,18.03) v1(208.09,17.01) v1(208.22,46.12) v1(208.41,85.17) v1(208.41,83.9) v1(208.41,82.63) v1(208.43,63.96) v1(208.43,63.07) v1(209.01,32.54) v1(209.3,42.5) v1(209.4,53.42) v1(209.52,97.86) v1(209.52,95.46) v1(209.68,81.36) v1(209.68,80.09) v1(209.66,50.48) v1(209.81,100.47) v1(210.02,51.92) v1(210.14,69.42) v1(210.32,97.86) v1(210.55,59.49) v1(210.65,69.99) v1(210.57,41.23) v1(210.57,39.96) v1(210.7,53.5) v1(210.83,103.71) v1(210.76,49.15) v1(210.95,85.17) v1(211.12,97.86) v1(211.31,70.59) v1(211.31,69.32) v1(211.46,104.35) v1(211.46,103.08) v1(211.82,58.22) v1(211.84,38.69) v1(211.84,37.42) v1(211.92,97.86) v1(212.22,83.9) v1(212.22,82.63) v1(212.72,97.86) v1(213.06,74.55) v1(213.49,81.36) v1(213.49,80.09) v1(213.75,104.92) v1(213.75,102.25) v1(213.7,97.86) v1(213.67,74.55) v1(213.85,69.32) v1(214.08,61.78) v1(214.33,54.33) v1(214.33,53.82) v1(214.5,97.86) v1(214.59,61.78) v1(214.84,54.33) v1(214.84,53.82) v1(215.09,61.78) v1(215.08,37.04) v1(215.3,49.99) v1(215.48,97.86) v1(215.88,49.99) v1(216.28,97.86) v1(216.39,50.5) v1(216.86,37.04) v1(217.25,52.04) v1(217.25,51.54) v1(217.56,49.99) v1(217.76,52.04) v1(217.76,51.54) v1(218.06,55.02) v1(218.06,54.51) v1(218.07,49.99) v1(218.57,55.02) v1(218.57,54.51) v1(218.57,49.99) v1(218.7,24.72) v1(218.7,22.18) v1(218.7,19.76) v1(219.51,63.73) v1(219.51,63.15) v1(219.74,49.99) v1(219.72,24.72) v1(219.72,22.18) v1(219.72,19.76) v1(220.25,49.99) v1(220.68,38.03) v1(220.68,37.01) v1(220.76,49.99) v1(222.53,107.87) v1(223.27,56.85) v1(223.27,55.58) v1(223.27,54.31) v1(223.27,53.04) v1(223.27,51.77) v1(223.27,50.5) v1(223.27,49.23) v1(223.46,73.77) v1(223.46,72.5) v1(224.54,55.58) v1(224.54,54.31) v1(224.54,53.04) v1(224.54,51.77) v1(224.54,50.5) v1(224.54,49.23) v1(224.73,73.77) v1(224.73,72.5) v1(224.73,71.23) v1(225.38,61.72) v1(225.41,61.17) v1(225.41,60.66) v1(225.51,30.46) v1(225.53,29.87) v1(225.69,62.51) v1(225.81,56.85) v1(225.81,55.58) v1(225.81,54.31) v1(225.81,53.04) v1(225.81,51.77) v1(225.81,49.23) v1(225.79,27.38) v1(225.81,26.79) v1(226,78.85) v1(226,77.58) v1(226,76.31) v1(226,75.04) v1(226,73.77) v1(226,72.5) v1(226,71.23) v1(226,69.96) v1(226,68.69) v1(226,67.42) v1(226,66.15) v1(226,64.88) v1(225.99,63.05) v1(226.02,61.72) v1(226.02,61.14) v1(226.02,60.61) v1(226.27,30.46) v1(226.27,29.87) v1(226.45,62.51) v1(226.55,27.38) v1(226.55,26.79) v1(226.75,63.96) v1(226.75,63.07) v1(227.13,82.53) v1(227.13,81.64) v1(227.08,53.04) v1(227.08,49.23) v1(227.27,78.85) v1(227.27,77.58) v1(227.27,76.31) v1(227.27,75.04) v1(227.27,73.77) v1(227.27,72.5) v1(227.27,71.23) v1(227.27,69.96) v1(227.27,68.69) v1(227.27,67.42) v1(227.27,66.15) v1(227.27,64.88) v1(227.51,30.75) v1(227.54,30.16) v1(227.64,63.96) v1(227.64,63.07) v1(227.57,27.24) v1(227.59,26.66) v1(228.02,82.53) v1(228.02,81.64) v1(228.28,30.75) v1(228.28,30.16) v1(228.33,27.24) v1(228.33,26.66) v1(228.35,64.06) v1(228.35,63.05) v1(228.35,58.12) v1(228.35,47.96) v1(228.54,78.85) v1(228.54,77.58) v1(228.54,76.31) v1(228.54,75.04) v1(228.54,68.69) v1(228.54,67.42) v1(228.54,66.15) v1(228.54,64.88) v1(228.78,82.53) v1(228.78,81.64) v1(229.01,47.37) v1(229.12,64.09) v1(229.12,63.05) v1(229.62,56.85) v1(229.62,47.96) v1(229.81,78.85) v1(229.81,77.58) v1(229.81,76.31) v1(229.81,75.04) v1(229.81,68.69) v1(229.81,67.42) v1(229.81,66.15) v1(229.81,64.88) v1(230,64.09) v1(229.98,63.02) v1(230.26,53.53) v1(230.26,47.26) v1(230.89,58.12) v1(230.89,56.85) v1(231.08,76.31) v1(231.08,75.04) v1(231.08,68.69) v1(231.08,67.42) v1(231.22,26.52) v1(231.22,25.71) v1(231.22,24.67) v1(231.22,23.85) v1(232.16,58.12) v1(232.16,56.85) v1(232.16,47.96) v1(232.35,77.58) v1(232.35,67.42) v1(232.35,66.15) v1(232.65,84.28) v1(232.57,26.52) v1(232.57,25.71) v1(232.57,24.67) v1(232.57,23.85) v1(232.67,86.24) v1(232.67,85.35) v1(233.43,56.85) v1(233.53,84.28) v1(233.56,86.24) v1(233.56,85.35) v1(234.32,86.24) v1(234.32,85.35) v1(234.3,84.28) v1(234.7,56.85) v1(234.7,55.58) v1(234.7,54.31) v1(234.7,53.04) v1(234.7,49.23) v1(235.11,27.39) v1(235.13,26.81) v1(235.74,84.23) v1(235.67,61.6) v1(235.69,61.04) v1(235.69,60.53) v1(235.95,103.03) v1(235.92,30.76) v1(235.92,30.19) v1(235.87,27.39) v1(235.87,26.81) v1(235.97,55.58) v1(235.97,54.31) v1(235.97,53.04) v1(235.97,51.77) v1(235.97,50.5) v1(235.97,49.23) v1(236.13,85.5) v1(236.3,61.6) v1(236.3,61.01) v1(236.3,60.48) v1(236.43,30.75) v1(236.43,30.16) v1(236.61,59.58) v1(236.63,49.84) v1(236.86,84.66) v1(236.99,27.06) v1(237.19,103.03) v1(237.24,56.85) v1(237.24,55.58) v1(237.24,54.31) v1(237.24,53.04) v1(237.24,51.77) v1(237.24,50.5) v1(237.24,49.23) v1(237.34,27.51) v1(237.5,30.15) v1(237.52,29.57) v1(237.73,27.06) v1(237.78,83.8) v1(237.93,103.05) v1(238.18,70.49) v1(238.18,69.98) v1(238.18,68.28) v1(238.18,67.77) v1(238.18,66.09) v1(238.18,65.59) v1(238.18,63.93) v1(238.18,63.43) v1(238.26,30.15) v1(238.26,29.57) v1(238.69,104.19) v1(238.69,70.49) v1(238.69,69.98) v1(238.69,68.28) v1(238.69,67.77) v1(238.69,66.09) v1(238.69,65.59) v1(238.69,63.93) v1(238.69,63.43) v1(238.73,56.06) v1(239.15,103.05) v1(239.85,65.99) v1(239.85,65.15) v1(239.85,62.44) v1(239.96,104.19) v1(240.65,103.1) v1(240.8,86.57) v1(241.23,105.46) v1(241.23,104.19) v1(241.18,86.18) v1(241.23,39.25) v1(241.43,86.69) v1(241.69,86.18) v1(241.74,39.25) v1(242.04,103.13) v1(242.25,39.25) v1(242.5,105.46) v1(242.5,104.19) v1(242.65,81.79) v1(242.73,80.11) v1(242.76,63.24) v1(242.86,33.23) v1(243.24,103.13) v1(243.34,53.29) v1(243.37,33.97) v1(243.36,33.23) v1(243.71,83.7) v1(243.77,105.46) v1(243.77,104.19) v1(243.87,33.23) v1(244.47,82.2) v1(244.61,53.29) v1(245.88,54.56) v1(245.88,53.29) v1(246.35,79.28) v1(246.72,67.06) v1(246.87,105.57) v1(247.1,67.52) v1(247.15,53.29) v1(247.21,32.72) v1(247.21,28.65) v1(247.21,24.59) v1(247.54,91.11) v1(247.58,105.46) v1(247.61,104.02) v1(247.56,60.18) v1(247.56,59.67) v1(248.07,60.18) v1(248.07,59.67) v1(248.29,54.56) v1(248.29,53.42) v1(248.36,55.22) v1(248.85,105.46) v1(248.85,104.19) v1(249.18,54.56) v1(249.18,53.42) v1(249.35,32.26) v1(249.35,22.66) v1(249.88,65.23) v1(250.12,105.46) v1(250.12,104.19) v1(250.15,28.26) v1(250.2,54.05) v1(250.2,52.28) v1(250.58,63.13) v1(250.95,25.86) v1(251.21,20.46) v1(251.39,105.46) v1(251.39,104.19) v1(251.47,54.05) v1(251.47,52.28) v1(252.03,78.11) v1(252.23,20.46) v1(252.55,29.86) v1(252.66,104.19) v1(252.74,54.05) v1(252.74,52.28) v1(252.74,43.26) v1(252.74,42.5) v1(252.74,41.73) v1(253.25,42.88) v1(253.25,42.12) v1(253.35,23.46) v1(253.83,44.61) v1(253.75,43.26) v1(253.75,42.5) v1(253.75,41.73) v1(254.01,54.05) v1(254.01,52.28) v1(254.15,27.46) v1(254.9,56.4) v1(254.95,30.66) v1(255.75,24.26) v1(256.55,29.06) v1(257.18,59.9) v1(257.35,30.66) v1(258.15,26.66) v1(258.58,55.45) v1(258.95,22.66) v1(260.27,44.08) v1(260.27,40.02) v1(260.67,29.29) v1(260.67,26.24) v1(260.67,24.21) v1(260.67,22.18) v1(261.61,107.55) v1(261.55,80.19) v1(262.14,80.19) v1(262.14,79.45) v1(262.29,34.24) v1(262.72,103.08) v1(262.77,74.31) v1(263.23,102.47) v1(263.66,103.13) v1(264.29,39.7) v1(264.72,44.08) v1(265.12,55.07) v1(265.12,51.01) v1(265.31,45.71) v1(265.63,36.15) v1(266.01,59.13) v1(266.07,60.09) v1(266.24,89.08) v1(266.24,88.22) v1(266.24,87.35) v1(267.02,49.06) v1(267.85,62.65) v1(269.5,64.02) v1(271.08,65.48) v1(271.08,61.42) v1(271.08,57.36) v1(271.08,53.29) v1(271.08,49.23) v2(16.64,41.56) v2(16.64,40.62) v2(17.28,41.56) v2(17.28,40.62) v2(17.91,41.56) v2(17.91,40.62) v2(19.06,41.61) v2(19.06,40.72) v2(19.31,56.34) v2(19.31,55.32) v2(20.2,56.34) v2(20.2,55.32) v2(20.28,42.23) v2(20.28,40.7) v2(21.03,56.34) v2(21.03,55.32) v2(21.85,42.24) v2(21.85,40.72) v2(24.01,56.09) v2(24.01,55.07) v2(24.9,56.09) v2(24.9,55.07) v2(24.9,41.56) v2(24.9,40.62) v2(25.53,41.56) v2(25.53,40.62) v2(25.72,56.09) v2(25.72,55.07) v2(26.17,41.56) v2(26.17,40.62) v2(27.31,41.61) v2(27.31,40.72) v2(28.54,42.23) v2(28.54,40.7) v2(30.11,42.24) v2(30.11,40.72) v2(53.09,92.92) v2(53.09,91.77) v2(54.62,91.77) v2(159,89.39) v2(159,87.43) v2(160.78,89.39) v2(160.78,87.43) v2(162.56,89.39) v2(162.56,87.43) v2(164.34,89.39) v2(164.34,87.43) v2(164.92,34.43) v2(169.12,89.41) v2(171.54,89.41) v2(176.12,89.43) v2(176.18,44.4) v2(176.27,78.43) v2(176.27,76.43) v2(176.27,74.43) v2(176.26,46.56) v2(176.36,48.54) v2(176.46,63.83) v2(176.46,60.58) v2(176.97,50.14) v2(177.1,63.07) v2(177.22,61.29) v2(177.2,45.77) v2(177.32,75.49) v2(177.27,48.49) v2(177.93,77.46) v2(178.04,45.04) v2(178.12,89.43) v2(178.29,76.1) v2(178.85,63.12) v2(178.92,77.47) v2(178.87,61.22) v2(181.52,48.85) v2(181.46,47.53) v2(182.94,47.22) v2(182.99,48.54) v2(184.08,89.44) v2(184.08,64.29) v2(184.08,63.66) v2(184.06,62.11) v2(184.06,61.47) v2(184.16,48.44) v2(184.16,47.81) v2(184.21,45.95) v2(184.21,45.32) v2(190.41,46.64) v2(193.07,34.37) v2(193.33,33.48) v2(193.81,83.47) v2(193.83,82.65) v2(194.83,78.29) v2(194.85,80.6) v2(194.85,79.73) v2(194.85,77.45) v2(195.18,36.05) v2(195.18,35.41) v2(195.59,42.22) v2(195.59,41.58) v2(195.82,36.05) v2(195.82,35.41) v2(196.22,42.22) v2(196.22,41.58) v2(196.45,36.05) v2(196.45,35.41) v2(196.81,88.6) v2(196.86,42.22) v2(196.86,41.58) v2(196.98,84.86) v2(196.98,84.23) v2(197.29,34.75) v2(197.62,84.86) v2(197.62,84.23) v2(197.82,89.49) v2(197.92,34.75) v2(198.23,77.37) v2(198.25,84.86) v2(198.25,84.23) v2(198.25,76.61) v2(198.81,68.94) v2(198.84,68.07) v2(202.57,96.34) v2(203.84,96.34) v2(204.99,96.34) v2(205.09,34.7) v2(205.75,34.29) v2(206.13,77.24) v2(206.26,96.34) v2(206.84,76.91) v2(207.04,34.37) v2(207.45,77.42) v2(207.47,76.38) v2(207.78,34.52) v2(208.16,76.94) v2(211.79,98.81) v2(212.61,102.06) v2(212.81,98.81) v2(212.86,42.88) v2(212.86,42.24) v2(213.37,100.03) v2(213.49,42.88) v2(213.49,42.24) v2(214.13,42.88) v2(214.13,42.24) v2(214.21,98.81) v2(214.18,76.53) v2(214.26,77.37) v2(214.38,100.03) v2(214.51,86.82) v2(214.51,86.18) v2(214.51,85.55) v2(214.51,84.91) v2(214.76,101.3) v2(214.76,42.62) v2(214.76,41.99) v2(214.76,41.35) v2(214.76,40.72) v2(214.76,40.08) v2(214.76,39.45) v2(214.76,38.81) v2(214.76,38.18) v2(214.95,102.48) v2(214.99,98.86) v2(215.15,86.82) v2(215.15,86.18) v2(215.15,85.55) v2(215.15,84.91) v2(215.4,42.62) v2(215.4,41.99) v2(215.4,41.35) v2(215.4,40.72) v2(215.4,40.08) v2(215.4,39.45) v2(215.4,38.81) v2(215.72,98.86) v2(215.78,100.03) v2(215.78,86.82) v2(215.78,86.18) v2(215.78,85.55) v2(215.78,84.91) v2(216.03,105.11) v2(216.03,101.3) v2(216.03,42.62) v2(216.03,41.99) v2(216.03,41.35) v2(216.03,40.72) v2(216.03,40.08) v2(216.03,39.45) v2(216.03,38.81) v2(216.1,103.93) v2(216.42,84.03) v2(216.42,83.39) v2(216.42,82.76) v2(216.42,82.12) v2(216.42,81.49) v2(216.42,80.85) v2(216.36,34.01) v2(216.61,98.86) v2(216.67,42.62) v2(216.67,41.99) v2(216.67,41.35) v2(216.67,40.72) v2(216.67,40.08) v2(216.67,39.45) v2(216.67,38.81) v2(216.72,34.72) v2(216.8,100.03) v2(216.77,33.3) v2(216.92,86.49) v2(216.92,85.85) v2(216.92,85.22) v2(216.92,84.58) v2(217.05,83.39) v2(217.05,82.76) v2(217.05,82.12) v2(217.05,81.49) v2(217.05,80.85) v2(217.05,80.22) v2(217.15,34.01) v2(217.3,105.11) v2(217.3,103.46) v2(217.3,101.93) v2(217.3,42.62) v2(217.3,41.99) v2(217.3,41.35) v2(217.3,40.72) v2(217.3,40.08) v2(217.35,39.4) v2(217.56,86.49) v2(217.56,85.85) v2(217.56,85.22) v2(217.56,84.58) v2(217.69,83.39) v2(217.69,82.76) v2(217.69,82.12) v2(217.69,81.49) v2(217.69,80.85) v2(217.94,41.99) v2(217.94,41.35) v2(217.94,40.72) v2(218.19,86.49) v2(218.19,85.85) v2(218.19,85.22) v2(218.19,84.58) v2(218.32,83.39) v2(218.32,82.76) v2(218.32,82.12) v2(218.32,81.49) v2(218.32,80.85) v2(218.96,85.3) v2(218.96,84.66) v2(218.96,84.03) v2(218.96,83.39) v2(218.96,82.76) v2(218.96,82.12) v2(218.96,81.49) v2(218.96,80.85) v2(240.8,68.28) v2(242.32,68.28) v2(243.85,68.28) v2(245.37,68.28) v2(246.51,44.78) v2(246.51,43.39) v2(246.51,39.58) v2(246.51,38.18) v2(246.9,68.28) v2(248.04,44.78) v2(248.04,43.39) v2(248.04,39.58) v2(248.04,38.18) v2(248.42,68.28) v2(249.94,68.28) v2(251.47,68.28) v2(251.98,39.7) v2(252,38.31) v2(252.76,40.74) v2(252.99,68.28) v2(253.63,40.72) v2(253.63,39.45) v2(253.63,38.18) v2(254.52,68.28) v2(255.4,21.41) v2(256.04,71.33) v2(256.04,69.8) v2(256.04,68.28) v2(257.56,69.8) v2(257.56,68.28) v2(258.58,21.41) v2(259.09,69.8) v2(259.09,68.28) v2(260.61,71.33) v2(260.61,69.8) v2(260.61,68.28) v5(164.92,36.43) v5(170.36,89.41) v5(171.02,34.43) v5(174.12,89.43) v7(91.53,45.93) v7(104.52,64.43) v7(110.58,73.93) v7(111.45,66.43) v7(111.45,65.43) v7(111.45,64.43) v7(111.45,63.43) v7(111.45,61.43) v7(111.45,60.43) v7(111.45,59.43) v7(111.45,58.43) v7(111.45,57.43) v7(113.18,57.43) v7(114.91,66.43) v7(114.91,57.43) v7(116.65,66.43) v7(116.65,57.43) v7(118.38,66.43) v7(118.38,57.43) v7(120.11,66.43) v7(120.11,57.43) v7(121.84,66.43) v7(121.84,65.43) v7(121.84,64.43) v7(121.84,63.43) v7(121.84,62.43) v7(121.84,61.43) v7(121.84,60.43) v7(121.84,59.43) v7(121.84,58.43) v7(121.84,57.43) v7(121.84,56.43) v7(128.77,51.43) v7(130.5,53.43) v7(133.97,80.43)
