# Allegro board TS28247BC0_FM61_agilex_PCIe_DEVKIT_ADI_REVB1.brd (continued)
## Nets (continued)
0P6V_VTT_DDR4_CH01: C16.2 C17.1 C19.1 C29.1 C31.1 C52.2 C53.1 C55.1 C57.1 C60.1 C653.1 C654.1 C655.1 C659.1 J1.77 J1.221 J2.77 J2.221 U59.3 U59.5(VOSNS)
0P6V_VTT_DDR4_CH01_PG: R647.2 U30.B13 U59.9
0P6V_VTT_DDR4_CH23: C88.2 C89.1 C91.1 C101.1 C103.1 C121.2 C122.1 C124.1 C134.1 C136.1 C662.1 C663.1 C664.1 C665.1 C666.1 C667.1 C670.1 C671.1 J3.77 J3.221 J4.77 J4.221 U60.3 U60.5(VOSNS)
0P8V_AGND: C1901.1 C1902.1 C1904.1 R5988.1 R5993.1 ST3.1 U51.B4
0P8V_VCCL_SDM: C737.1 C836.1 C837.1 C838.1 C839.1 C840.2 C841.2 C842.2 C1213.1 C1905.1 C1906.1 C2032.2 FB9.2 R369.2 U2.BT39 U2.BT41 U2.BV39 U2.BV41 U51.C1 U51.D1 U51.D2 U51.E1 U51.E2(VOUT5)
0P9V_VCCH: C1256.1 C1257.1 C1258.1 C1259.1 C1260.1 C1261.1 C1262.1 C1263.1 C1264.1 C1265.1 C1266.1 C1267.1 C1268.1 C1269.1 C1270.1 C1271.1 C1272.1 C1273.1 C1274.1 C1275.1 C1276.1 C1277.1 C1278.1 C1279.1 C1280.1 C1281.1 C1282.1 C1283.1 C1284.1 C1285.1 C1286.2 C1287.2 C1288.2 C1289.2 C1290.2 C1291.2 C1292.2 C1293.2 C1294.2 C1295.2 C1296.2 C1297.2 C1298.1 C1299.1 C1302.1 C1303.1 C1317.1 C1318.1 C1426.2 C1443.1 C1445.2 C1915.2 C1916.2 C1917.2 C1926.2 C1928.1 C1929.1 C1930.2 C1931.2 C1932.2 FB13.2 FB16.2 FB37.2 L14.1 R381.2 R6101.2 U2.AR44 U2.AU20 U2.AU44 U2.AV43 U2.AW20 U2.AW44 U2.AY19 U2.AY43 U2.BA44 U2.BB19 U2.BC20 U2.BC44 U2.BD19 U2.BD43 U2.BE20 U2.BE44 U2.BF43 U2.BH19 U2.BH43 U2.BJ20 U2.BK19 U2.BL20 U2.BP19 U2.BR20 U2.BT19 U2.BT43 U55.A7 U55.A8 U55.A9 U55.A10 U55.B7 U55.B8 U55.B9 U55.B10 U55.B11 U55.B12 U55.C7 U55.C8 U55.C9 U55.D7 U55.K7 U55.K8 U55.K9 U55.K10 U55.K11 U55.L7 U55.L8 U55.L9 U55.L10 U55.L11 U55.L12 U55.M7 U55.M8 U55.M9 U55.M10
0P9V_VCCL_HPS: C828.1 C829.1 C830.1 C831.1 C832.1 C833.1 C834.1 C835.1 C1909.1 C1910.2 C1911.2 C1912.1 C1913.2 FB10.2 R372.2 U2.AF23 U2.AF25 U2.AH23 U2.AH25 U2.AK23 U65.C10 U65.C11 U65.D10 U65.D11 U65.E9 U65.E10 U65.E11 U65.F9 U65.F10(VOUT9) U65.F11 U65.G9 U65.G10 U65.G11
0P9V_VCCRT_GXER1: C843.1 C844.1 C845.1 C846.1 C847.1 C848.1 C849.1 C850.1 C851.1 C852.1 C853.1 C854.1 C855.1 C856.1 C857.1 C858.2 C859.2 C860.1 C861.1 C1196.1 C1197.1 C1199.1 C1200.1 C1427.1 C1440.2 C1441.2 L14.2 U2.AV15 U2.AW14 U2.AY15 U2.BA14 U2.BB15 U2.BC14 U2.BE14 U2.BG14 U2.BJ14 U2.BK15 U2.BL14 U2.BM15 U2.BN14 U2.BP15
0P9V_VCCRT_GXPL1: C1304.1 C1305.1 C1306.1 C1307.1 C1308.1 C1309.1 C1310.1 C1311.1 C1312.1 C1313.1 C1314.1 C1315.1 C1410.2 C1446.1 C1447.1 FB37.1 U2.AM49 U2.AN48 U2.AP49 U2.AR48 U2.AT49 U2.AV49 U2.AY49 U2.BB49 U2.BC48 U2.BD49
1P1V_VCCH_GXER1: C1242.1 C1243.1 C1244.2 C1245.2 C1246.2 C1247.2 C1248.2 C1249.2 C1250.2 C1251.1 C1252.1 C1253.1 C1254.1 C1255.1 C1992.1 C1993.1 C2036.1 R376.2 U2.AY17 U2.BB17 U2.BK17 U2.BM17 U2.BP17 U66.A1 U66.A7 U66.B1 U66.B7 U66.F1 U66.F7 U66.G1(VOUT4_2) U66.G7
1P2V_DDR4_CH01: C3.1 C4.1 C5.1 C6.1 C7.1 C8.1 C9.1 C10.1 C11.1 C12.1 C13.1 C14.1 C15.1 C20.2 C21.2 C22.1 C23.1 C25.1 C26.1 C27.1 C28.1 C39.1 C40.1 C41.1 C42.1 C43.1 C44.1 C45.1 C46.1 C47.1 C48.1 C49.1 C50.1 C51.1 C58.1 C65.2 C66.2 C67.1 C68.1 C69.1 C70.1 C71.1 C333.1 C656.1 C657.1 C702.1 C704.1 C1323.1 C1324.1 C1325.1 C1326.1 C1327.1 C1328.1 C1329.1 C1330.1 C1331.1 C1332.1 C1333.1 C1334.1 C1335.1 C1336.1 C1337.1 C1338.1 C1339.1 C1340.1 C1341.2 C1342.2 C1343.2 C1344.2 C1345.1 C1346.1 C1347.1 C1348.1 C1349.1 C1350.1 C1351.1 C1352.1 C1353.1 C1354.1 C1355.1 C1356.1 C1357.1 C1358.1 C1359.1 C1360.1 C1361.2 C1362.2 C1363.2 C1364.2 C1365.1 C1366.1 C1951.1 C1952.2 C1953.2 C1954.2 J1.59 J1.61 J1.64 J1.67 J1.70 J1.73 J1.76 J1.80 J1.83 J1.85 J1.88 J1.90 J1.92 J1.204 J1.206 J1.209 J1.212 J1.215 J1.217 J1.220 J1.223 J1.226 J1.229 J1.231 J1.233 J1.236 J2.59 J2.61 J2.64 J2.67 J2.70 J2.73 J2.76 J2.80 J2.83 J2.85 J2.88 J2.90 J2.92 J2.204 J2.206 J2.209 J2.212 J2.215 J2.217 J2.220 J2.223 J2.226 J2.229 J2.231 J2.233 J2.236 R10.2 R26.2 R36.2 R37.2 R38.2 R39.2 R40.2 R41.2 R42.2 R44.2 R46.2 R47.2 R49.1 R50.1 R301.1 R302.2 R303.2 R384.2 R651.2 R672.1 R673.1 R789.2 R790.2 U1.1(VL) U1.8 U2.AB25 U2.AB27 U2.AB29 U2.AB31 U2.AB33 U2.AB35 U2.AB37 U2.AB39 U2.AD25 U2.AD27 U2.AD29 U2.AD31 U2.AD33 U2.AD35 U2.AD37 U2.AD39 U2.BV43 U3.1(VL) U3.8 U23.1(VL) U57.A1 U57.A2 U57.A3 U57.C1 U57.D1 U57.D2 U57.F1 U57.G1 U57.G2 U57.J1 U57.K1 U57.K2(VOUT4_3) U59.2 U67.1(VL) U67.8 U68.1(VL) U68.8
1P2V_DDR4_CH01_AGND: ST13.1 U57.F7
1P2V_DDR4_CH01_EN: R373.2 R6033.2
1P2V_DDR4_CH01_PG: R6037.1 U30.B5 U57.C3
1P2V_DDR4_CH23: C75.1 C76.1 C77.1 C78.1 C79.1 C80.1 C81.1 C82.1 C83.1 C84.1 C85.1 C86.1 C87.1 C92.2 C93.2 C94.1 C95.1 C96.1 C97.1 C98.1 C99.1 C109.1 C110.1 C111.1 C112.1 C113.1 C114.1 C115.1 C116.1 C117.1 C118.1 C119.1 C120.1 C125.2 C126.2 C127.1 C128.1 C129.1 C130.1 C131.1 C132.1 C176.1 C668.1 C669.1 C1367.1 C1368.1 C1369.1 C1370.1 C1371.1 C1372.1 C1373.1 C1374.1 C1375.1 C1376.1 C1377.1 C1378.1 C1379.1 C1380.1 C1381.1 C1382.1 C1383.1 C1384.2 C1385.2 C1386.2 C1387.2 C1388.1 C1389.1 C1390.1 C1391.1 C1392.1 C1393.1 C1394.1 C1395.1 C1396.1 C1397.1 C1398.1 C1399.1 C1400.1 C1401.1 C1402.1 C1403.1 C1404.1 C1405.2 C1406.2 C1407.2 C1408.2 C1961.1 C1962.2 C1963.2 C1964.2 J3.59 J3.61 J3.64 J3.67 J3.70 J3.73 J3.76 J3.80 J3.83 J3.85 J3.88 J3.90 J3.92 J3.204 J3.206 J3.209 J3.212 J3.215 J3.217 J3.220 J3.223 J3.226 J3.229 J3.231 J3.233 J3.236 J4.59 J4.61 J4.64 J4.67 J4.70 J4.73 J4.76 J4.80 J4.83 J4.85 J4.88 J4.90 J4.92 J4.204 J4.206 J4.209 J4.212 J4.215 J4.217 J4.220 J4.223 J4.226 J4.229 J4.231 J4.233 J4.236 R61.2 R75.2 R81.2 R82.2 R83.2 R386.2 R657.2 R674.1 R675.1 R676.1 R677.1 R791.2 R792.2 R833.1 U2.BY25 U2.BY27 U2.BY29 U2.BY31 U2.BY33 U2.BY35 U2.BY37 U2.BY39 U2.CB25 U2.CB27 U2.CB29 U2.CB31 U2.CB33 U2.CB35 U2.CB37 U2.CB39 U4.1(VL) U4.8 U5.1(VL) U5.8 U58.A1 U58.A2 U58.A3 U58.C1 U58.D1 U58.D2 U58.F1 U58.G1 U58.G2 U58.J1 U58.K1 U58.K2(VOUT4_3) U60.2
1P2V_DDR4_CH23_AGND: C1966.1 R6041.1 ST14.1 U58.F7
1P2V_DDR4_CH23_EN: R374.2 R6040.2
1P2V_DDR4_CH23_PG: R6045.1 U30.A3 U58.C3
1P2V_PRE: C683.2 C684.1 C685.1 C686.1 FB26.2 R318.2 R680.2 U64.1 U64.2(VOUT2)
1P2V_PRE_PG: R787.2 U64.4
1P2V_UBII: C367.1 C708.1 FB26.1 U26.H11 U26.J11
1P2V_VCCR: C1428.1 C1429.1 C1430.2 C1431.2 C1432.2 C1433.2 C1434.1 C1435.1 C1436.1 C1437.1 C1438.1 C1439.1 C1943.1 C1944.2 C1945.2 C1946.1 C1947.2 U2.AF37 U2.AH37 U2.AJ24 U2.AJ26 U2.AJ28 U2.BR24 U2.BR26 U2.BR28 U2.BT37 U2.BV37 U56.C10 U56.C11 U56.D10 U56.D11 U56.E9 U56.E10 U56.E11 U56.F9 U56.F10(VOUT9) U56.F11 U56.G9 U56.G10 U56.G11
1P8V: C1203.1 C1204.1 C1205.1 C1206.1 C1207.1 C1208.2 C1209.2 C1210.2 C1211.1 C1212.2 C1214.1 C1215.1 C1239.1 C1240.1 C1241.2 C1886.1 C1887.2 C1888.2 C1889.2 C1896.2 C1897.2 C1898.2 C1899.1 FB11.1 FB12.2 FB14.1 FB15.1 FB38.2 FB45.1 R89.1 R383.2 R5963.1 U2.AJ30 U2.AJ32 U2.AJ34 U2.AJ36 U2.BR30 U2.BR32 U2.BR34 U2.BR36 U2.CA48 U2.CC48 U71.A1 U71.B1 U71.C1 U71.D1 U71.J1 U71.K1 U71.L1 U71.M1
1P8V_AGND: C2003.1 R5975.1 R5980.2 R5981.1 R5982.1 R5983.1 R6098.1 ST19.1 U71.F5 U71.F6 U71.G5 U71.G6
1P8V_EN: R368.2 R5977.2
1P8V_PRE: C459.2 C463.1 C464.1 C465.1 FB27.2 R445.2 U45.1 U45.2(VOUT2)
1P8V_PRE_PG: R786.2 U45.4
1P8V_SI52202: C320.1 C321.1 C322.1 C323.1 C707.1 FB23.1 U18.4 U18.10 U18.15 U18.19
1P8V_UBII: C365.1 C366.1 FB27.1 U26.F11 U26.G11
2P5V: C1.1 C2.1 C32.2 C33.1 C34.1 C35.1 C61.2 C62.1 C63.1 C64.1 C73.1 C74.1 C104.2 C105.1 C106.1 C107.1 C137.2 C138.1 C139.1 C140.1 C277.1 C1980.1 C1981.1 C2033.2 FB20.2 J1.142 J1.143 J1.284 J1.286 J1.287 J2.142 J2.143 J2.284 J2.286 J2.287 J3.142 J3.143 J3.284 J3.286 J3.287 J4.142 J4.143 J4.284 J4.286 J4.287 R3.2 R4.2 R5.2 R6.2 R14.1 R19.1 R21.2 R22.2 R23.2 R30.1 R56.2 R57.2 R59.2 R65.1 R70.2 R71.2 R72.2 R73.2 R79.1 R5757.2 R5758.2 U1.14 U2.AR18 U4.14 U61.C1 U61.D1 U61.D2 U61.E1 U61.E2(VOUT5)
2P5V_AGND: C1976.1 C1978.1 C1979.1 R6059.1 R6063.1 ST15.1 U61.B4
2P5V_EN: R378.2 R6061.2
2P5V_PG: R6055.1 U30.E10 U61.C2
3P3V: C393.2 C394.2 C652.2 C661.2 C1907.2 C1908.2 C1941.2 C1942.2 C7777.2 FB33.1 R547.2 R647.1 R648.1 R653.1 R654.1 R667.1 R669.2 R788.2 R815.1 R817.1 R819.1 R821.1 R873.2 R5929.2 R5931.2 R5933.2 R5937.2 R5938.2 R5943.1 R5968.2 R5969.2 R5970.2 R5971.2 R5972.2 R5973.1 R5984.2 R5989.2 R5994.2 R5995.1 R6000.2 R6004.1 R6011.2 R6012.2 R6018.1 R6019.1 R6020.1 R6021.1 R6024.2 R6030.2 R6032.2 R6037.2 R6038.2 R6039.2 R6044.2 R6045.2 R6055.2 R6060.2 R6071.2 R6075.2 R6079.2 R6083.2 R6097.1 R6274.1 R6275.1 R6276.2 R6283.1 R6284.1 R6292.1 U56.C1 U56.C8 U56.C9 U56.D1 U56.D3 U56.D4 U56.D5 U56.D7 U56.D8 U56.D9 U56.E8 U59.10 U60.10 U62.5 U63.3 U65.C1 U65.C8 U65.C9 U65.D1 U65.D3 U65.D4 U65.D5 U65.D7 U65.D8 U65.D9 U65.E8 U73.8 U126.4(VSS)
3P3V_AGND: C7761.2 C7762.1 C7763.1 R6263.2 ST32.1
3P3V_EN: R361.2 R6265.1 R6267.2 U46.2
3P3V_LDO3: C682.1 FB36.1 R681.1 U64.9 U64.10
3P3V_PG: R6261.1 U30.A6 U46.26
3P3V_STBY: C344.1 C356.2 C357.1 C358.1 C359.1 C360.1 C361.1 C362.1 C363.1 C364.1 C368.2 C369.1 C370.1 C371.1 C372.1 C373.1 C374.1 C375.1 C396.1 C399.2 C400.2 C401.2 C402.2 C403.2 C404.2 C405.2 C411.2 C412.2 C413.2 C414.2 C415.2 C416.2 C458.2 C460.1 C461.1 C462.1 FB24.1 FB25.2 FB28.2 FB29.1 FB36.2 J14.4 L9.1 R276.1 R277.1 R312.2 R319.2 R320.2 R334.2 R336.1 R337.1 R338.1 R341.1 R342.1 R343.1 R345.1 R348.2 R349.2 R350.2 R351.2 R352.1 R353.1 R360.2 R390.1 R396.1 R397.1 R398.1 R399.2 R400.2 R407.1 R419.2 R423.2 R424.2 R444.2 R729.1 R784.2 R787.1 R794.1 U26.C6 U26.C7 U26.C8 U26.F2 U26.F7 U26.G3 U26.G6 U26.G8 U26.H7 U26.J3 U26.K3 U26.L6 U26.L7 U26.L8 U29.14(V+) U30.C6 U30.C7 U30.C8 U30.F7 U30.F11 U30.G3 U30.G6 U30.G8 U30.G11 U30.H7 U30.H11 U30.J3 U30.J11 U30.K3 U30.L6 U30.L7 U30.L8 U32.15 U32.17(VCC) U44.1 U44.2(VOUT2)
3P3V_STBY_PG: R785.2 U44.4
3P3V_USBPHY: C340.2 C346.1 C347.1 C348.1 C349.1 C350.1 C351.1 C352.1 C353.1 C354.1 FB25.1 R330.2 R331.2 R339.1 U25.4(VCC) U28.3 U28.7 U28.11 U28.17 U28.27 U28.32 U28.43 U28.55
24M_XTALIN: C342.1 U28.5 Y4.1
24M_XTALOUT: C343.1 U28.4(XTALOUT) Y4.3
ACTIVITY_LED: J8.13(YK) L2.2
AS_CLK: R113.1 R115.2 U6.B2
AS_CLK_R: R113.2 U2.CT59
AS_CS0_MSEL0: R107.1 SW1.1 U2.CR60 U6.C2
AS_DATA0: U2.CN60 U6.D3
AS_DATA1: U2.CU60 U6.D2
AS_DATA2: U2.CK59 U6.C4(W#/DQ2)
AS_DATA3: U2.CM59 U6.D4
BUFFER_DIF0_N: R798.2 U72.11
BUFFER_DIF0_P: R797.2 U72.10
BUFFER_DIF1_N: R800.2 U72.14
BUFFER_DIF1_P: R799.2 U72.13
CH01_RUN: C1956.2 R6032.1 R6033.1 R6034.2 U57.C6 U57.F6 U57.J6 U57.K7
CH23_RUN: C1966.2 R6039.1 R6040.1 R6041.2 U58.C6 U58.F6 U58.J6 U58.K7
CLK125_NDO_LED_MODE: R154.2 R155.1 U7.41
CLK_DDR4_CH0_N: R16.1 R248.1 U2.N40
CLK_DDR4_CH0_P: R16.2 R246.1 U2.L40
CLK_DDR4_CH1_N: R53.1 R250.1 U2.N10
CLK_DDR4_CH1_P: R53.2 R249.1 U2.L10
CLK_DDR4_CH2_N: R67.1 R252.1 U2.CL38
CLK_DDR4_CH2_P: R67.2 R251.1 U2.CN38
CLK_DDR4_CH3_N: R85.1 R254.1 U2.DA8
CLK_DDR4_CH3_P: R85.2 R253.1 U2.DC8
CLK_PWR_M10: R270.2 R823.1 U30.H6
CLK_SYS_100M_N: R80.2 R256.1 U2.CR24
CLK_SYS_100M_P: R80.1 R255.1 U2.CU24
CLK_SYS_BAK_50M_N: R31.2 R258.1 U2.J26
CLK_SYS_BAK_50M_P: R31.1 R257.1 U2.G26
CLK_UBII_M10: R272.2 U26.H4
COMPA_1P8V: C2003.2 C2004.2 R6103.1 R6104.1
CORE_PMBUS_ALERTN: R516.1 U26.N11 U30.C12
CORE_PMBUS_SCL: R283.1 R284.2 R288.2 R515.1 U20.2
CORE_PMBUS_SDA: R281.1 R285.2 R289.2 R514.1 U20.3
CPU_RESETN: R318.1 R322.1 S2.2 U2.A24 U26.H13
CT0: C211.1 J8.12
CT1: C212.1 J8.6
CT2: C213.1 J8.1
CT3: C214.1 J8.7
DAOUT0: C2012.1 R5935.1 U47.11
DDR4_CH0_EVENT_N: R49.2 U1.2 U2.A20
DDR4_CH0_SAVE_N: R50.2 U1.3 U2.D21
DDR4_CH1_EVENT_N: R672.2 U2.B19 U3.2
DDR4_CH1_SAVE_N: R673.2 U2.C20 U3.3
DDR4_CH2_EVENT_N: R674.2 U2.CN46 U4.2
DDR4_CH2_SAVE_N: R675.2 U2.CL46 U4.3
DDR4_CH3_EVENT_N: R676.2 U2.CM45 U4.4
DDR4_CH3_SAVE_N: R677.2 U2.CK45 U4.5
DDR4_DIMM0_EVENT_N: J1.78 R4.1 U1.13
DDR4_DIMM0_SAVE_N: J1.230 R3.1 U1.12
DDR4_DIMM1_EVENT_N: J2.78 R22.1 U3.13
DDR4_DIMM1_SAVE_N: J2.230 R21.1 U3.12
DDR4_DIMM2_EVENT_N: J3.78 R56.1 U4.13
DDR4_DIMM2_SAVE_N: J3.230 R57.1 U4.12
DDR4_DIMM3_EVENT_N: J4.78 R70.1 U4.11
DDR4_DIMM3_SAVE_N: J4.230 R71.1 U4.10
DDR4_DIMM_CH0_A0: J1.79 U2.T33
DDR4_DIMM_CH0_A1: J1.72 U2.V33
DDR4_DIMM_CH0_A2: J1.216 U2.U34
DDR4_DIMM_CH0_A3: J1.71 U2.W34
DDR4_DIMM_CH0_A4: J1.214 U2.T35
DDR4_DIMM_CH0_A5: J1.213 U2.V35
DDR4_DIMM_CH0_A6: J1.69 U2.U36
DDR4_DIMM_CH0_A7: J1.211 U2.W36
DDR4_DIMM_CH0_A8: J1.68 U2.T37
DDR4_DIMM_CH0_A9: J1.66 U2.V37
DDR4_DIMM_CH0_A10: J1.225 U2.U38
DDR4_DIMM_CH0_A11: J1.210 U2.W38
DDR4_DIMM_CH0_A12: J1.65 U2.P41
DDR4_DIMM_CH0_A13: J1.232 U2.L42
DDR4_DIMM_CH0_A14: J1.228(WE_N/A14) U2.N42
DDR4_DIMM_CH0_A15: J1.86 U2.M43
DDR4_DIMM_CH0_A16: J1.82 U2.P43
DDR4_DIMM_CH0_A17: J1.234 U2.L44
DDR4_DIMM_CH0_ACT_N: J1.62 U2.N34
DDR4_DIMM_CH0_ALERT_N: J1.208 R789.1 U2.U44
DDR4_DIMM_CH0_BA0: J1.81 U2.N44
DDR4_DIMM_CH0_BA1: J1.224 U2.M45
DDR4_DIMM_CH0_BG0: J1.63 U2.P45
DDR4_DIMM_CH0_BG1: J1.207 U2.M33
DDR4_DIMM_CH0_C2: J1.235 U2.T41
DDR4_DIMM_CH0_CK_N0: J1.75 U2.P37
DDR4_DIMM_CH0_CK_N1: J1.219 U2.V45
DDR4_DIMM_CH0_CK_P0: J1.74 U2.M37
DDR4_DIMM_CH0_CK_P1: J1.218 U2.T45
DDR4_DIMM_CH0_CKE0: J1.60 R12.2 U2.L36
DDR4_DIMM_CH0_CKE1: J1.203 R13.2 U2.N36
DDR4_DIMM_CH0_CS_N0: J1.84 U2.L34
DDR4_DIMM_CH0_CS_N1: J1.89 U2.L38
DDR4_DIMM_CH0_CS_N2: J1.93 U2.U40
DDR4_DIMM_CH0_CS_N3: J1.237 U2.W40
DDR4_DIMM_CH0_DBI_N0: J1.7 U2.G36
DDR4_DIMM_CH0_DBI_N1: J1.18 U2.A36
DDR4_DIMM_CH0_DBI_N2: J1.29 U2.B43
DDR4_DIMM_CH0_DBI_N3: J1.40 U2.F43
DDR4_DIMM_CH0_DBI_N4: J1.99 U2.G50
DDR4_DIMM_CH0_DBI_N5: J1.110 U2.F57
DDR4_DIMM_CH0_DBI_N6: J1.121 U2.B57
DDR4_DIMM_CH0_DBI_N7: J1.132 U2.T57
DDR4_DIMM_CH0_DBI_N8: J1.51 U2.A50
DDR4_DIMM_CH0_DQ0: J1.5 U2.F33
DDR4_DIMM_CH0_DQ1: J1.150 U2.H33
DDR4_DIMM_CH0_DQ2: J1.12 U2.G34
DDR4_DIMM_CH0_DQ3: J1.157 U2.J34
DDR4_DIMM_CH0_DQ4: J1.3 U2.J38
DDR4_DIMM_CH0_DQ5: J1.148 U2.G38
DDR4_DIMM_CH0_DQ6: J1.10 U2.F37
DDR4_DIMM_CH0_DQ7: J1.155 U2.H37
DDR4_DIMM_CH0_DQ8: J1.16 U2.B33
DDR4_DIMM_CH0_DQ9: J1.161 U2.D33
DDR4_DIMM_CH0_DQ10: J1.23 U2.A34
DDR4_DIMM_CH0_DQ11: J1.168 U2.C34
DDR4_DIMM_CH0_DQ12: J1.14 U2.D37
DDR4_DIMM_CH0_DQ13: J1.159 U2.A38
DDR4_DIMM_CH0_DQ14: J1.21 U2.B37
DDR4_DIMM_CH0_DQ15: J1.166 U2.C38
DDR4_DIMM_CH0_DQ16: J1.27 U2.A40
DDR4_DIMM_CH0_DQ17: J1.172 U2.C40
DDR4_DIMM_CH0_DQ18: J1.34 U2.B41
DDR4_DIMM_CH0_DQ19: J1.179 U2.D41
DDR4_DIMM_CH0_DQ20: J1.25 U2.D45
DDR4_DIMM_CH0_DQ21: J1.170 U2.B45
DDR4_DIMM_CH0_DQ22: J1.32 U2.A44
DDR4_DIMM_CH0_DQ23: J1.177 U2.C44
DDR4_DIMM_CH0_DQ24: J1.38 U2.G40
DDR4_DIMM_CH0_DQ25: J1.183 U2.J40
DDR4_DIMM_CH0_DQ26: J1.45 U2.F41
DDR4_DIMM_CH0_DQ27: J1.190 U2.H41
DDR4_DIMM_CH0_DQ28: J1.36 U2.J44
DDR4_DIMM_CH0_DQ29: J1.181 U2.H45
DDR4_DIMM_CH0_DQ30: J1.43 U2.G44
DDR4_DIMM_CH0_DQ31: J1.188 U2.F45
DDR4_DIMM_CH0_DQ32: J1.97 U2.G48
DDR4_DIMM_CH0_DQ33: J1.242 U2.F47
DDR4_DIMM_CH0_DQ34: J1.104 U2.J48
DDR4_DIMM_CH0_DQ35: J1.249 U2.H47
DDR4_DIMM_CH0_DQ36: J1.95 U2.F51
DDR4_DIMM_CH0_DQ37: J1.240 U2.H51
DDR4_DIMM_CH0_DQ38: J1.102 U2.G52
DDR4_DIMM_CH0_DQ39: J1.247 U2.J52
DDR4_DIMM_CH0_DQ40: J1.108 U2.F55
DDR4_DIMM_CH0_DQ41: J1.253 U2.G54
DDR4_DIMM_CH0_DQ42: J1.115 U2.H55
DDR4_DIMM_CH0_DQ43: J1.260 U2.J54
DDR4_DIMM_CH0_DQ44: J1.106 U2.J58
DDR4_DIMM_CH0_DQ45: J1.251 U2.F59
DDR4_DIMM_CH0_DQ46: J1.113 U2.G58
DDR4_DIMM_CH0_DQ47: J1.258 U2.H59
DDR4_DIMM_CH0_DQ48: J1.119 U2.B55
DDR4_DIMM_CH0_DQ49: J1.264 U2.A54
DDR4_DIMM_CH0_DQ50: J1.126 U2.D55
DDR4_DIMM_CH0_DQ51: J1.271 U2.C54
DDR4_DIMM_CH0_DQ52: J1.117 U2.D59
DDR4_DIMM_CH0_DQ53: J1.262 U2.C58
DDR4_DIMM_CH0_DQ54: J1.124 U2.F61
DDR4_DIMM_CH0_DQ55: J1.269 U2.H61
DDR4_DIMM_CH0_DQ56: J1.130 U2.V55
DDR4_DIMM_CH0_DQ57: J1.275 U2.T55
DDR4_DIMM_CH0_DQ58: J1.137 U2.W54
DDR4_DIMM_CH0_DQ59: J1.282 U2.U54
DDR4_DIMM_CH0_DQ60: J1.128 U2.W58
DDR4_DIMM_CH0_DQ61: J1.273 U2.T59
DDR4_DIMM_CH0_DQ62: J1.135 U2.U58
DDR4_DIMM_CH0_DQ63: J1.280 U2.V59
DDR4_DIMM_CH0_DQ64: J1.49 U2.A48
DDR4_DIMM_CH0_DQ65: J1.194 U2.B47
DDR4_DIMM_CH0_DQ66: J1.56 U2.C48
DDR4_DIMM_CH0_DQ67: J1.201 U2.D47
DDR4_DIMM_CH0_DQ68: J1.47 U2.C52
DDR4_DIMM_CH0_DQ69: J1.192 U2.D51
DDR4_DIMM_CH0_DQ70: J1.54 U2.B51
DDR4_DIMM_CH0_DQ71: J1.199 U2.A52
DDR4_DIMM_CH0_DQS_N0: J1.152 U2.H35
DDR4_DIMM_CH0_DQS_N1: J1.163 U2.D35
DDR4_DIMM_CH0_DQS_N2: J1.174 U2.C42
DDR4_DIMM_CH0_DQS_N3: J1.185 U2.J42
DDR4_DIMM_CH0_DQS_N4: J1.244 U2.H49
DDR4_DIMM_CH0_DQS_N5: J1.255 U2.J56
DDR4_DIMM_CH0_DQS_N6: J1.266 U2.C56
DDR4_DIMM_CH0_DQS_N7: J1.277 U2.W56
DDR4_DIMM_CH0_DQS_N8: J1.196 U2.D49
DDR4_DIMM_CH0_DQS_P0: J1.153 U2.F35
DDR4_DIMM_CH0_DQS_P1: J1.164 U2.B35
DDR4_DIMM_CH0_DQS_P2: J1.175 U2.A42
DDR4_DIMM_CH0_DQS_P3: J1.186 U2.G42
DDR4_DIMM_CH0_DQS_P4: J1.245 U2.F49
DDR4_DIMM_CH0_DQS_P5: J1.256 U2.G56
DDR4_DIMM_CH0_DQS_P6: J1.267 U2.A56
DDR4_DIMM_CH0_DQS_P7: J1.278 U2.U56
DDR4_DIMM_CH0_DQS_P8: J1.197 U2.B49
DDR4_DIMM_CH0_ODT0: J1.87 U2.M35
DDR4_DIMM_CH0_ODT1: J1.91 U2.P35
DDR4_DIMM_CH0_PAR: J1.222 U2.N38
DDR4_DIMM_CH0_RESET_N: J1.58 R10.1 R11.2 U2.P33
DDR4_DIMM_CH0_RZQ: R15.2 U2.M41
DDR4_DIMM_CH0_SA0: J1.139 R7.2
DDR4_DIMM_CH0_SA1: J1.140 R8.2
DDR4_DIMM_CH0_SA2: J1.238 R9.2
DDR4_DIMM_CH0_TDQS_N9: J1.8 U2.J36
DDR4_DIMM_CH0_TDQS_N10: J1.19 U2.C36
DDR4_DIMM_CH0_TDQS_N11: J1.30 U2.D43
DDR4_DIMM_CH0_TDQS_N12: J1.41 U2.H43
DDR4_DIMM_CH0_TDQS_N13: J1.100 U2.J50
DDR4_DIMM_CH0_TDQS_N14: J1.111 U2.H57
DDR4_DIMM_CH0_TDQS_N15: J1.122 U2.D57
DDR4_DIMM_CH0_TDQS_N16: J1.133 U2.V57
DDR4_DIMM_CH0_TDQS_N17: J1.52 U2.C50
DDR4_DIMM_CH1_A0: J2.79 U2.T17
DDR4_DIMM_CH1_A1: J2.72 U2.V17
DDR4_DIMM_CH1_A2: J2.216 U2.U16
DDR4_DIMM_CH1_A3: J2.71 U2.W16
DDR4_DIMM_CH1_A4: J2.214 U2.T15
DDR4_DIMM_CH1_A5: J2.213 U2.V15
DDR4_DIMM_CH1_A6: J2.69 U2.U14
DDR4_DIMM_CH1_A7: J2.211 U2.W14
DDR4_DIMM_CH1_A8: J2.68 U2.T13
DDR4_DIMM_CH1_A9: J2.66 U2.V13
DDR4_DIMM_CH1_A10: J2.225 U2.U12
DDR4_DIMM_CH1_A11: J2.210 U2.W12
DDR4_DIMM_CH1_A12: J2.65 U2.P9
DDR4_DIMM_CH1_A13: J2.232 U2.L8
DDR4_DIMM_CH1_A14: J2.228(WE_N/A14) U2.N8
DDR4_DIMM_CH1_A15: J2.86 U2.M7
DDR4_DIMM_CH1_A16: J2.82 U2.P7
DDR4_DIMM_CH1_ACT_N: J2.62 U2.N16
DDR4_DIMM_CH1_ALERT_N: J2.208 R790.1 U2.L6
DDR4_DIMM_CH1_BA0: J2.81 U2.N6
DDR4_DIMM_CH1_BA1: J2.224 U2.M5
DDR4_DIMM_CH1_BG0: J2.63 U2.P5
DDR4_DIMM_CH1_BG1: J2.207 U2.M17
DDR4_DIMM_CH1_CK_N0: J2.75 R679.2 U2.P13
DDR4_DIMM_CH1_CK_N1: J2.219 R679.1
DDR4_DIMM_CH1_CK_P0: J2.74 R678.2 U2.M13
DDR4_DIMM_CH1_CK_P1: J2.218 R678.1
DDR4_DIMM_CH1_CKE0: J2.60 R28.2 U2.L14
DDR4_DIMM_CH1_CKE1: J2.203 R29.2 U2.N14
DDR4_DIMM_CH1_CS_N0: J2.84 U2.L16
DDR4_DIMM_CH1_CS_N1: J2.89 U2.L12
DDR4_DIMM_CH1_DBI_N0: J2.7 U2.B7
DDR4_DIMM_CH1_DBI_N1: J2.18 U2.F7
DDR4_DIMM_CH1_DBI_N2: J2.29 U2.G14
DDR4_DIMM_CH1_DBI_N3: J2.40 U2.A14
DDR4_DIMM_CH1_DBI_N4: J2.99 U2.T21
DDR4_DIMM_CH1_DBI_N5: J2.110 U2.M21
DDR4_DIMM_CH1_DBI_N6: J2.121 U2.L28
DDR4_DIMM_CH1_DBI_N7: J2.132 U2.U28
DDR4_DIMM_CH1_DBI_N8: J2.51 U2.T7
DDR4_DIMM_CH1_DQ0: J2.5 U2.A10
DDR4_DIMM_CH1_DQ1: J2.150 U2.C10
DDR4_DIMM_CH1_DQ2: J2.12 U2.B9
DDR4_DIMM_CH1_DQ3: J2.157 U2.D9
DDR4_DIMM_CH1_DQ4: J2.3 U2.A6
DDR4_DIMM_CH1_DQ5: J2.148 U2.B5
DDR4_DIMM_CH1_DQ6: J2.10 U2.C6
DDR4_DIMM_CH1_DQ7: J2.155 U2.D5
DDR4_DIMM_CH1_DQ8: J2.16 U2.G10
DDR4_DIMM_CH1_DQ9: J2.161 U2.J10
DDR4_DIMM_CH1_DQ10: J2.23 U2.F9
DDR4_DIMM_CH1_DQ11: J2.168 U2.H9
DDR4_DIMM_CH1_DQ12: J2.14 U2.G6
DDR4_DIMM_CH1_DQ13: J2.159 U2.J6
DDR4_DIMM_CH1_DQ14: J2.21 U2.F5
DDR4_DIMM_CH1_DQ15: J2.166 U2.H5
DDR4_DIMM_CH1_DQ16: J2.27 U2.F17
DDR4_DIMM_CH1_DQ17: J2.172 U2.H17
DDR4_DIMM_CH1_DQ18: J2.34 U2.G16
DDR4_DIMM_CH1_DQ19: J2.179 U2.J16
DDR4_DIMM_CH1_DQ20: J2.25 U2.F13
DDR4_DIMM_CH1_DQ21: J2.170 U2.J12
DDR4_DIMM_CH1_DQ22: J2.32 U2.H13
DDR4_DIMM_CH1_DQ23: J2.177 U2.G12
DDR4_DIMM_CH1_DQ24: J2.38 U2.B17
DDR4_DIMM_CH1_DQ25: J2.183 U2.D17
DDR4_DIMM_CH1_DQ26: J2.45 U2.A16
DDR4_DIMM_CH1_DQ27: J2.190 U2.C16
DDR4_DIMM_CH1_DQ28: J2.36 U2.B13
DDR4_DIMM_CH1_DQ29: J2.181 U2.D13
DDR4_DIMM_CH1_DQ30: J2.43 U2.A12
DDR4_DIMM_CH1_DQ31: J2.188 U2.C12
DDR4_DIMM_CH1_DQ32: J2.97 U2.U24
DDR4_DIMM_CH1_DQ33: J2.242 U2.W24
DDR4_DIMM_CH1_DQ34: J2.104 U2.T23
DDR4_DIMM_CH1_DQ35: J2.249 U2.V23
DDR4_DIMM_CH1_DQ36: J2.95 U2.U20
DDR4_DIMM_CH1_DQ37: J2.240 U2.W20
DDR4_DIMM_CH1_DQ38: J2.102 U2.T19
DDR4_DIMM_CH1_DQ39: J2.247 U2.V19
DDR4_DIMM_CH1_DQ40: J2.108 U2.L24
DDR4_DIMM_CH1_DQ41: J2.253 U2.N24
DDR4_DIMM_CH1_DQ42: J2.115 U2.M23
DDR4_DIMM_CH1_DQ43: J2.260 U2.P23
DDR4_DIMM_CH1_DQ44: J2.106 U2.L20
DDR4_DIMM_CH1_DQ45: J2.251 U2.P19
DDR4_DIMM_CH1_DQ46: J2.113 U2.N20
DDR4_DIMM_CH1_DQ47: J2.258 U2.M19
DDR4_DIMM_CH1_DQ48: J2.119 U2.M31
DDR4_DIMM_CH1_DQ49: J2.264 U2.P31
DDR4_DIMM_CH1_DQ50: J2.126 U2.L30
DDR4_DIMM_CH1_DQ51: J2.271 U2.N30
DDR4_DIMM_CH1_DQ52: J2.117 U2.M27
DDR4_DIMM_CH1_DQ53: J2.262 U2.P27
DDR4_DIMM_CH1_DQ54: J2.124 U2.L26
DDR4_DIMM_CH1_DQ55: J2.269 U2.N26
DDR4_DIMM_CH1_DQ56: J2.130 U2.T31
DDR4_DIMM_CH1_DQ57: J2.275 U2.V31
DDR4_DIMM_CH1_DQ58: J2.137 U2.U30
DDR4_DIMM_CH1_DQ59: J2.282 U2.W30
DDR4_DIMM_CH1_DQ60: J2.128 U2.T27
DDR4_DIMM_CH1_DQ61: J2.273 U2.W26
DDR4_DIMM_CH1_DQ62: J2.135 U2.V27
DDR4_DIMM_CH1_DQ63: J2.280 U2.U26
DDR4_DIMM_CH1_DQ64: J2.49 U2.U10
DDR4_DIMM_CH1_DQ65: J2.194 U2.W10
DDR4_DIMM_CH1_DQ66: J2.56 U2.T9
DDR4_DIMM_CH1_DQ67: J2.201 U2.V9
DDR4_DIMM_CH1_DQ68: J2.47 U2.U6
DDR4_DIMM_CH1_DQ69: J2.192 U2.W6
DDR4_DIMM_CH1_DQ70: J2.54 U2.T5
DDR4_DIMM_CH1_DQ71: J2.199 U2.V5
DDR4_DIMM_CH1_DQS_N0: J2.152 U2.C8
DDR4_DIMM_CH1_DQS_N1: J2.163 U2.J8
DDR4_DIMM_CH1_DQS_N2: J2.174 U2.H15
DDR4_DIMM_CH1_DQS_N3: J2.185 U2.D15
DDR4_DIMM_CH1_DQS_N4: J2.244 U2.W22
DDR4_DIMM_CH1_DQS_N5: J2.255 U2.N22
DDR4_DIMM_CH1_DQS_N6: J2.266 U2.P29
DDR4_DIMM_CH1_DQS_N7: J2.277 U2.V29
DDR4_DIMM_CH1_DQS_N8: J2.196 U2.W8
DDR4_DIMM_CH1_DQS_P0: J2.153 U2.A8
DDR4_DIMM_CH1_DQS_P1: J2.164 U2.G8
DDR4_DIMM_CH1_DQS_P2: J2.175 U2.F15
DDR4_DIMM_CH1_DQS_P3: J2.186 U2.B15
DDR4_DIMM_CH1_DQS_P4: J2.245 U2.U22
DDR4_DIMM_CH1_DQS_P5: J2.256 U2.L22
DDR4_DIMM_CH1_DQS_P6: J2.267 U2.M29
DDR4_DIMM_CH1_DQS_P7: J2.278 U2.T29
DDR4_DIMM_CH1_DQS_P8: J2.197 U2.U8
DDR4_DIMM_CH1_ODT0: J2.87 U2.M15
DDR4_DIMM_CH1_ODT1: J2.91 U2.P15
DDR4_DIMM_CH1_PAR: J2.222 U2.N12
DDR4_DIMM_CH1_RESET_N: J2.58 R26.1 R27.2 U2.P17
DDR4_DIMM_CH1_RZQ: R48.2 U2.M9
DDR4_DIMM_CH1_SA0: J2.139 R23.1
DDR4_DIMM_CH1_SA1: J2.140 R24.2
DDR4_DIMM_CH1_SA2: J2.238 R25.2
DDR4_DIMM_CH1_TDQS_N9: J2.8 U2.D7
DDR4_DIMM_CH1_TDQS_N10: J2.19 U2.H7
DDR4_DIMM_CH1_TDQS_N11: J2.30 U2.J14
DDR4_DIMM_CH1_TDQS_N12: J2.41 U2.C14
DDR4_DIMM_CH1_TDQS_N13: J2.100 U2.V21
DDR4_DIMM_CH1_TDQS_N14: J2.111 U2.P21
DDR4_DIMM_CH1_TDQS_N15: J2.122 U2.N28
DDR4_DIMM_CH1_TDQS_N16: J2.133 U2.W28
DDR4_DIMM_CH1_TDQS_N17: J2.52 U2.V7
DDR4_DIMM_CH2_A0: J3.79 U2.CH31
DDR4_DIMM_CH2_A1: J3.72 U2.CF31
DDR4_DIMM_CH2_A2: J3.216 U2.CG32
DDR4_DIMM_CH2_A3: J3.71 U2.CE32
DDR4_DIMM_CH2_A4: J3.214 U2.CH33
DDR4_DIMM_CH2_A5: J3.213 U2.CF33
DDR4_DIMM_CH2_A6: J3.69 U2.CG34
DDR4_DIMM_CH2_A7: J3.211 U2.CE34
DDR4_DIMM_CH2_A8: J3.68 U2.CH35
DDR4_DIMM_CH2_A9: J3.66 U2.CF35
DDR4_DIMM_CH2_A10: J3.225 U2.CG36
DDR4_DIMM_CH2_A11: J3.210 U2.CE36
DDR4_DIMM_CH2_A12: J3.65 U2.CK39
DDR4_DIMM_CH2_A13: J3.232 U2.CN40
DDR4_DIMM_CH2_A14: J3.228(WE_N/A14) U2.CL40
DDR4_DIMM_CH2_A15: J3.86 U2.CM41
DDR4_DIMM_CH2_A16: J3.82 U2.CK41
DDR4_DIMM_CH2_A17: J3.234 U2.CN42
DDR4_DIMM_CH2_ACT_N: J3.62 U2.CL32
DDR4_DIMM_CH2_ALERT_N: J3.208 R791.1 U2.CG42
DDR4_DIMM_CH2_BA0: J3.81 U2.CL42
DDR4_DIMM_CH2_BA1: J3.224 U2.CM43
DDR4_DIMM_CH2_BG0: J3.63 U2.CK43
DDR4_DIMM_CH2_BG1: J3.207 U2.CM31
DDR4_DIMM_CH2_C2: J3.235 U2.CH39
DDR4_DIMM_CH2_CK_N0: J3.75 U2.CK35
DDR4_DIMM_CH2_CK_N1: J3.219 U2.CF43
DDR4_DIMM_CH2_CK_P0: J3.74 U2.CM35
DDR4_DIMM_CH2_CK_P1: J3.218 U2.CH43
DDR4_DIMM_CH2_CKE0: J3.60 R63.2 U2.CN34
DDR4_DIMM_CH2_CKE1: J3.203 R64.2 U2.CL34
DDR4_DIMM_CH2_CS_N0: J3.84 U2.CN32
DDR4_DIMM_CH2_CS_N1: J3.89 U2.CN36
DDR4_DIMM_CH2_CS_N2: J3.93 U2.CG38
DDR4_DIMM_CH2_CS_N3: J3.237 U2.CE38
DDR4_DIMM_CH2_DBI_N0: J3.7 U2.CH55
DDR4_DIMM_CH2_DBI_N1: J3.18 U2.CV55
DDR4_DIMM_CH2_DBI_N2: J3.29 U2.DB55
DDR4_DIMM_CH2_DBI_N3: J3.40 U2.DC48
DDR4_DIMM_CH2_DBI_N4: J3.99 U2.CV41
DDR4_DIMM_CH2_DBI_N5: J3.110 U2.DB41
DDR4_DIMM_CH2_DBI_N6: J3.121 U2.DC34
DDR4_DIMM_CH2_DBI_N7: J3.132 U2.CU34
DDR4_DIMM_CH2_DBI_N8: J3.51 U2.CU48
DDR4_DIMM_CH2_DQ0: J3.5 U2.CE52
DDR4_DIMM_CH2_DQ1: J3.150 U2.CF53
DDR4_DIMM_CH2_DQ2: J3.12 U2.CG52
DDR4_DIMM_CH2_DQ3: J3.157 U2.CH53
DDR4_DIMM_CH2_DQ4: J3.3 U2.CE56
DDR4_DIMM_CH2_DQ5: J3.148 U2.CG56
DDR4_DIMM_CH2_DQ6: J3.10 U2.CF57
DDR4_DIMM_CH2_DQ7: J3.155 U2.CH57
DDR4_DIMM_CH2_DQ8: J3.16 U2.CR52
DDR4_DIMM_CH2_DQ9: J3.161 U2.CT53
DDR4_DIMM_CH2_DQ10: J3.23 U2.CU52
DDR4_DIMM_CH2_DQ11: J3.168 U2.CV53
DDR4_DIMM_CH2_DQ12: J3.14 U2.CR56
DDR4_DIMM_CH2_DQ13: J3.159 U2.CU56
DDR4_DIMM_CH2_DQ14: J3.21 U2.CT57
DDR4_DIMM_CH2_DQ15: J3.166 U2.CV57
DDR4_DIMM_CH2_DQ16: J3.27 U2.DA52
DDR4_DIMM_CH2_DQ17: J3.172 U2.CY53
DDR4_DIMM_CH2_DQ18: J3.34 U2.DB53
DDR4_DIMM_CH2_DQ19: J3.179 U2.DC52
DDR4_DIMM_CH2_DQ20: J3.25 U2.CY57
DDR4_DIMM_CH2_DQ21: J3.170 U2.DB57
DDR4_DIMM_CH2_DQ22: J3.32 U2.DA56
DDR4_DIMM_CH2_DQ23: J3.177 U2.DC56
DDR4_DIMM_CH2_DQ24: J3.38 U2.DA46
DDR4_DIMM_CH2_DQ25: J3.183 U2.DC46
DDR4_DIMM_CH2_DQ26: J3.45 U2.DB45
DDR4_DIMM_CH2_DQ27: J3.190 U2.CY45
DDR4_DIMM_CH2_DQ28: J3.36 U2.DC50
DDR4_DIMM_CH2_DQ29: J3.181 U2.DA50
DDR4_DIMM_CH2_DQ30: J3.43 U2.DB49
DDR4_DIMM_CH2_DQ31: J3.188 U2.CY49
DDR4_DIMM_CH2_DQ32: J3.97 U2.CT39
DDR4_DIMM_CH2_DQ33: J3.242 U2.CV39
DDR4_DIMM_CH2_DQ34: J3.104 U2.CU38
DDR4_DIMM_CH2_DQ35: J3.249 U2.CR38
DDR4_DIMM_CH2_DQ36: J3.95 U2.CU42
DDR4_DIMM_CH2_DQ37: J3.240 U2.CV43
DDR4_DIMM_CH2_DQ38: J3.102 U2.CR42
DDR4_DIMM_CH2_DQ39: J3.247 U2.CT43
DDR4_DIMM_CH2_DQ40: J3.108 U2.CY39
DDR4_DIMM_CH2_DQ41: J3.253 U2.DB39
DDR4_DIMM_CH2_DQ42: J3.115 U2.DC38
DDR4_DIMM_CH2_DQ43: J3.260 U2.DA38
DDR4_DIMM_CH2_DQ44: J3.106 U2.DC42
DDR4_DIMM_CH2_DQ45: J3.251 U2.DB43
DDR4_DIMM_CH2_DQ46: J3.113 U2.DA42
DDR4_DIMM_CH2_DQ47: J3.258 U2.CY43
DDR4_DIMM_CH2_DQ48: J3.119 U2.DA32
DDR4_DIMM_CH2_DQ49: J3.264 U2.DC32
DDR4_DIMM_CH2_DQ50: J3.126 U2.DB31
DDR4_DIMM_CH2_DQ51: J3.271 U2.CY31
DDR4_DIMM_CH2_DQ52: J3.117 U2.DA36
DDR4_DIMM_CH2_DQ53: J3.262 U2.DC36
DDR4_DIMM_CH2_DQ54: J3.124 U2.DB35
DDR4_DIMM_CH2_DQ55: J3.269 U2.CY35
DDR4_DIMM_CH2_DQ56: J3.130 U2.CR32
DDR4_DIMM_CH2_DQ57: J3.275 U2.CU32
DDR4_DIMM_CH2_DQ58: J3.137 U2.CV31
DDR4_DIMM_CH2_DQ59: J3.282 U2.CT31
DDR4_DIMM_CH2_DQ60: J3.128 U2.CV35
DDR4_DIMM_CH2_DQ61: J3.273 U2.CU36
DDR4_DIMM_CH2_DQ62: J3.135 U2.CT35
DDR4_DIMM_CH2_DQ63: J3.280 U2.CR36
DDR4_DIMM_CH2_DQ64: J3.49 U2.CU46
DDR4_DIMM_CH2_DQ65: J3.194 U2.CT45
DDR4_DIMM_CH2_DQ66: J3.56 U2.CR46
DDR4_DIMM_CH2_DQ67: J3.201 U2.CV45
DDR4_DIMM_CH2_DQ68: J3.47 U2.CT49
DDR4_DIMM_CH2_DQ69: J3.192 U2.CU50
DDR4_DIMM_CH2_DQ70: J3.54 U2.CV49
DDR4_DIMM_CH2_DQ71: J3.199 U2.CR50
DDR4_DIMM_CH2_DQS_N0: J3.152 U2.CE54
DDR4_DIMM_CH2_DQS_N1: J3.163 U2.CR54
DDR4_DIMM_CH2_DQS_N2: J3.174 U2.DA54
DDR4_DIMM_CH2_DQS_N3: J3.185 U2.CY47
DDR4_DIMM_CH2_DQS_N4: J3.244 U2.CR40
DDR4_DIMM_CH2_DQS_N5: J3.255 U2.DA40
DDR4_DIMM_CH2_DQS_N6: J3.266 U2.CY33
DDR4_DIMM_CH2_DQS_N7: J3.277 U2.CT33
DDR4_DIMM_CH2_DQS_N8: J3.196 U2.CT47
DDR4_DIMM_CH2_DQS_P0: J3.153 U2.CG54
DDR4_DIMM_CH2_DQS_P1: J3.164 U2.CU54
DDR4_DIMM_CH2_DQS_P2: J3.175 U2.DC54
DDR4_DIMM_CH2_DQS_P3: J3.186 U2.DB47
DDR4_DIMM_CH2_DQS_P4: J3.245 U2.CU40
DDR4_DIMM_CH2_DQS_P5: J3.256 U2.DC40
DDR4_DIMM_CH2_DQS_P6: J3.267 U2.DB33
DDR4_DIMM_CH2_DQS_P7: J3.278 U2.CV33
DDR4_DIMM_CH2_DQS_P8: J3.197 U2.CV47
DDR4_DIMM_CH2_ODT0: J3.87 U2.CM33
DDR4_DIMM_CH2_ODT1: J3.91 U2.CK33
DDR4_DIMM_CH2_PAR: J3.222 U2.CL36
DDR4_DIMM_CH2_RESET_N: J3.58 R61.1 R62.2 U2.CK31
DDR4_DIMM_CH2_RZQ: R66.2 U2.CM39
DDR4_DIMM_CH2_SA0: J3.139 R58.2
DDR4_DIMM_CH2_SA1: J3.140 R59.1
DDR4_DIMM_CH2_SA2: J3.238 R60.2
DDR4_DIMM_CH2_TDQS_N9: J3.8 U2.CF55
DDR4_DIMM_CH2_TDQS_N10: J3.19 U2.CT55
DDR4_DIMM_CH2_TDQS_N11: J3.30 U2.CY55
DDR4_DIMM_CH2_TDQS_N12: J3.41 U2.DA48
DDR4_DIMM_CH2_TDQS_N13: J3.100 U2.CT41
DDR4_DIMM_CH2_TDQS_N14: J3.111 U2.CY41
DDR4_DIMM_CH2_TDQS_N15: J3.122 U2.DA34
DDR4_DIMM_CH2_TDQS_N16: J3.133 U2.CR34
DDR4_DIMM_CH2_TDQS_N17: J3.52 U2.CR48
DDR4_DIMM_CH3_A0: J4.79 U2.CV15
DDR4_DIMM_CH3_A1: J4.72 U2.CT15
DDR4_DIMM_CH3_A2: J4.216 U2.CU14
DDR4_DIMM_CH3_A3: J4.71 U2.CR14
DDR4_DIMM_CH3_A4: J4.214 U2.CV13
DDR4_DIMM_CH3_A5: J4.213 U2.CT13
DDR4_DIMM_CH3_A6: J4.69 U2.CU12
DDR4_DIMM_CH3_A7: J4.211 U2.CR12
DDR4_DIMM_CH3_A8: J4.68 U2.CV11
DDR4_DIMM_CH3_A9: J4.66 U2.CT11
DDR4_DIMM_CH3_A10: J4.225 U2.CU10
DDR4_DIMM_CH3_A11: J4.210 U2.CR10
DDR4_DIMM_CH3_A12: J4.65 U2.CY7
DDR4_DIMM_CH3_A13: J4.232 U2.DC6
DDR4_DIMM_CH3_A14: J4.228(WE_N/A14) U2.DA6
DDR4_DIMM_CH3_A15: J4.86 U2.DB5
DDR4_DIMM_CH3_A16: J4.82 U2.CY5
DDR4_DIMM_CH3_A17: J4.234 U2.DA4
DDR4_DIMM_CH3_ACT_N: J4.62 U2.DA14
DDR4_DIMM_CH3_ALERT_N: J4.208 R792.1 U2.CU4
DDR4_DIMM_CH3_BA0: J4.81 U2.CY3
DDR4_DIMM_CH3_BA1: J4.224 U2.CV1
DDR4_DIMM_CH3_BG0: J4.63 U2.CT1
DDR4_DIMM_CH3_BG1: J4.207 U2.DB15
DDR4_DIMM_CH3_C2: J4.235 U2.CV7
DDR4_DIMM_CH3_CK_N0: J4.75 U2.CY11
DDR4_DIMM_CH3_CK_N1: J4.219 U2.CT3
DDR4_DIMM_CH3_CK_P0: J4.74 U2.DB11
DDR4_DIMM_CH3_CK_P1: J4.218 U2.CV3
DDR4_DIMM_CH3_CKE0: J4.60 R77.2 U2.DC12
DDR4_DIMM_CH3_CKE1: J4.203 R78.2 U2.DA12
DDR4_DIMM_CH3_CS_N0: J4.84 U2.DC14
DDR4_DIMM_CH3_CS_N1: J4.89 U2.DC10
DDR4_DIMM_CH3_CS_N2: J4.93 U2.CU8
DDR4_DIMM_CH3_CS_N3: J4.237 U2.CR8
DDR4_DIMM_CH3_DBI_N0: J4.7 U2.CN26
DDR4_DIMM_CH3_DBI_N1: J4.18 U2.CG26
DDR4_DIMM_CH3_DBI_N2: J4.29 U2.CH19
DDR4_DIMM_CH3_DBI_N3: J4.40 U2.DC26
DDR4_DIMM_CH3_DBI_N4: J4.99 U2.CN12
DDR4_DIMM_CH3_DBI_N5: J4.110 U2.CG12
DDR4_DIMM_CH3_DBI_N6: J4.121 U2.CM5
DDR4_DIMM_CH3_DBI_N7: J4.132 U2.CH5
DDR4_DIMM_CH3_DBI_N8: J4.51 U2.CM19
DDR4_DIMM_CH3_DQ0: J4.5 U2.CN28
DDR4_DIMM_CH3_DQ1: J4.150 U2.CL28
DDR4_DIMM_CH3_DQ2: J4.12 U2.CK29
DDR4_DIMM_CH3_DQ3: J4.157 U2.CM29
DDR4_DIMM_CH3_DQ4: J4.3 U2.CK25
DDR4_DIMM_CH3_DQ5: J4.148 U2.CM25
DDR4_DIMM_CH3_DQ6: J4.10 U2.CN24
DDR4_DIMM_CH3_DQ7: J4.155 U2.CL24
DDR4_DIMM_CH3_DQ8: J4.16 U2.CG28
DDR4_DIMM_CH3_DQ9: J4.161 U2.CH29
DDR4_DIMM_CH3_DQ10: J4.23 U2.CE28
DDR4_DIMM_CH3_DQ11: J4.168 U2.CF29
DDR4_DIMM_CH3_DQ12: J4.14 U2.CE24
DDR4_DIMM_CH3_DQ13: J4.159 U2.CH25
DDR4_DIMM_CH3_DQ14: J4.21 U2.CF25
DDR4_DIMM_CH3_DQ15: J4.166 U2.CG24
DDR4_DIMM_CH3_DQ16: J4.27 U2.CH21
DDR4_DIMM_CH3_DQ17: J4.172 U2.CF21
DDR4_DIMM_CH3_DQ18: J4.34 U2.CE22
DDR4_DIMM_CH3_DQ19: J4.179 U2.CG22
DDR4_DIMM_CH3_DQ20: J4.25 U2.CE18
DDR4_DIMM_CH3_DQ21: J4.170 U2.CG18
DDR4_DIMM_CH3_DQ22: J4.32 U2.CH17
DDR4_DIMM_CH3_DQ23: J4.177 U2.CF17
DDR4_DIMM_CH3_DQ24: J4.38 U2.DC28
DDR4_DIMM_CH3_DQ25: J4.183 U2.DA28
DDR4_DIMM_CH3_DQ26: J4.45 U2.CY29
DDR4_DIMM_CH3_DQ27: J4.190 U2.DB29
DDR4_DIMM_CH3_DQ28: J4.36 U2.CY25
DDR4_DIMM_CH3_DQ29: J4.181 U2.DB25
DDR4_DIMM_CH3_DQ30: J4.43 U2.DC24
DDR4_DIMM_CH3_DQ31: J4.188 U2.DA24
DDR4_DIMM_CH3_DQ32: J4.97 U2.CN14
DDR4_DIMM_CH3_DQ33: J4.242 U2.CL14
DDR4_DIMM_CH3_DQ34: J4.104 U2.CK15
DDR4_DIMM_CH3_DQ35: J4.249 U2.CM15
DDR4_DIMM_CH3_DQ36: J4.95 U2.CK11
DDR4_DIMM_CH3_DQ37: J4.240 U2.CM11
DDR4_DIMM_CH3_DQ38: J4.102 U2.CN10
DDR4_DIMM_CH3_DQ39: J4.247 U2.CL10
DDR4_DIMM_CH3_DQ40: J4.108 U2.CG14
DDR4_DIMM_CH3_DQ41: J4.253 U2.CH15
DDR4_DIMM_CH3_DQ42: J4.115 U2.CE14
DDR4_DIMM_CH3_DQ43: J4.260 U2.CF15
DDR4_DIMM_CH3_DQ44: J4.106 U2.CE10
DDR4_DIMM_CH3_DQ45: J4.251 U2.CH11
DDR4_DIMM_CH3_DQ46: J4.113 U2.CF11
DDR4_DIMM_CH3_DQ47: J4.258 U2.CG10
DDR4_DIMM_CH3_DQ48: J4.119 U2.CM7
DDR4_DIMM_CH3_DQ49: J4.264 U2.CN8
DDR4_DIMM_CH3_DQ50: J4.126 U2.CK7
DDR4_DIMM_CH3_DQ51: J4.271 U2.CL8
DDR4_DIMM_CH3_DQ52: J4.117 U2.CK3
DDR4_DIMM_CH3_DQ53: J4.262 U2.CN4
DDR4_DIMM_CH3_DQ54: J4.124 U2.CL4
DDR4_DIMM_CH3_DQ55: J4.269 U2.CM3
DDR4_DIMM_CH3_DQ56: J4.130 U2.CH7
DDR4_DIMM_CH3_DQ57: J4.275 U2.CF7
DDR4_DIMM_CH3_DQ58: J4.137 U2.CE8
DDR4_DIMM_CH3_DQ59: J4.282 U2.CG8
DDR4_DIMM_CH3_DQ60: J4.128 U2.CE4
DDR4_DIMM_CH3_DQ61: J4.273 U2.CG4
DDR4_DIMM_CH3_DQ62: J4.135 U2.CH3
DDR4_DIMM_CH3_DQ63: J4.280 U2.CF3
DDR4_DIMM_CH3_DQ64: J4.49 U2.CM21
DDR4_DIMM_CH3_DQ65: J4.194 U2.CN22
DDR4_DIMM_CH3_DQ66: J4.56 U2.CK21
DDR4_DIMM_CH3_DQ67: J4.201 U2.CL22
DDR4_DIMM_CH3_DQ68: J4.47 U2.CK17
DDR4_DIMM_CH3_DQ69: J4.192 U2.CL18
DDR4_DIMM_CH3_DQ70: J4.54 U2.CN18
DDR4_DIMM_CH3_DQ71: J4.199 U2.CM17
DDR4_DIMM_CH3_DQS_N0: J4.152 U2.CK27
DDR4_DIMM_CH3_DQS_N1: J4.163 U2.CF27
DDR4_DIMM_CH3_DQS_N2: J4.174 U2.CE20
DDR4_DIMM_CH3_DQS_N3: J4.185 U2.CY27
DDR4_DIMM_CH3_DQS_N4: J4.244 U2.CK13
DDR4_DIMM_CH3_DQS_N5: J4.255 U2.CF13
DDR4_DIMM_CH3_DQS_N6: J4.266 U2.CL6
DDR4_DIMM_CH3_DQS_N7: J4.277 U2.CE6
DDR4_DIMM_CH3_DQS_N8: J4.196 U2.CL20
DDR4_DIMM_CH3_DQS_P0: J4.153 U2.CM27
DDR4_DIMM_CH3_DQS_P1: J4.164 U2.CH27
DDR4_DIMM_CH3_DQS_P2: J4.175 U2.CG20
DDR4_DIMM_CH3_DQS_P3: J4.186 U2.DB27
DDR4_DIMM_CH3_DQS_P4: J4.245 U2.CM13
DDR4_DIMM_CH3_DQS_P5: J4.256 U2.CH13
DDR4_DIMM_CH3_DQS_P6: J4.267 U2.CN6
DDR4_DIMM_CH3_DQS_P7: J4.278 U2.CG6
DDR4_DIMM_CH3_DQS_P8: J4.197 U2.CN20
DDR4_DIMM_CH3_ODT0: J4.87 U2.DB13
DDR4_DIMM_CH3_ODT1: J4.91 U2.CY13
DDR4_DIMM_CH3_PAR: J4.222 U2.DA10
DDR4_DIMM_CH3_RESET_N: J4.58 R75.1 R76.2 U2.CY15
DDR4_DIMM_CH3_RZQ: R84.1 U2.DB7
DDR4_DIMM_CH3_SA0: J4.139 R72.1
DDR4_DIMM_CH3_SA1: J4.140 R73.1
DDR4_DIMM_CH3_SA2: J4.238 R74.2
DDR4_DIMM_CH3_TDQS_N9: J4.8 U2.CL26
DDR4_DIMM_CH3_TDQS_N10: J4.19 U2.CE26
DDR4_DIMM_CH3_TDQS_N11: J4.30 U2.CF19
DDR4_DIMM_CH3_TDQS_N12: J4.41 U2.DA26
DDR4_DIMM_CH3_TDQS_N13: J4.100 U2.CL12
DDR4_DIMM_CH3_TDQS_N14: J4.111 U2.CE12
DDR4_DIMM_CH3_TDQS_N15: J4.122 U2.CK5
DDR4_DIMM_CH3_TDQS_N16: J4.133 U2.CF5
DDR4_DIMM_CH3_TDQS_N17: J4.52 U2.CK19
DDR4_DIMM_SCL: R36.1 U1.4 U2.B23
DDR4_DIMM_SDA: R37.1 U1.5 U2.B21
DDR4D_SCL: J1.141 J2.141 J3.141 J4.141 R5.1 U1.11
DDR4D_SDA: J1.285 J2.285 J3.285 J4.285 R6.1 U1.10
E_RX_CLK: R127.1 R152.2 R153.1 U7.35
E_RX_DV: R129.1 R150.2 R151.1 U7.33
E_RXD0: R130.1 R148.2 R149.1 U7.32
E_RXD1: R131.1 R146.2 R147.1 U7.31
E_RXD2: R132.1 R144.2 R145.1 U7.28
E_RXD3: R133.1 R141.2 R142.1 U7.27
EMMC_CLK: U2.AH5 U16.M6 U16.N7 U16.P7
EMMC_CMD: R226.1 R235.1 U2.AD1
EMMC_COMMAND: R226.2 U16.L1 U16.L2 U16.L3 U16.M5
EMMC_DAT0: R220.2 U16.A3
EMMC_DAT1: R221.2 U16.A4
EMMC_DAT2: R222.2 U16.A5
EMMC_DAT3: R218.2 U16.A1 U16.B2
EMMC_DAT4: R223.2 U16.A2 U16.B3
EMMC_DAT5: R219.2 U16.B4 U16.C3 U16.D1 U16.D2
EMMC_DAT6: R224.2 U16.B5 U16.C5
EMMC_DAT7: R225.2 U16.A8 U16.B6 U16.B7
EMMC_DATA0: R220.1 R227.1 U2.AG6
EMMC_DATA1: R221.1 R228.1 U2.AB1
EMMC_DATA2: R222.1 R229.1 U2.AG4
EMMC_DATA3: R218.1 R230.1 U2.AD3
EMMC_DATA4: R223.1 R231.1 U2.AF5
EMMC_DATA5: R219.1 R232.1 U2.AC2
EMMC_DATA6: R224.1 R233.1 U2.AF1
EMMC_DATA7: R225.1 R234.1 U2.AB3
EMMC_RSTN: R236.1 U16.K5 U26.E13
EN: R187.1 U14.20
ENET_1.2V_AVDDL: C230.1 C231.2 C232.2 L6.2 U7.4 U7.9
ENET_1.2V_AVDLL_PLL: C223.1 C224.2 L5.2 U7.44
ENET_1.2V_DVDDL: C236.1 C237.2 C238.2 C239.2 C240.2 C241.2 C242.2 L7.2 U7.14 U7.18 U7.23 U7.26 U7.30 U7.39
ENET_1.8V_DVDDH: C219.1 C220.2 C221.2 C222.2 L4.2 R136.1 R138.1 R141.1 R144.1 R146.1 R148.1 R150.1 R152.1 R154.1 U7.16 U7.34 U7.40
ENET_3.3V_AVDDH: C216.1 C217.2 C218.2 L3.2 U7.1 U7.12
ENET_GTX_CLK: R128.2 U2.AC4
ENET_INTN: R158.2 U2.AC6 U7.38
ENET_LED1: Q4.1 R138.2 R139.1 U7.17
ENET_LED2: Q2.1 R136.2 R137.1 U7.15
ENET_MDC: R156.2 U2.F3 U7.36
ENET_MDIO: R157.2 U2.AD13 U7.37
ENET_RSET: R135.1 U7.48
ENET_RSTN: R159.2 U7.42 U26.G10
ENET_RX_CLK: R127.2 U2.AA4
ENET_RX_DV: R129.2 U2.T1
ENET_RXD0: R130.2 U2.AF7
ENET_RXD1: R131.2 U2.M1
ENET_RXD2: R132.2 U2.AB5
ENET_RXD3: R133.2 U2.U2
ENET_TX_EN: U2.V1 U7.25
ENET_TXD0: U2.AD5 U7.19
ENET_TXD1: U2.P1 U7.20
ENET_TXD2: U2.AF9 U7.21
ENET_TXD3: U2.W2 U7.22
ENET_VDD1.2V: C225.2 C233.1 C234.1 L5.1 L6.1 L7.1 R164.1 R165.2 U8.1 U8.2(VOUT2)
ENET_XI: R161.2 U7.46
EXT_JTAG_TCK: J14.1 R347.1 R831.1 U26.J1 U29.1
EXT_JTAG_TDI: J14.9 R343.2 U26.L3 U29.8
EXT_JTAG_TDO: J14.3 R341.2 U26.K2 U29.11
EXT_JTAG_TMS: J14.5 R342.2 U26.M1 U29.4
FAN_CTRL: J15.4 R784.1 U30.K12
FAULT: R5937.1 R5938.1 R6090.1 R6110.1 R6111.1 R6112.1 R6113.1 U47.18
FPGA_3V3_LED0: Q5.1 U26.D1
FPGA_3V3_LED1: Q7.1 U26.C2
FPGA_3V3_LED2: Q8.1 U26.B1
FPGA_3V3_LED3: Q9.1 U26.H1
FPGA_BYPASSN: R351.1 SW4.4 U26.E4
FPGA_CONF_DONE: Q10.1 R123.2 U2.CA60 U26.F8
FPGA_CVP_CONFDONE: R124.2 R321.2 R5773.2 U26.C13
FPGA_I2C_EN: R301.2 SW3.1 U23.8 U26.K13
FPGA_I2C_SCL: R303.1 U2.F23 U23.2
FPGA_I2C_SDA: R302.1 U2.D19 U23.3
FPGA_INIT_DONE: R122.2 U2.CF59 U26.B12
FPGA_JTAG_TCK: R119.2 U2.CU62 U26.C11
FPGA_JTAG_TDI: R118.2 U2.CV61 U26.A12
FPGA_JTAG_TDO: U2.CR62 U26.D11
FPGA_JTAG_TMS: R117.2 U2.CT61 U26.E10
FPGA_LED0: R35.2 U2.C30 U26.H9
FPGA_LED1: R34.2 U2.A30 U26.G13
FPGA_LED2: R33.2 U2.D31 U26.H8
FPGA_LED3: R32.2 U2.B31 U26.G12
FPGA_NCONFIG: R121.2 U2.CB57 U26.E9
FPGA_NSTATUS: R120.2 U2.CH59
FPGA_OSC_CLK_1: R259.1 U2.CC60
FPGA_PCIE_PERSTN: R89.2 R357.1 U2.BU58
FPGA_PMBUS_EN: R292.2 SW3.4 U20.5 U26.G4
FPGA_SDM_SCL: R282.1 U2.CG60 U20.7
FPGA_SDM_SDA: R280.1 U2.CE60 U20.6
FPGA_TEMP0N: R402.2 U2.CA52
FPGA_TEMP0P: R401.2 U2.CC52
FPGA_TEMP1N: R731.2 U2.AH43
FPGA_TEMP1P: R730.2 U2.AF43
FPGA_TEMP2N: R733.2 U2.AG46
FPGA_TEMP2P: R732.2 U2.AH45
FPGA_TEMP3N: R735.2 U2.AR20
FPGA_TEMP3P: R734.2 U2.AN18
FPGA_VCC: C762.1 C763.1 C764.1 C765.1 C766.1 C767.1 C768.1 C769.1 C770.1 C771.1 C772.1 C773.1 C774.1 C775.1 C776.1 C777.1 C778.1 C779.1 C780.1 C781.1 C782.1 C783.1 C784.1 C785.1 C786.1 C787.1 C788.1 C789.1 C790.1 C791.1 C792.1 C793.1 C794.1 C795.1 C796.1 C797.1 C798.1 C799.1 C800.1 C801.1 C802.2 C803.2 C804.2 C805.2 C806.2 C807.2 C808.1 C809.1 C810.1 C811.1 C812.1 C814.1 C815.1 C817.1 C818.1 C819.1 C821.1 C825.1 C1483.2 C1484.2 C1485.2 C1486.2 C1487.2 C1488.2 C1489.2 C1490.2 C1491.2 C1492.2 C1493.2 C1494.2 C1495.2 C1496.2 C1497.2 C1498.2 C1499.2 C1500.2 C1501.2 C1502.2 C1503.2 C1504.2 C1505.2 C1506.2 C1507.2 C1508.2 C1509.2 C1510.2 C1511.2 C1512.2 C1513.2 C1514.2 C1515.2 C1516.2 C1517.2 C1841.1(P) C1842.2 C1843.2 C1844.1(P) C1845.1(P) C1846.1(P) C1847.1(P) C1856.1(P) C1857.2 C1858.2 C1869.1(P) C1870.2 C1871.2 C1883.1(P) C1884.2 C1885.2 C2013.2 C2014.2 C2015.2 C2016.2 C2021.2 C2022.2 C2023.2 C2024.2 L23.2 L24.2 L25.2 L26.2 R362.2 R5947.1 R5948.2 U2.AF27 U2.AF29 U2.AF31 U2.AF33 U2.AF35 U2.AF41 U2.AH27 U2.AH29 U2.AH31 U2.AH33 U2.AH35 U2.AH41 U2.AK21 U2.AK25 U2.AK27 U2.AK29 U2.AK31 U2.AK33 U2.AK35 U2.AK37 U2.AK39 U2.AK41 U2.AM21 U2.AM23 U2.AM25 U2.AM27 U2.AM29 U2.AM31 U2.AM33 U2.AM35 U2.AM37 U2.AM39 U2.AM41 U2.AP21 U2.AP23 U2.AP25 U2.AP37 U2.AP39 U2.AP41 U2.AT21 U2.AT23 U2.AT25 U2.AT37 U2.AT39 U2.AT41 U2.AV21 U2.AV23 U2.AV25 U2.AV37 U2.AV39 U2.AV41 U2.AY21 U2.AY23 U2.AY25 U2.AY37 U2.AY39 U2.AY41 U2.BB21 U2.BB23 U2.BB37 U2.BB39 U2.BB41 U2.BD21 U2.BD23 U2.BD25 U2.BD37 U2.BD39 U2.BD41 U2.BF21 U2.BF23 U2.BF25 U2.BF37 U2.BF39 U2.BF41 U2.BH21 U2.BH23 U2.BH25 U2.BH37 U2.BH39 U2.BH41 U2.BK21 U2.BK23 U2.BK25 U2.BK37 U2.BK39 U2.BK41 U2.BM21 U2.BM23 U2.BM25 U2.BM27 U2.BM29 U2.BM31 U2.BM33 U2.BM35 U2.BM37 U2.BM39 U2.BM41 U2.BP21 U2.BP23 U2.BP25 U2.BP27 U2.BP29 U2.BP31 U2.BP33 U2.BP35 U2.BP37 U2.BP39 U2.BP41 U2.BT21 U2.BT23 U2.BT27 U2.BT29 U2.BT31 U2.BT33 U2.BT35 U2.BV21 U2.BV23 U2.BV27 U2.BV29 U2.BV31 U2.BV33 U2.BV35
FPGA_VCC_EN: R363.2 R877.2 R5943.2 TP16.1 U47.20
FPGA_VCC_PG: R5933.1 TP20.1 U30.A9 U47.13
FT232R_3V3OUT: C249.2 C250.1 R171.1 U11.16
FT232R_RXD: U10.4(Y) U11.2
FT232R_TXD: U9.2 U11.30
FT232R_VCCIO: C244.1 C247.1 C251.2 C252.1 C253.1 D2.A D3.A R167.2 R171.2 R172.1 R179.2 U10.5 U11.1(VCCIO) U12.5
FX2_D_N: J13.2 U27.2 U28.9
FX2_D_P: J13.3 U27.1 U28.8
FX2_FLAGA: U26.J8 U28.29
FX2_FLAGB: U26.L5 U28.30
FX2_FLAGC: U26.L11 U28.31
FX2_PA0: U26.K6 U28.33
FX2_PA1: U26.M4 U28.34
FX2_PA2: U26.M5 U28.35
FX2_PA3: U26.K5 U28.36
FX2_PA4: U26.L4 U28.37
FX2_PA5: U26.J5 U28.38
FX2_PA6: U26.N4 U28.39
FX2_PA7: U26.J7 U28.40
FX2_PB0: U26.K7 U28.18
FX2_PB1: U26.N9 U28.19
FX2_PB2: U26.N7 U28.20
FX2_PB3: U26.N6 U28.21
FX2_PB4: U26.M13 U28.22
FX2_PB5: U26.N5 U28.23
FX2_PB6: U26.M9 U28.24
FX2_PB7: U26.M11 U28.25
FX2_PD0: U28.45 U29.16
FX2_PD1: U28.46 U29.3
FX2_PD2: U28.47 U29.9
FX2_PD3: U28.48 U29.12
FX2_PD4: U26.N8 U28.49
FX2_PD5: U26.M7 U28.50
FX2_PD6: U26.M8 U28.51
FX2_PD7: U26.J6 U28.52
FX2_RESETN: R328.1 U25.2 U26.N3 U28.42
FX2_SCL: R330.1 U26.K8 U28.15
FX2_SDA: R326.1 R331.1 U28.16
FX2_SLRDN: U26.M12 U28.1
FX2_SLWRN: U26.N10 U28.2
FX2_WAKEUP: C345.1 R339.2 R340.2 R344.2 U28.44
HPS_COLD_RESETN: R315.1 U24.2 U26.B9
HPS_I2C_EN: R290.2 SW3.2 U22.5 U26.H3
HPS_I2C_SCL: R294.1 U2.L2 U22.7
HPS_I2C_SDA: R293.1 U2.AB7 U22.6
HPS_JTAG_TCK: R198.1 U26.F12
HPS_JTAG_TDI: R200.1 U26.E12
HPS_JTAG_TDO: R197.1 U26.C12
HPS_JTAG_TMS: R199.1 U26.B11
HPS_OSC_CLK: R834.1 U2.AD11
HPS_RESETN: R125.2 R354.1 U2.CB59
HPS_WARM_RESETN: R319.1 R324.1 S4.2 U26.D6
I2C_INA_SCL: R6283.2 R6286.2 R6289.1 U126.5
I2C_INA_SDA: R6284.2 R6285.2 R6290.1 U126.6
IIN-_1: C1919.2 C1920.2 C1921.2 C1922.2 C1923.2 C1924.2 C1925.2 R6002.2 R6008.2 U55.E1 U55.E2 U55.E3 U55.E4 U55.F1 U55.F2 U55.F3 U55.F4 U55.G1 U55.G2 U55.G3 U55.G4 U55.H1 U55.H2 U55.H3 U55.H4
IN1+_3P3V: C7771.1 C7772.1 C7773.1 C7774.1 C7775.1 C7776.1 L30.2 R6271.1 R6276.1 R6291.1 TP971.1
INTVCC_PVCC: R5960.2 U124.C3
IO_1P8V: C207.1 C208.1 C243.1 C258.2 C270.1 C271.1 C272.1 C273.1 C327.2 C331.2 C1236.2 C1237.1 C1238.1 C1421.1 C1422.1 C1423.2 C1424.1 C1425.1 C1988.1 C1989.1 C2034.1 FB19.1 FB22.2 FB23.2 L4.1 R107.2 R108.2 R109.2 R116.1 R117.1 R118.1 R120.1 R121.1 R122.1 R123.1 R124.1 R125.1 R140.1 R143.1 R156.1 R157.1 R158.1 R159.1 R174.2 R181.1 R182.1 R183.1 R184.1 R185.1 R186.1 R190.2 R205.2 R207.2 R210.1 R212.2 R213.2 R214.1 R215.1 R216.1 R227.2 R228.2 R229.2 R230.2 R231.2 R232.2 R233.2 R234.2 R235.2 R236.2 R265.2 R268.2 R269.2 R273.1 R280.2 R282.2 R293.2 R294.2 R375.2 R5774.1 U2.AD21 U2.AF21 U2.AH21 U2.BY41 U2.CB41 U6.B4 U9.5 U14.2 U16.C6 U16.M4 U16.N4 U16.P3 U16.P5 U20.8(VCCB) U22.8(VCCB) U70.A1 U70.A7 U70.B1 U70.B7 U70.F1 U70.F7 U70.G1(VOUT4_2) U70.G7
IO_1P8V_AGND: R6074.1 ST20.1
IO_1P8V_EN: R367.2 R6076.2
IO_1P8V_PG: R6071.1 U30.E8 U70.D2
IO_3P3V: C142.1 C143.2 C157.1 C158.2 C173.1 C174.1 C226.2 C229.1 C264.1 C267.1 C268.1 C269.1 C304.1 C328.2 C329.2 C330.2 C332.2 C334.2 C335.1 C679.1 C680.1 C703.2 C705.2 FB21.1 FB40.1 FB41.1 FB42.1 L3.1 L15.1 L16.1 L17.1 L18.1 L19.1 L20.1 R20.1 R90.1 R91.1 R92.2 R93.2 R95.1 R96.1 R98.2 R99.2 R102.2 R103.2 R104.1 R105.2 R106.1 R126.1 R134.1 R162.1 R163.2 R243.2 R244.2 R245.2 R247.2 R281.2 R283.2 R286.2 R287.2 R290.1 R291.1 R292.1 R306.2 R309.2 R311.2 R313.2 R314.2 R316.2 R317.2 R667.2 R704.2 R705.2 R706.2 R707.2 R708.2 R709.2 R715.1 R716.1 R717.1 R718.1 R719.1 R721.1 R801.2 R809.2 R832.1 U5.14 U8.9 U8.10 U15.A2 U16.E6 U16.F5 U16.J10 U16.K9 U20.1 U21.1 U21.8(VCCB) U22.1 U23.14 U24.4(VCC) U62.1 U62.2 U62.3(S3) U63.6(VOUT) U67.14 U68.14
IO_3P3V_EN: R382.2 R670.2
IREF: C1816.2 R6105.1 U47.33 U47.43 U47.44 U47.47 U47.48
ISENSE0: R5928.2 U47.4 U76.33
ISENSE2: R5932.2 U47.3 U78.33
ISENSE3: R5934.2 U47.52 U79.33
ISENSE4: R5930.2 U47.51 U77.33
ITH0: C1822.2 U47.9
ITHR0: C1823.1 U47.10
JTAG_INPUT_SOURCE: R348.1 SW4.1 U26.M3
LINK_LED: J8.17 L1.2
LOGIC0A: J12.30 R208.2
LOGIC0B: J12.32 R209.2
LOGIC1: J12.34 R210.2
LT4625_INTVCC: C443.2 R431.2 R434.2 R435.2 R436.2 U43.E4
LTM3888_ALERTN: R516.2 R876.2 TP17.1 U47.17
LTM3888_SCL: J22.2 R515.2 R874.2 U47.15
LTM3888_SDA: J22.4 R514.2 R875.2 U47.16
LTM4623_INTVCC0: C1900.2 R6096.1 U51.E4
LTM4623_INTVCC1: C1975.2 R6093.1 U61.E4
LTM4668_INTVCC0: C2039.2 R6072.2 U70.C4 U70.C7 U70.E1 U70.E7
LTM4668_INTVCC1: C2038.1 R6065.2 U66.C4 U66.C7 U66.E1 U66.E7
LTM4686_3P3V_PG: D25.1(K) U30.B6
LTM_PMBUS_ALERTN: R5974.2 R6006.1 U26.L1 U30.B11
LTM_SCL: J17.1 R470.2 R6274.2 R6286.1 U55.J12 U71.E4
LTM_SDA: J17.2 R471.2 R6275.2 R6285.1 U55.H10 U71.D4
MAIN_I2C_SCL: R261.1 R284.1 R287.1 R296.2 R304.2 R470.1 U17.16 U21.7 U26.C10 U30.N9 U32.20 U73.6
MAIN_I2C_SDA: R263.1 R285.1 R286.1 R298.2 R305.2 R471.1 U17.18 U21.6 U26.A8 U30.M12 U32.19 U73.5
MAIN_PMBUS_EN: R291.2 SW3.3 U21.5 U26.H2
MAX10_AGND: C382.2 C383.2 C384.2 C385.2 C386.2 C387.2 C388.2 C389.2 C390.2 C391.2 R387.1 U30.E2
MAX_SDA: R326.2 U26.L10
MDI_HPS_N0: J8.10 U7.3
MDI_HPS_N1: J8.5 U7.6
MDI_HPS_N2: J8.2 U7.8
MDI_HPS_N3: J8.9 U7.11
MDI_HPS_P0: J8.11 U7.2
MDI_HPS_P1: J8.4 U7.5
MDI_HPS_P2: J8.3 U7.7
MDI_HPS_P3: J8.8 U7.10
MICTOR_BYPASSN: R350.1 SW4.3 U26.M2
MICTOR_JTAG_TCK: J12.15 R198.2 R217.2 U2.AC8
MICTOR_JTAG_TDI: J12.19 R200.2 R214.2 U2.G2
MICTOR_JTAG_TDO: J12.11 R197.2 R215.2 U2.AA8
MICTOR_JTAG_TMS: J12.17 R199.2 R216.2 U2.J2
MICTOR_JTAG_TRSTN: J12.21 R213.1
MICTOR_PWR1: J12.12(VTREF) R205.1
MICTOR_SRSTN: J12.9 R212.1 U26.F9
MODE/SYNC: R6072.1 R6073.2 U70.E4
MODE/SYNC1: R6065.1 R6066.2 U66.E4
MSEL1: R108.1 SW1.2 U2.CY59
MSEL2: R109.1 SW1.3 U2.CV59
OVERTEMPN: D11.C(CATHODE) R399.1 U30.K11 U32.16
PCIE_1V2_CLKREQN: R833.2 U2.CR20 U5.5
PCIE_CLKREQN: C1472.1 J7.B12 R832.2 U5.10
PCIE_EP_3P3V: J7.A9 J7.A10 J7.B8 R100.2
PCIE_EP_3V3_I2C_SCL: J7.B5 R98.1 U5.13 U26.K1
PCIE_EP_3V3_I2C_SDA: J7.B6 R99.1 U5.12 U26.L2
PCIE_EP_3V3_WAKEN: R101.2 R106.2 U5.11
PCIE_EP_12V: C433.1 D16.1(C) J7.A2 J7.A3 J7.B1 J7.B2 J7.B3 R412.1 R428.2 U38.1 U38.2 U38.3(S3) U40.2
PCIE_EP_I2C_SCL: R81.1 U2.CT19 U5.2
PCIE_EP_I2C_SDA: R82.1 U2.CV17 U5.3
PCIE_EP_JTAG_TCK: J7.A5 R358.1 R359.2 U26.E3
PCIE_EP_JTAG_TDI: J7.A6 R102.1 U26.F1
PCIE_EP_JTAG_TDO: J7.A7 U26.F4
PCIE_EP_JTAG_TMS: J7.A8 R103.1 U26.C1
PCIE_EP_PERSTN: J7.A11 R105.1 U26.B7 U30.H4
PCIE_EP_PRSNT_N: J7.A1 SW6.1 SW6.2 SW6.3 SW6.4
PCIE_EP_PRSNT_NX1: C1479.1 J7.B17 SW6.5(B4)
PCIE_EP_PRSNT_NX4: C1480.1 J7.B31 SW6.6
PCIE_EP_PRSNT_NX8: C1481.1 J7.B48 SW6.7
PCIE_EP_PRSNT_NX16: C1482.1 J7.B81 SW6.8
PCIE_EP_RX_CN0: C175.1 J7.A17
PCIE_EP_RX_CN1: C178.1 J7.A22
PCIE_EP_RX_CN2: C180.1 J7.A26
PCIE_EP_RX_CN3: C182.1 J7.A30
PCIE_EP_RX_CN4: C184.1 J7.A36
PCIE_EP_RX_CN5: C186.1 J7.A40
PCIE_EP_RX_CN6: C188.1 J7.A44
PCIE_EP_RX_CN7: C190.1 J7.A48
PCIE_EP_RX_CN8: C192.1 J7.A53
PCIE_EP_RX_CN9: C194.1 J7.A57
PCIE_EP_RX_CN10: C196.1 J7.A61
PCIE_EP_RX_CN11: C198.1 J7.A65
PCIE_EP_RX_CN12: C200.1 J7.A69
PCIE_EP_RX_CN13: C202.1 J7.A73
PCIE_EP_RX_CN14: C204.1 J7.A77
PCIE_EP_RX_CN15: C206.1 J7.A81
PCIE_EP_RX_CP0: C172.1 J7.A16
PCIE_EP_RX_CP1: C177.1 J7.A21
PCIE_EP_RX_CP2: C179.1 J7.A25
PCIE_EP_RX_CP3: C181.1 J7.A29
PCIE_EP_RX_CP4: C183.1 J7.A35
PCIE_EP_RX_CP5: C185.1 J7.A39
PCIE_EP_RX_CP6: C187.1 J7.A43
PCIE_EP_RX_CP7: C189.1 J7.A47
PCIE_EP_RX_CP8: C191.1 J7.A52
PCIE_EP_RX_CP9: C193.1 J7.A56
PCIE_EP_RX_CP10: C195.1 J7.A60
PCIE_EP_RX_CP11: C197.1 J7.A64
PCIE_EP_RX_CP12: C199.1 J7.A68
PCIE_EP_RX_CP13: C201.1 J7.A72
PCIE_EP_RX_CP14: C203.1 J7.A76
PCIE_EP_RX_CP15: C205.1 J7.A80
PCIE_EP_RX_N0: C175.2 U2.BR56
PCIE_EP_RX_N1: C178.2 U2.BM53
PCIE_EP_RX_N2: C180.2 U2.BL56
PCIE_EP_RX_N3: C182.2 U2.BH53
PCIE_EP_RX_N4: C184.2 U2.BG56
PCIE_EP_RX_N5: C186.2 U2.BD53
PCIE_EP_RX_N6: C188.2 U2.BC56
PCIE_EP_RX_N7: C190.2 U2.AY53
PCIE_EP_RX_N8: C192.2 U2.AW56
PCIE_EP_RX_N9: C194.2 U2.AT53
PCIE_EP_RX_N10: C196.2 U2.AR56
PCIE_EP_RX_N11: C198.2 U2.AM53
PCIE_EP_RX_N12: C200.2 U2.AL56
PCIE_EP_RX_N13: C202.2 U2.AH53
PCIE_EP_RX_N14: C204.2 U2.AG56
PCIE_EP_RX_N15: C206.2 U2.AD53
PCIE_EP_RX_P0: C172.2 U2.BP55
PCIE_EP_RX_P1: C177.2 U2.BN52
PCIE_EP_RX_P2: C179.2 U2.BK55
PCIE_EP_RX_P3: C181.2 U2.BJ52
PCIE_EP_RX_P4: C183.2 U2.BF55
PCIE_EP_RX_P5: C185.2 U2.BE52
PCIE_EP_RX_P6: C187.2 U2.BB55
PCIE_EP_RX_P7: C189.2 U2.BA52
PCIE_EP_RX_P8: C191.2 U2.AV55
PCIE_EP_RX_P9: C193.2 U2.AU52
PCIE_EP_RX_P10: C195.2 U2.AP55
PCIE_EP_RX_P11: C197.2 U2.AN52
PCIE_EP_RX_P12: C199.2 U2.AK55
PCIE_EP_RX_P13: C201.2 U2.AJ52
PCIE_EP_RX_P14: C203.2 U2.AF55
PCIE_EP_RX_P15: C205.2 U2.AE52
PCIE_EP_TX_N0: J7.B15 U2.BR62
PCIE_EP_TX_N1: J7.B20 U2.BM59
PCIE_EP_TX_N2: J7.B24 U2.BL62
PCIE_EP_TX_N3: J7.B28 U2.BH59
PCIE_EP_TX_N4: J7.B34 U2.BG62
PCIE_EP_TX_N5: J7.B38 U2.BD59
PCIE_EP_TX_N6: J7.B42 U2.BC62
PCIE_EP_TX_N7: J7.B46 U2.AY59
PCIE_EP_TX_N8: J7.B51 U2.AW62
PCIE_EP_TX_N9: J7.B55 U2.AT59
PCIE_EP_TX_N10: J7.B59 U2.AR62
PCIE_EP_TX_N11: J7.B63 U2.AM59
PCIE_EP_TX_N12: J7.B67 U2.AL62
PCIE_EP_TX_N13: J7.B71 U2.AH59
PCIE_EP_TX_N14: J7.B75 U2.AG62
PCIE_EP_TX_N15: J7.B79 U2.AD59
PCIE_EP_TX_P0: J7.B14 U2.BP61
PCIE_EP_TX_P1: J7.B19 U2.BN58
PCIE_EP_TX_P2: J7.B23 U2.BK61
PCIE_EP_TX_P3: J7.B27 U2.BJ58
PCIE_EP_TX_P4: J7.B33 U2.BF61
PCIE_EP_TX_P5: J7.B37 U2.BE58
PCIE_EP_TX_P6: J7.B41 U2.BB61
PCIE_EP_TX_P7: J7.B45 U2.BA58
PCIE_EP_TX_P8: J7.B50 U2.AV61
PCIE_EP_TX_P9: J7.B54 U2.AU58
PCIE_EP_TX_P10: J7.B58 U2.AP61
PCIE_EP_TX_P11: J7.B62 U2.AN58
PCIE_EP_TX_P12: J7.B66 U2.AK61
PCIE_EP_TX_P13: J7.B70 U2.AJ58
PCIE_EP_TX_P14: J7.B74 U2.AF61
PCIE_EP_TX_P15: J7.B78 U2.AE58
PCIE_EP_WAKEN: R83.1 U2.CR18 U5.4
PCIE_PERSTN: R320.1 R323.1 S3.2 U26.M10
PCIE_PWRBRKN: C1474.1 J7.B30 R794.2 U26.B4 U30.G9
PCIE_RSV2: C1473.1 J7.A19
PCIE_RSV4: C1475.1 J7.A32
PCIE_RSV5: C1476.1 J7.A33
PCIE_RSV6: C1477.1 J7.B82
PCIE_RSV7: C1478.1 J7.A50
PHMD137: R6269.1 R6272.2 U46.28
PHY_25M_3.3V: C227.2 C228.2 R160.1 R162.2 Y1.4(VCC)
POWER_ON: R385.2 R408.2 R420.2 R429.2 SW5.5
PWM0: R5946.1 U47.5
PWM2: R5955.1 U47.2
PWM3: R5962.1 U47.1
PWM4: R5952.1 U47.50
PWR_ENA: R179.1 U11.11
PWR_GOOD: R356.2 U26.E1 U30.E9
PWR_LED_DR: Q6.1 R310.1 U30.B12
PWR_M10_VCCA: C406.2 C407.2 C408.2 C409.2 C410.2 FB29.2 U30.D4 U30.D10 U30.K4 U30.K9
PWR_M10_VCCIO1A: C397.2 C398.2 L9.2 U30.F2
PWR_MAX10_BYPASSN: R349.1 SW4.2 U26.J2
PWR_MAX10_JTAG_TCK: R355.2 R392.2 U26.B3
PWR_MAX10_JTAG_TDI: R353.2 R393.2 U26.A5
PWR_MAX10_JTAG_TDO: R394.2 U26.A2
PWR_MAX10_JTAG_TMS: R352.2 R391.2 U26.E6
QSFPDD0_1V2_INT_L: U2.F31 U26.L12
QSFPDD0_1V2_LPMODE: R42.1 R43.2 U2.H31 U26.J10
QSFPDD0_1V2_MODPRS_L: U2.G30 U26.K11
QSFPDD0_1V2_MODSEL_L: R40.1 U2.C26 U26.J13
QSFPDD0_1V2_RESET_L: R38.1 U2.J30 U26.K10
QSFPDD0_3V3_INT_L: J5.28 R90.2 U26.E8
QSFPDD0_3V3_LPMODE: J5.31 U26.A11
QSFPDD0_3V3_MODPRS_L: J5.27 R91.2 U26.A10
QSFPDD0_3V3_MODSEL_L: J5.8 U26.A3
QSFPDD0_3V3_RESET_L: J5.9 U26.B10
QSFPDD0_FPGA_LED0: R714.1 U2.H19 U67.2
QSFPDD0_FPGA_LED1: R711.1 U2.F19 U67.3
QSFPDD0_FPGA_LED2: R710.1 U2.J20 U67.4
QSFPDD0_LED0: Q24.1 R717.2 U67.13
QSFPDD0_LED1: Q26.1 R716.2 U67.12
QSFPDD0_LED2: Q25.1 R715.2 U67.11
QSFPDD0_RX0_N: J5.18 U2.AJ8
QSFPDD0_RX0_P: J5.17 U2.AK7
QSFPDD0_RX1_N: J5.21 U2.AN8
QSFPDD0_RX1_P: J5.22 U2.AP7
QSFPDD0_RX2_N: J5.15 U2.AM11
QSFPDD0_RX2_P: J5.14 U2.AL10
QSFPDD0_RX3_N: J5.24 U2.AT11
QSFPDD0_RX3_P: J5.25 U2.AR10
QSFPDD0_RX4_N: J5.56 U2.AU8
QSFPDD0_RX4_P: J5.55 U2.AV7
QSFPDD0_RX5_N: J5.59 U2.BA8
QSFPDD0_RX5_P: J5.60 U2.BB7
QSFPDD0_RX6_N: J5.53 U2.AY11
QSFPDD0_RX6_P: J5.52 U2.AW10
QSFPDD0_RX7_N: J5.62 U2.BD11
QSFPDD0_RX7_P: J5.63 U2.BC10
QSFPDD0_TX0_N: J5.37 U2.AJ2
QSFPDD0_TX0_P: J5.36 U2.AK1
QSFPDD0_TX1_N: J5.2 U2.AN2
QSFPDD0_TX1_P: J5.3 U2.AP1
QSFPDD0_TX2_N: J5.34 U2.AM5
QSFPDD0_TX2_P: J5.33 U2.AL4
QSFPDD0_TX3_N: J5.5 U2.AT5
QSFPDD0_TX3_P: J5.6 U2.AR4
QSFPDD0_TX4_N: J5.75 U2.AU2
QSFPDD0_TX4_P: J5.74 U2.AV1
QSFPDD0_TX5_N: J5.40 U2.BA2
QSFPDD0_TX5_P: J5.41 U2.BB1
QSFPDD0_TX6_N: J5.72 U2.AY5
QSFPDD0_TX6_P: J5.71 U2.AW4
QSFPDD0_TX7_N: J5.43 U2.BD5
QSFPDD0_TX7_P: J5.44 U2.BC4
QSFPDD0_VCC: C152.1 C153.2 C154.2 C155.2 J5.30 J5.68 L17.2
QSFPDD0_VCCR: C148.1 C149.2 C150.2 C151.2 J5.10 J5.48 L16.2
QSFPDD0_VCCT: C144.1 C145.2 C146.2 C147.2 J5.29 J5.67 L15.2
QSFPDD1_1V2_INT_L: U2.C28 U26.J9
QSFPDD1_1V2_LPMODE: R44.1 R45.2 U2.A28 U26.H10
QSFPDD1_1V2_MODPRS_L: U2.D27 U26.L13
QSFPDD1_1V2_MODSEL_L: R41.1 U2.B27 U26.J12
QSFPDD1_1V2_RESET_L: R39.1 U2.A26 U26.K12
QSFPDD1_3V3_INT_L: J6.28 R95.2 U26.A4
QSFPDD1_3V3_LPMODE: J6.31 U26.B6
QSFPDD1_3V3_MODPRS_L: J6.27 R96.2 U26.A6
QSFPDD1_3V3_MODSEL_L: J6.8 U26.B5
QSFPDD1_3V3_RESET_L: J6.9 U26.A7
