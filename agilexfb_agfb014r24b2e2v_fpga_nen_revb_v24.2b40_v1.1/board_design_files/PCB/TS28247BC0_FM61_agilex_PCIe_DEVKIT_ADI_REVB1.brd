# Allegro board TS28247BC0_FM61_agilex_PCIe_DEVKIT_ADI_REVB1.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
VCCCLK_GXPL1 on L05_SIG2: 145.55,76.76 145.55,79.2 146.18,79.83 159.9,79.83 161.09,78.64 161.09,64.14 154.97,58.02 127.87,58.02 127.64,58.24 127.64,63.2 127.9,63.45 142.25,63.45 143.26,62.44 146.06,62.44 146.95,63.32 146.95,66.5 147.45,67.01 153.68,67.01 154.82,68.15 154.82,75.39 154.19,76.02 146.28,76.02
VCCFUSE_GXP on BOTTOM: 126.77,55.33 127.07,55.83 127.57,56.93 129.37,56.93 129.37,55.03 128.87,54.03 127.77,54.43 127.37,55.03
VCCFUSEWR_SDM on TOP: 206,53.88 206,52.94 205.67,52.61 205.09,52.61 204.88,52.4 204.88,52.07 205.06,51.89 207.65,51.89 208.03,51.51 208.95,51.51 208.97,51.54 208.97,53.09 207.88,54.18 206.31,54.18
VCCFUSEWR_SDM on L12_SIG4: 159.9,57.48 149.4,57.48 145.8,55.83 140.47,55.83 139.45,54.82 137.42,54.82 136.91,54.31 136.66,54.31 136.02,53.67 135.64,53.67 134.5,52.53 134.5,51.13 133.48,50.12 129.55,50.12 128.53,51.13 128.53,55.83 131.33,58.63 134.72,58.63 137.39,61.29 144.49,61.29 151.22,68.02 151.26,68.02 156.73,73.48 204.1,73.48 208.39,69.19 208.39,47.76 208.4,47.74 208.34,47.68 208.34,47.4 206.74,45.8 179.16,45.8
VCCH_GXPL1 on TOP: 147.84,77.68 147.84,76.15 144.41,76.15 144.15,76.41 144.15,77.42 144.41,77.68
VCCH_GXPL1 on L12_SIG4: 142.25,74.37 140.85,72.98 139.71,72.98 137.31,70.58 134.52,70.58 131.58,67.64 126.75,67.64 126.37,67.26 126.37,59.77 127.13,59.01 134.5,59.01 137.17,61.67 137.8,61.67 137.8,61.67 144.28,61.67 154.19,71.58 154.19,80.72 153.8,81.1 142.63,81.1 142.25,80.72
VCCL_HPS_AGND on BOTTOM: 69.68,68.63 69.86,68.46 69.86,67.59 70.01,67.44 70.42,67.44 70.54,67.57 70.54,69.22 69.91,69.85 67.83,69.85 67.67,70.01 67.67,71.78 68.36,72.47 68.66,72.47 68.79,72.6 68.79,73.36 69.1,73.66 69.1,73.87 68.84,74.12 68.59,74.12 66.66,72.19 66.66,68.99 67.01,68.63
VCCPLL_HPS on L05_SIG2: 131.45,68.66 140.98,68.66 142.63,67.01 146.06,67.01 146.57,66.5 146.57,63.32 145.93,62.69 143.52,62.69 142.37,63.83 129.45,63.83 127.29,65.99 120.4,65.99 119.64,66.75 105.8,66.75 105.42,67.13 105.42,73.23 105.67,73.48 108.97,73.48 109.35,73.1 109.35,71.83 111.89,69.29 130.82,69.29
VCCPLL_SDM on BOTTOM: 129.72,51.59 129.32,51.34 129.12,51.01 128.66,51.24 128.66,51.76 129.34,52.38 129.09,52.83 129.54,53.14 129.72,53.14 129.98,52.89 129.98,52.02
VCCPLLDIG_HPS on TOP: 84.59,71.83 84.59,73.36 84.72,73.48 85.99,73.48 86.11,73.36 86.11,71.83
VCCPLLDIG_SDM on TOP: 140.47,38.69 141.49,38.69 141.49,38.67 141.73,38.43 141.73,36.53 141.43,36.23 140.51,36.23 140.22,36.53 140.22,38.43
VCCPLLDIG_SDM on L03_SIG1: 135.61,35.93 134.25,37.29 134.25,46.61 132.36,48.49 132.09,48.73 127.65,51.4 126.93,52.13 126.93,52.23 126.75,52.4 126.75,55.45 129.17,57.86 136.66,57.86 142.25,52.28 142.25,43.13 141.13,40.79 141.13,36.13 140.93,35.93
VCCR_AGND on BOTTOM: 68.57,54.17 68.59,54.18 70.37,54.18 70.64,53.9 70.64,53.75 70.77,53.62 71.36,53.62 71.56,53.83 71.56,55.1 71.36,55.3 70.62,55.3 69.88,56.04 67.8,56.04 67.65,56.19 67.65,57.97 68.31,58.63 68.71,58.63 68.84,58.75 68.84,59.51 68.46,59.9 68.16,59.9 66.63,58.37 66.63,54.61 67.08,54.17
VCCRTPLL_GXER1 on L07_SIG3: 103.19,60.72 103.26,60.66 103.26,57.99 102.88,57.61 102.37,57.61 101.99,57.23 101.73,57.23 101.35,56.85 89.16,56.85 88.27,55.96 86.49,55.96 84.72,54.18 79.51,54.18 78.87,54.82 78.87,62.94 79.89,63.96 102.93,63.96 103.19,63.69
VDDIM on L07_SIG3: 26.55,109.81 30.36,109.81 30.36,103.58 26.55,103.58
0P6V_VREF_DDR4_CH01 on BOTTOM: 120.53,76.02 122.56,73.99 122.56,72.34 121.93,71.71 120.28,71.71 119.77,72.21 119.77,72.85 119.64,72.98 112.15,72.98 112.15,72.72 111.64,72.21 109.35,72.21 108.64,72.93 107.15,72.93 106.18,71.96 104.53,71.96 104.4,72.09 104.4,73.48 106.94,76.02
0P6V_VTT_DDR4_CH01 on TOP: 63.89,104.73 65.67,102.95 130.56,102.95 130.56,105.74 130.82,106 133.23,106 133.48,105.74 133.48,90.25 133.23,89.99 130.82,89.99 130.56,90.25 130.56,93.42 64.27,93.42 60.08,97.62 53.22,97.62 52.59,98.25 52.59,104.09 53.22,104.73 ; 1 cut-out
0P6V_VTT_DDR4_CH01 on BOTTOM: 130.82,91.26 129.04,91.26 128.79,91.52 128.79,95.58 128.53,95.84 128.53,98.88 130.06,98.88 130.06,104.6 130.69,105.23 131.07,105.23 131.07,91.52
0P6V_VTT_DDR4_CH01 on BOTTOM: 55.63,100.15 55.63,103.96 54.36,103.96 54.24,104.09 53.73,104.09 53.73,103.84 53.86,103.71 54.11,103.71 54.49,103.33 54.49,102.31 54.24,102.06 53.68,102.06 53.09,101.47 53.09,100.15 53.22,100.03 55.51,100.03
0P6V_VTT_DDR4_CH23 on TOP: 125.61,17.99 125.36,18.24 125.36,32.97 125.61,33.23 128.28,33.23 128.53,32.97 128.53,30.3 194.57,30.3 197.37,27.51 204.1,27.51 206.13,25.48 206.13,22.56 204.48,22.56 204.48,20.53 203.59,20.53 203.59,24.84 198.51,24.84 194.57,20.91 128.53,20.91 128.53,18.24 128.28,17.99 ; 1 cut-out
0P6V_VTT_DDR4_CH23 on BOTTOM: 203.52,24.25 203.52,20.44 204.79,20.44 204.91,20.31 205.42,20.31 205.42,20.57 205.29,20.7 205.04,20.7 204.66,21.08 204.66,22.09 204.91,22.35 205.47,22.35 206.06,22.94 206.06,24.25 205.93,24.38 203.64,24.38
0P6V_VTT_DDR4_CH23 on BOTTOM: 127.9,32.59 129.93,32.59 130.18,32.34 130.18,18.87 129.93,18.62 128.79,18.62 128.79,17.86 128.15,17.86 127.9,18.11
0P8V_AGND on BOTTOM: 207.68,62 207.68,60.76 207.27,60.35 207.27,59.31 207.47,59.11 208.03,59.11 208.21,59.29 208.21,59.9 208.85,60.53 208.85,60.81 209.13,61.09 209.13,62.05 208.92,62.26 207.93,62.26
0P8V_AGND on BOTTOM: 204.83,57.18 204.83,56.31 204.58,56.06 204.58,54.59 204.76,54.41 205.24,54.41 205.34,54.51 205.34,55.96 205.49,56.11 205.49,57.2 205.37,57.33 204.99,57.33
0P8V_AGND on L12_SIG4: 208.24,54.43 208.29,54.38 209.15,54.38 209.38,54.61 209.38,61.67 208.62,62.44 204.93,62.44 204.58,62.08 204.58,58.22 204.59,58.21 204.59,54.8 205.01,54.38 208.19,54.38
0P8V_VCCL_SDM on TOP: 213.47,59.16 213.47,57.71 213.07,57.32 210.18,57.32 208.9,56.04 208.9,55.53 209.16,55.26 209.16,55.25 215.15,55.25 215.65,55.76 215.65,59.18 215.45,59.39 213.7,59.39
0P8V_VCCL_SDM on TOP: 142.33,38.73 146.13,38.73 146.13,36.53 144.93,36.53 144.93,34.93 142.33,34.93
0P8V_VCCL_SDM on TOP: 151.92,43.73 147.93,43.73 147.93,45.13 146.43,45.13 146.43,46.73 151.92,46.73
0P8V_VCCL_SDM on BOTTOM: 212.4,55.83 212.4,56.92 212.02,57.31 210.5,57.31 209.07,55.88 209.07,55.35 209.18,55.25 209.18,54.71 209.28,54.61 211.18,54.61
0P8V_VCCL_SDM on BOTTOM: 148.77,46.69 149.03,46.43 149.03,46.13 149.32,45.83 149.82,45.83 150.02,45.63 150.02,43.23 149.82,43.03 148.49,43.03 146.57,41.1 146.57,37.42 146.31,37.16 143.77,37.16 143.52,37.42 143.52,46.43 143.77,46.69
0P8V_VCCL_SDM on L05_SIG2: 162.26,70.94 209.81,70.94 210.83,69.93 210.83,65.64 209.13,65.64 207.35,63.86 207.35,59.41 208.16,58.6 210.83,58.6 212.05,57.38 212.05,51.34 202.45,41.73 198.13,41.73 197.49,42.37 194.95,42.37 194.95,42.12 194.57,41.73 159.14,41.73 155.71,45.16 144.97,45.16 136.91,50.37 122.31,50.37 121.55,51.13 121.55,56.97 122.2,57.63 155.27,57.63 161.47,63.83 161.47,70.16 ; 4 cut-outs
0P9V_VCCH on TOP: 69.22,46.94 69.22,51.64 68.97,51.89 65.67,51.89 65.41,51.64 65.41,46.94 66.02,46.33 68.61,46.33
0P9V_VCCH on TOP: 83.7,71.83 78.62,71.83 78.49,71.71 78.49,69.93 78.75,69.67 83.7,69.67 83.83,69.8 83.83,71.71
0P9V_VCCH on TOP: 225.03,69.07 225.31,68.79 225.31,64.59 224.8,64.09 224.8,60.76 224.29,60.25 220.2,60.25 219.84,60.61 219.84,62.31 219.53,62.63 217.11,62.63 216.92,62.82 216.92,66.22 216.95,66.22 217.35,66.63 220.91,66.63 222.26,67.97 223.55,67.97 224.64,69.07
0P9V_VCCH on TOP: 225.05,76.02 225.05,79.83 226.02,80.8 226.02,83.06 226.47,83.52 229.88,83.52 230.26,83.9 230.26,89.49 229.75,89.99 216.97,89.99 216.54,89.56 216.54,87.71 216.92,87.33 218.96,87.33 219.51,86.77 219.51,81.54 221.01,80.04 221.01,79.45 220.99,79.45 220.23,78.69 220.23,78.31 219.97,78.06 218.19,78.06 217.94,77.8 217.94,77.04 218.12,76.86 218.6,76.86 218.83,76.63 218.83,75.82 219.01,75.64 224.67,75.64
0P9V_VCCH on BOTTOM: 125.81,55.37 126.07,55.5 126.93,55.02 127.11,54.92 127.13,54.77 127.39,54.33 126.93,54.08 126.76,53.99 125.61,54.71 125.56,54.94
0P9V_VCCH on BOTTOM: 146.52,51.86 146.52,49.36 146.22,49.06 143.63,49.06 143.33,49.36 143.33,51.56 143.63,51.86
0P9V_VCCH on BOTTOM: 79.51,68.79 79.51,71.96 79.76,72.21 81.8,72.21 82.05,71.96 82.05,68.79
0P9V_VCCH on BOTTOM: 87.76,85.8 92.34,85.8 92.59,86.06 92.59,87.58 92.08,88.09 92.08,90.76 87.76,90.76 87.51,90.5 87.51,86.06
0P9V_VCCH on BOTTOM: 146.82,60.4 145.3,60.4 145.17,60.28 144.15,60.28 144.15,63.45 144.28,63.58 147.71,63.58 147.96,63.83 147.96,68.4 147.71,68.66 143.52,68.66 142.63,69.55 138.95,69.55 138.69,69.29 138.69,56.85 138.95,56.59 142.88,56.59 143.77,57.48 146.57,57.48 146.82,57.74
0P9V_VCCH on BOTTOM: 150.82,46.23 149.52,46.23 149.36,46.39 149.36,48.47 149.61,48.72 150.5,48.72 150.82,48.4
0P9V_VCCH on BOTTOM: 216.92,89.99 229.75,89.99 230.13,89.61 230.13,83.9 229.62,83.39 226.96,83.39 226.19,83.39 225.94,83.14 225.94,79.45 225.81,79.33 225.43,79.33 225.31,79.2 225.31,77.17 225.43,77.04 227.46,77.04 228.1,76.41 228.1,65.74 227.72,65.36 225.76,65.36 225.18,64.77 225.18,62.69 224.77,62.28 224.77,60.58 224.34,60.15 221.42,60.15 221.19,60.38 221.19,61.72 220.35,62.56 220.35,64.82 219.95,65.23 218.19,65.23 217.89,65.53 217.89,66.14 218.12,66.37 221.62,66.37 222,66.75 222,67.62 222.05,67.67 223.17,67.67 223.78,68.28 223.78,71.76 223.91,71.76 224.04,71.88 224.04,74.35 224.05,74.36 224.04,74.37 224.04,75.52 223.53,76.02 218.96,76.02 218.83,76.15 218.83,76.66 218.57,76.91 218.07,76.91 217.94,77.04 217.94,77.8 218.19,78.06 219.97,78.06 220.23,78.31 220.23,78.72 220.25,78.72 220.99,79.45 220.99,80.06 219.49,81.56 219.49,86.29 218.62,87.15 216.92,87.15 216.54,87.53 216.54,89.61
0P9V_VCCH on L03_SIG1: 105.29,51.89 104.78,52.4 104.78,63.2 105.04,63.45 105.67,63.45 106.05,63.83 106.05,64.47 106.18,64.59 109.74,64.59 110.24,64.09 110.24,61.8 110.52,61.53 113.39,61.53 114.61,62.74 123.26,62.74 125.62,65.1 128.79,65.1 129.42,64.47 129.42,58.75 126.37,55.7 126.37,53.55 125.99,53.16 118.88,53.16 116.47,51.89
0P9V_VCCH on L03_SIG1: 216.75,89.51 216.75,87.56 217.05,87.25 218.52,87.25 219.95,85.83 219.95,81.44 221.52,79.86 224.62,79.86 225.76,81 225.76,82.93 226.17,83.34 228.91,83.34 229.37,83.8 229.37,89.36 228.68,90.05 217.28,90.05
0P9V_VCCH on L05_SIG2: 105.16,54.56 105.42,54.31 112.53,54.31 116.72,51.89 120.66,51.89 121.17,52.4 121.17,57.1 122.05,57.99 126.88,57.99 127.26,58.37 127.26,65.48 127.13,65.61 120.28,65.61 119.51,66.37 106.05,66.37 105.16,65.48
0P9V_VCCH on L05_SIG2, L07_SIG3: 216.75,89.51 216.75,87.56 217.05,87.25 218.52,87.25 219.95,85.83 219.95,81.18 221.01,80.11 224.87,80.11 225.76,81 225.76,82.93 226.17,83.34 228.91,83.34 229.37,83.8 229.37,89.36 228.68,90.05 217.28,90.05
0P9V_VCCH on L07_SIG3: 123.2,65.74 125.47,67.13 127.39,67.13 127.64,66.88 127.64,59.26 127.13,58.75 123.58,58.75 123.26,59.08 122.47,59.08 121.55,59.99 120.47,59.99 120.39,60.07 112.71,60.07 109.86,58.88 106.05,58.88 105.67,58.5 103.89,58.5 103.64,58.75 103.64,64.59 104.02,64.98 106.59,64.98 107.35,65.74
0P9V_VCCH on L10_PWR2: 110.4,70.03 122.79,70.03 131.71,78.95 206.64,78.95 206.64,95.84 225.94,95.84 225.94,68.28 229.12,68.28 229.12,63.58 239.28,63.58 239.28,66.75 245.5,66.75 245.5,56.3 245.28,56.08 245.28,55.51 245.5,55.29 245.5,47.07 129.67,47.07 122.98,53.76 110.33,53.76 108.49,51.92 108.49,36.02 104.43,31.96 58.68,31.96 58.68,80.34 71.51,80.34 80.91,89.74 90.69,89.74 ; 2 cut-outs
0P9V_VCCL_HPS on TOP: 76.72,78.31 76.72,69.55 76.28,69.12 74.48,69.12 74.3,69.29 74.3,71.07 73.02,72.35 73.02,78.31 73.03,78.31 73.54,78.82 76.21,78.82
0P9V_VCCL_HPS on TOP: 78.47,69.45 78.47,68.07 78.67,67.87 83.93,67.87 84.97,68.91 86.32,68.91 87.05,69.65 87.05,70.74 86.57,71.22 84.54,71.22 84.26,70.94 84.26,69.83 83.8,69.37 78.54,69.37
0P9V_VCCL_HPS on BOTTOM: 84.21,71.83 86.88,71.83 87.13,71.58 87.13,69.93 86.88,69.67 84.46,69.67 84.21,69.93
0P9V_VCCL_HPS on BOTTOM: 73.06,72.14 73.06,78.84 73.49,79.28 76.31,79.28 76.72,78.87 76.72,69.55 76.28,69.12 74.48,69.12 74.25,69.34 74.25,70.82 73.87,71.2 72.45,71.2 72.3,71.35 72.3,71.78 72.47,71.96 72.88,71.96
0P9V_VCCL_HPS on L14_SIG5: 104.27,73.48 110.88,73.48 111.26,73.1 111.26,67.85 110.19,66.78 79.76,66.78 76.94,63.96 65.54,63.96 65.16,64.34 65.16,73.99 69.73,78.56 96.53,78.56 98.43,76.66
0P9V_VCCRT_GXER1 on TOP: 70.49,46.69 70.24,46.94 70.24,52.1 70.75,52.61 77.68,52.61 79.26,54.18 81.54,54.18 82.05,53.67 82.05,48.72 81.8,48.47 78.98,48.47 77.6,47.09 73.82,47.09 73.41,46.69
0P9V_VCCRT_GXER1 on BOTTOM: 87,33.35 86.24,34.11 86.24,40.85 81.41,45.67 81.41,48.47 78.24,48.47 78.24,47.2 74.51,47.2 74,46.69 70.37,46.69 70.11,46.94 70.11,52 70.75,52.63 77.68,52.63 78.7,53.65 79.38,53.65 79.38,53.67 82.81,53.67 83.19,53.29 83.19,52.02 86.37,52.02 86.37,52.66 88.53,52.66 89.29,53.42 89.29,60.53 89.16,60.66 87.51,60.66 87.51,61.93 89.8,61.93 89.8,67.01 91.19,68.4 102.37,68.4 102.75,68.02 102.75,65.1 102.37,64.72 102.37,60.93 101.92,60.93 101.92,58.43 102.37,58.43 102.37,55.32 102.5,55.2 102.5,49.48 98.05,45.04 97.67,45.04 93.1,40.46 93.1,33.35
0P9V_VCCRT_GXER1 on L03_SIG1: 89.16,44.91 89.54,44.91 99.83,50.75 100.34,51.26 100.34,63.83 100.72,64.21 103.89,64.21 104.4,63.71 104.4,48.78 96.4,43.85 96.4,41.1 94.67,39.37 94.67,34.83 93.96,34.11 87.51,34.11 86.88,34.75 86.88,42.62
0P9V_VCCRT_GXER1 on L09_PWR1: 70.31,46.54 70.8,46.05 99.83,46.05 103.13,49.35 103.13,65.6 100.53,68.2 79.69,68.2 79,67.52 79,64.09 76.97,62.05 72.78,62.05 70.31,59.59
0P9V_VCCRT_GXER1 on L14_SIG5: 109.07,66.4 79.86,66.4 76.99,63.53 63.58,63.53 60.84,60.78 60.84,33.48 61.48,32.84 87.14,32.84 89.03,34.73 89.03,48.27 98.6,53.42 108.59,53.42 109.35,54.18 109.35,66.12
0P9V_VCCRT_GXPL1 on BOTTOM: 144.03,57.13 144.03,54.56 144.15,54.43 149.74,54.43 149.99,54.69 149.99,57.61 150.63,58.24 150.63,60.91 150.38,61.17 147.84,61.17 147.84,63.07 147.71,63.2 146.44,63.2 146.31,63.07 146.31,60.66 147.45,60.66 147.45,57.13
0P9V_VCCRT_GXPL1 on L07_SIG3: 150.38,56.97 150.38,56.91 147.94,54.47 141.45,54.47 139.45,56.47 128.79,56.47 128.15,57.1 128.15,68.53 128.53,68.91 141.1,68.91 141.87,68.15 151.9,68.15 152.28,67.77 152.28,57.99 151.9,57.61 151.01,57.61
1P1V_VCCH_GXER1 on TOP: 82.05,56.47 79.51,56.47 79.51,61.42 79.76,61.67 81.8,61.67 82.05,61.42
1P1V_VCCH_GXER1 on TOP: 46.29,54.84 46.29,54.38 46.67,54 50.98,54 51.49,54.51 51.98,54.51 52.89,53.6 56.04,53.6 56.62,54.18 56.62,54.33 56.8,54.51 57.13,54.51 57.23,54.41 57.23,53.11 56.47,52.35 46.13,52.35 45.04,53.44 45.04,54.84 45.24,55.04 46.08,55.04
1P1V_VCCH_GXER1 on BOTTOM: 82.56,56.59 81.54,56.59 81.54,57.61 79.76,57.61 79.51,57.86 79.51,61.42 82.3,61.42 82.56,61.17
1P1V_VCCH_GXER1 on BOTTOM: 49.23,59.74 57.82,59.74 58.27,59.29 58.27,57.38 58.05,57.15 56.85,57.15 56.62,57.38 56.62,58.37 56.34,58.65 52.61,58.65 52.43,58.47 52.43,57.41 51.49,56.47 51.01,56.47 50.71,56.77 46.64,56.77 46.18,56.31 46.18,54.33 46.51,54 47.68,54 47.94,53.75 47.94,52.25 47.68,52 45.09,52 44.36,52.73 44.36,56.9 45.57,58.12 45.57,58.8 46.5,59.73 49.22,59.73
1P1V_VCCH_GXER1 on L05_SIG2: 88,66.53 88.37,66.16 90.58,66.16 91.56,67.13 92.97,67.13 94.75,68.4 96.4,69.04 104.27,69.04 104.78,68.53 104.78,54.82 103.89,53.93 101.1,53.93 100.08,52.91 80.4,52.91 78.06,50.57 45.42,50.57 44.91,51.08 44.91,55.07 49.13,59.29 57.94,59.29 65.19,66.53 ; 1 cut-out
1P1V_VCCH_GXER1 on L07_SIG3: 62.14,59.11 62.14,59.36 61.48,60.02 43.7,60.02 42.81,59.13 42.81,56.92 46.95,52.78 56.22,52.78 58.55,55.12 61.14,55.12 62.16,56.14 62.16,59.08
1P2V_DDR4_CH01 on TOP: 200.11,82.96 201.23,82.96 201.48,82.71 201.48,79.89 201.84,79.53 202.39,79.53 204.48,81.61 204.78,81.61 204.99,81.41 204.99,79.78 205.32,79.45 206.13,79.45 208.29,81.61 208.67,81.61 208.8,81.49 208.8,79.96 209.3,79.45 209.94,79.45 212.1,81.61 212.55,81.61 212.71,81.46 212.71,78.79 211.97,78.06 211.97,75.9 211.78,75.71 210.64,75.71 210.45,75.9 210.45,77.68 210.07,78.06 204.48,78.06 204.1,77.68 204.1,76.28 203.59,75.77 200.79,75.77 199.3,77.27 199.3,79.71 199.73,80.14 199.73,82.58
1P2V_DDR4_CH01 on BOTTOM: 145.8,103.33 145.8,103.96 146.06,104.22 148.72,104.22 148.98,103.96 148.98,99.27 148.72,99.01 146.44,99.01 146.44,102.69
1P2V_DDR4_CH01 on BOTTOM: 148.6,96.98 148.85,96.73 148.85,92.15 148.6,91.9 146.06,91.9 145.8,92.15 145.8,96.73 146.06,96.98
1P2V_DDR4_CH01 on BOTTOM: 200.57,77.83 200.57,76.28 200.87,75.97 203.77,75.97 203.97,76.18 203.97,77.83 203.77,78.03 200.77,78.03
1P2V_DDR4_CH01 on BOTTOM: 210.83,77.5 210.83,76.43 211.13,76.13 211.87,76.13 212.2,76.46 212.2,77.52 211.89,77.83 211.16,77.83
1P2V_DDR4_CH01 on BOTTOM: 55.51,107.14 55.51,104.6 54.49,104.6 54.24,104.35 53.73,104.35 53.73,104.6 53.98,104.85 53.98,107.01 54.11,107.14
1P2V_DDR4_CH01 on L07_SIG3: 199.7,82.58 199.7,77.5 200.82,76.38 203.61,76.38 203.92,76.69 203.92,77.5 204.48,78.06 210.07,78.06 210.45,77.68 210.45,75.9 210.65,75.69 211.54,75.69 211.97,76.13 211.97,77.5 212.96,78.49 212.96,81.66 212.81,81.82 202.19,81.82 201.45,82.55 201.45,82.83 201.18,83.11 200.24,83.11
1P2V_DDR4_CH01 on L10_PWR2: 206.26,95.84 206.26,79.33 131.58,79.33 122.66,70.41 110.52,70.41 90.81,90.12 80.78,90.12 78.11,87.45 78.11,87.46 71.38,80.72 56.78,80.72 56.78,91.9 50.81,91.9 50.81,109.81 65.41,109.81 65.41,99.77 70.37,99.77 70.37,102.06 111.01,102.06 113.55,104.6 146.06,104.6 149.87,100.79 192.29,100.79 197.24,95.84
1P2V_DDR4_CH23 on TOP: 198.38,39.7 198.89,40.21 199.4,40.21 199.78,39.83 199.78,37.16 200.03,36.91 200.79,36.91 202.83,38.94 203.59,38.94 203.72,38.81 203.72,37.16 203.97,36.91 204.6,36.91 206.76,39.07 207.14,39.07 207.4,38.81 207.4,37.09 207.78,36.71 208.34,36.71 210.45,38.81 210.83,38.81 211.23,38.41 211.23,36.88 213.01,35.11 213.01,33.4 212.52,32.91 210.13,32.91 209.68,33.35 209.68,35.26 209.56,35.38 203.59,35.38 203.33,35.13 203.33,33.35 202.95,32.97 200.16,32.97 197.87,35.26 197.87,36.93 198.38,37.44
1P2V_DDR4_CH23 on BOTTOM: 123.06,36.63 119.96,36.63 119.76,36.43 119.76,34.23 119.96,34.03 123.06,34.03
1P2V_DDR4_CH23 on BOTTOM: 203.64,17.27 203.64,19.81 204.66,19.81 204.91,20.06 205.42,20.06 205.42,19.81 205.17,19.55 205.17,17.52 204.91,17.27
1P2V_DDR4_CH23 on BOTTOM: 134.12,27.64 134.75,28.27 134.75,29.29 135.01,29.54 142.63,29.54 143.9,30.81 146.82,30.81 146.82,18.11 131.45,18.11 131.2,18.37 131.2,27.38 131.45,27.64
1P2V_DDR4_CH23 on L10_PWR2: 123.83,16.97 58.68,16.97 58.68,31.57 104.71,31.57 108.87,35.74 108.87,51.67 110.59,53.38 122.85,53.38 129.55,46.69 245.5,46.69 245.5,27.13 222.13,27.13 222.13,22.43 129.29,22.43
1P2V_DDR4_CH23 on L16_SIG6: 197.24,43.77 197.24,19.79 198.13,18.9 198.13,18.87 201.3,15.7 208.16,15.7 208.8,16.33 208.8,23.32 209.43,23.95 209.43,32.21 210.07,32.84 217.05,32.84 217.69,33.48 217.69,44.78 217.05,45.42 198.89,45.42
1P2V_PRE on BOTTOM: 26.35,20.02 26.35,21.14 26.19,21.3 24.91,21.3 24.75,21.14 24.75,20.18 24.91,20.02
1P2V_PRE on BOTTOM: 17.74,39.94 19.39,39.94 19.65,39.69 20.53,39.69 20.55,39.67 22.23,39.67 22.23,37.67 21.98,37.42 19.82,37.42 19.57,37.67 19.57,38.18 19.18,38.56 17.79,38.56 17.61,38.73 17.61,39.81
1P2V_PRE on L10_PWR2: 17.66,44.15 27.31,44.15 27.31,37.04 29.6,37.04 29.6,16.33 22.36,16.33 22.36,32.84 17.66,32.84
1P2V_UBII on BOTTOM: 26.43,19.3 26.43,17.38 24.91,17.38 24.75,17.54 24.75,19.22 24.91,19.38 26.35,19.38
1P2V_UBII on L14_SIG5: 30.36,18.37 30.36,17.22 30.11,16.97 25.41,16.97 25.15,17.22 25.15,20.78 25.41,21.03 30.74,21.03 31,20.78 31,19
1P2V_VCCR on TOP: 72.88,58.24 73.34,57.79 73.95,57.79 74.25,57.48 74.25,55.55 74.48,55.32 76.26,55.32 76.92,55.98 76.92,62.46 76.69,62.69 75.9,62.69 75.19,63.4 75.19,64.7 74.94,64.95 73.74,64.95 73.45,64.66 73.45,62.87 73.44,62.86 73.44,62.82 72.88,62.26
1P2V_VCCR on TOP: 84.59,55.2 84.59,54.23 84.69,54.13 85.99,54.13 86.11,54.26 86.11,55.12 85.94,55.3 84.69,55.3
1P2V_VCCR on BOTTOM: 84.21,67.64 84.21,69.17 87.51,69.17 87.51,70.44 87.64,70.56 88.91,70.56 88.91,69.29 88.53,68.91 88.53,68.15 87.13,68.15 86.62,67.64
1P2V_VCCR on BOTTOM: 73.03,58.32 73.03,65.03 73.46,65.46 76.28,65.46 76.69,65.05 76.69,55.73 76.26,55.3 74.45,55.3 74.23,55.53 74.23,57 73.84,57.38 72.42,57.38 72.27,57.53 72.27,57.97 72.45,58.14 72.85,58.14
1P2V_VCCR on BOTTOM: 87.13,60.4 87.13,58.75 84.21,58.75 84.21,60.4
1P2V_VCCR on L12_SIG4: 122.05,53.55 121.42,52.91 73.67,52.91 72.65,53.93 72.65,61.06 81.82,70.23 89.03,70.23 91.78,67.49 107.97,67.49 109.04,68.56 109.04,72.02 110.88,73.87 120.15,73.87 122.5,71.52 122.5,69.48 124.34,67.64 124.34,53.93 123.96,53.55
1P8V on TOP: 222.77,48.59 227.21,48.59 227.34,48.47 227.34,47.7 228.35,46.69 232.16,46.69 232.93,47.45 232.93,48.08 233.31,48.47 238.34,48.47 239.68,47.12 242.88,47.12 243.34,46.66 243.34,44.48 242.55,43.69 237.62,43.69 235.77,45.54 221.19,45.54 219.34,43.69 215.98,43.69 213.8,45.88 213.8,48.06 214.31,48.57 222.74,48.57
1P8V on TOP: 150.64,79.83 148.63,79.83 148.43,79.63 148.43,75.31 148.6,75.14 150.76,75.14 151.01,75.39 151.01,79.45
1P8V on TOP: 146.4,83.23 146.69,83.52 146.69,87.07 145.68,88.09 145.68,88.97 145.42,89.23 142.46,89.23 142.26,89.03 142.26,83.43 142.46,83.23
1P8V on BOTTOM: 114.05,68.79 114.05,67.39 114.18,67.26 120.15,67.26 120.28,67.39 120.28,68.79
1P8V on BOTTOM: 141.49,90.76 141.49,84.15 142.42,83.21 144.71,83.21 144.84,83.34 144.84,90.33 144.41,90.76
1P8V on BOTTOM: 128.89,49.48 128.66,49.71 128.66,50.5 128.79,50.62 129.67,50.62 130.08,51.03 130.08,51.39 130.23,51.67 130.23,53.16 129.27,53.8 129.58,54.37 129.75,54.49 131.34,56.07 131.34,57.47 132.62,58.75 132.62,79.86 135.39,82.63 135.39,84.03 137.8,84.03 137.8,80.34 135.36,77.9 135.36,56.19 133.99,54.82 131.33,54.82 131.2,54.69 131.2,53.29 130.94,53.04 130.94,50.24 130.18,49.48
1P8V on BOTTOM: 228.23,46.69 232.67,46.69 233.18,47.2 233.18,48.03 233.36,48.21 237.9,48.21 238.79,47.32 242.17,47.32 243.16,46.33 243.16,43.64 242.7,43.18 237.19,43.18 236.53,43.84 236.53,44.68 236.18,45.04 224.04,45.04 222.51,46.56 222.51,47.83 223.15,48.47 227.06,48.47 227.34,48.19 227.34,47.58
1P8V on BOTTOM: 113.8,56.59 113.8,55.07 120.28,55.07 120.28,56.47 120.02,56.72 115.32,56.72 113.94,56.73
1P8V on L07_SIG3: 233.38,58.52 237.04,58.52 237.85,57.71 237.85,47.88 237.52,47.55 230.89,47.55 229.85,48.59 229.85,54.99 ; 1 cut-out
1P8V on L07_SIG3: 236.81,45.27 236.81,39.78 238.56,38.03 253.68,38.03 257.72,33.99 261.14,33.99 262.36,35.21 262.36,43 259.42,45.95 237.5,45.95
1P8V on L14_SIG5: 148.22,88.98 142.25,88.98 138.18,84.91 136.91,84.91 135.39,83.39 135.39,82.63 130.82,78.06 130.82,75.64 129.93,74.75 124.72,71.58 124.47,71.45 122.56,71.45 122.05,72.09 113.67,72.09 113.42,71.83 113.42,55.7 114.43,54.69 122.05,54.69 122.82,55.45 124.21,55.45 130.06,51.26 132.21,51.26 136.15,53.16 138.56,55.58 144.11,58.93 156.73,58.93 157.44,59.64 163.08,59.64 167.65,55.07 171.33,55.07 179.59,46.81 192.29,46.81 198.64,40.46 206.89,40.46 210.57,36.78 217.15,36.78 224.39,44.02 225.46,44.02 227.31,45.88 227.31,49.25 224.75,51.82 224.75,56.92 224.39,57.28 223.07,57.28 222.66,57.69 217.58,57.69 215.68,59.59 209.4,59.59 208.69,60.3 208.69,67.11 199.02,76.79 151.39,76.79 150.88,77.29 150.88,86.31
1P8V_AGND on TOP: 230.89,56.01 233.48,56.01 233.71,55.78 233.71,53.01 234.07,52.66 234.83,52.66 235.08,52.91 235.59,52.91 235.72,52.78 235.72,52.28 235.47,52.02 235.47,51.41 235.21,51.16 235.21,50.55 234.86,50.19 233.41,50.19 232.8,49.58 232.8,49.28 232.44,48.92 228.05,48.92 227.59,49.38 227.59,49.86 226.58,50.88 226.58,51.77 227.21,52.4 227.95,52.4 228.99,53.44 228.99,54.41 229.57,54.99 229.88,54.99 ; 1 cut-out
1P8V_AGND on L12_SIG4: 229.24,54.61 229.24,52.89 229.39,52.73 231.25,52.73 231.25,54.61 231.05,54.82 229.45,54.82
1P8V_PRE on BOTTOM: 26,39.94 27.65,39.94 27.9,39.69 28.79,39.69 28.81,39.67 30.49,39.67 30.49,37.67 30.23,37.42 28.07,37.42 27.82,37.67 27.82,38.18 27.44,38.56 26.04,38.56 25.87,38.73 25.87,39.81
1P8V_PRE on L10_PWR2: 27.69,44.15 39,44.15 39,16.33 29.98,16.33 29.98,37.42 27.69,37.42
1P8V_SI52202 on BOTTOM: 209.3,103.71 209.43,103.58 209.43,102.31 209.3,102.19 207.65,102.19 207.4,102.44 207.4,103.58 207.53,103.71
1P8V_SI52202 on L05_SIG2: 209.05,103.96 209.05,105.69 209.48,106.12 209.91,106.12 211.18,104.85 212.73,104.85 213.24,104.35 213.24,102.19 211.97,100.92 209.81,100.92 208.29,102.44 208.29,103.2
1P8V_UBII on BOTTOM: 30.75,17.22 30.75,18.18 30.91,18.34 32.59,18.34 32.75,18.18 32.75,17.06 30.91,17.06
1P8V_UBII on L14_SIG5: 31,16.97 30.74,17.22 30.74,18.24 31.38,18.87 31.38,20.78 31.63,21.03 34.3,21.03 34.55,20.78 34.55,17.22 34.3,16.97
2P5V on TOP: 210.78,66.47 211.94,66.47 212.33,66.09 212.33,65.41 213.06,65.41 213.09,65.43 213.09,66.63 211.23,68.48 209.15,68.48 208.34,69.29 206.92,69.29 206.89,69.32 206.74,69.17 206.74,65.38 207.14,64.98 209.28,64.98
2P5V on BOTTOM: 99.58,102.19 101.1,102.19 101.1,100.28 105.67,100.28 105.67,107.52 106.18,108.03 185.05,108.03 185.81,107.27 185.81,100.92 185.55,100.66 183.01,100.66 182.76,100.92 182.76,103.58 182.51,103.84 151.9,103.84 151.14,104.6 145.55,104.6 144.53,105.62 130.56,105.62 129.42,104.47 121.29,104.47 120.15,105.62 114.05,105.62 113.8,105.36 113.8,104.09 113.55,103.84 108.97,103.84 108.72,103.58 108.72,98.63 108.21,98.12 99.83,98.12 99.58,98.38
2P5V on BOTTOM: 47.51,20.78 46.36,20.78 46.24,20.65 46.24,20.14 46.49,19.89 47.25,19.89 47.51,20.14
2P5V on BOTTOM: 103.41,65.28 103.41,64.8 103.97,64.34 104.17,64.01 104.71,64.29 104.71,65.03 104.96,65.47 104.81,65.56 104.54,65.71 104.18,65.71 103.94,65.28
2P5V on BOTTOM: 151.26,20.91 152.66,20.91 152.66,23.32 151.52,23.32 151.26,23.07
2P5V on BOTTOM: 206.97,64.85 207.93,64.85 209.1,66.02 212.48,66.02 212.91,66.45 212.91,67.13 212.54,67.5 212.29,67.5 211.13,68.66 209.53,68.66 208.92,69.27 206.89,69.27 206.56,68.94 206.56,65.26
2P5V on L05_SIG2: 124.54,105.67 132.39,105.67 133.23,106.5 133.23,108.92 132.6,109.55 130.89,109.55 130.13,110.31 126.88,110.31 126.12,109.55 124.34,109.55 123.71,108.92 123.71,106.5
2P5V on L07_SIG3: 46.24,20.14 46.24,26.37 46.62,26.75 55.13,26.75 60.59,32.21 70.37,32.21 70.75,31.83 70.75,20.14 70.37,19.76 46.62,19.76
2P5V on L07_SIG3: 193.91,105.39 193.91,92.92 193.28,92.28 189.24,92.28 188.86,92.66 188.86,99.14 188.48,99.52 182.51,99.52 182.13,99.9 182.13,105.49 182.51,105.87 193.43,105.87
2P5V on L12_SIG4: 65.29,8.97 64.65,9.6 64.65,30.94 65.29,31.57 73.92,31.57 74.94,30.56 74.94,21.16 75.95,20.14 91.32,20.14 96.78,25.61 115.7,25.61 116.09,25.99 116.97,25.99 117.61,25.35 146.82,25.35 147.71,24.46 152.66,24.46 154.06,25.86 165.49,25.86 166.63,24.72 171.2,24.72 172.35,25.86 184.16,25.86 185.3,24.72 190.13,24.72 212.1,46.69 212.1,65.94 211.64,66.4 209.95,66.4 209.11,67.24 209.11,69.94 205.06,73.99 197.75,73.99 195.33,76.41 185.3,76.41 181.49,80.22 181.49,98.88 183.4,100.79 192.29,100.79 192.92,100.15 192.92,95.41 197.29,91.04 222.94,91.04 225.05,88.93 225.05,36.91 220.99,32.84 220.58,32.84 215.15,27.41 215.15,27.38 201.81,14.05 136.53,14.05 133.61,11.13 128.28,11.13 126.12,8.97 ; 8 cut-outs
2P5V on L14_SIG5: 65.67,30.05 65.67,20.14 66.3,19.51 74.68,19.51 75.32,20.14 75.32,30.18 74.81,30.69 66.3,30.69
2P5V_AGND on BOTTOM: 213.09,70.82 213.09,65.05 213.65,64.49 215.35,64.49 216.14,65.28 216.14,70.59 215.6,71.12 213.39,71.12
3P3V on BOTTOM (solid shape): 39.43,70.42 36.03,70.42 36.03,72.52 39.43,72.52
3P3V on TOP: 64.68,70.28 71.25,70.28 71.69,69.85 71.69,69.37 71.89,69.17 73.69,69.17 73.92,69.4 73.92,71.07 73.51,71.48 72.88,71.48 72.65,71.71 72.65,72.52 72.47,72.7 71.89,72.7 71.66,72.47 71.66,71.73 71.43,71.5 65.16,71.5 65.01,71.35 62.14,71.35 61.14,70.36 61.14,65.18 62.36,63.96 62.36,62.82 62.75,62.44 64.02,62.44 64.27,62.69 64.27,65.74 63.63,66.37 62.87,66.37 62.24,67.01 62.24,68.53 62.87,69.17 63.56,69.17
3P3V on TOP: 247.83,67.64 247.83,66.53 246.97,65.66 246.59,65.66 246.41,65.48 246.41,65.15 246.64,64.93 249.28,64.93 249.38,65.03 249.38,67.41 248.95,67.85 248.04,67.85
3P3V on TOP: 62.95,55.32 63.51,55.32 64.65,56.47 71.23,56.47 71.66,56.04 71.66,55.55 71.94,55.27 73.74,55.27 74.02,55.55 74.02,57.25 73.62,57.66 73.06,57.66 72.63,58.09 72.63,58.7 72.45,58.88 71.86,58.88 71.64,58.65 71.64,57.91 71.41,57.69 65.13,57.69 64.98,57.53 62.95,57.53 62.57,57.91 60.97,57.91 60.78,57.72 60.78,56.63 61.07,56.34 61.93,56.34
3P3V on TOP: 203.99,32.77 203.99,32.29 204.32,31.96 206.74,31.96 206.94,32.16 206.94,32.64 206.69,32.9 204.12,32.9
3P3V on TOP: 230.44,38.74 229.78,39.4 228.86,39.4 228.71,39.25 226.98,39.25 226.68,39.55 226.68,39.91 226.19,40.39 224.57,40.39 224.21,40.74 224.21,42.09 223.5,42.8 220.63,42.8 220.33,43.11 220.33,44.02 221.52,45.21 225.56,45.21 226.22,44.55 236.33,44.55 237.34,43.54 242.75,43.54 243.31,44.1 244.63,44.1 245.07,43.67 245.07,38.03 243.9,36.86 237.4,36.86 235.52,38.74
3P3V on BOTTOM: 220.4,73.54 219.44,73.54 218.88,74.09 218.88,74.63 218.8,74.7 218.14,74.7 217.94,74.91 217.94,75.75 217.76,75.92 217.76,76.53 217.58,76.71 217.05,76.71 216.69,76.36 216.69,73.54 217.3,72.93 220.43,72.93 220.58,73.08 220.58,73.36
3P3V on BOTTOM: 210.17,16.79 210.63,17.25 210.63,19.3 209.87,19.3 209.61,19.55 208.85,19.55 208.72,19.43 208.72,17.77 208.77,17.73 208.77,16.79 ; 1 cut-out
3P3V on BOTTOM: 66.15,56.62 66.15,57.43 66,57.58 64.52,57.58 64.4,57.46 63.08,57.46 62.52,58.02 60.87,58.02 60.56,57.71 60.56,51.16 60.79,50.93 62.14,50.93 62.41,51.21 62.41,54.46 64.42,56.47 66,56.47
3P3V on BOTTOM: 216.67,20.98 216.67,19.79 217.1,19.36 218.04,19.36 218.19,19.51 218.19,20.91 217.89,21.21 216.9,21.21
3P3V on BOTTOM: 36.46,70.44 36.08,70.82 36.08,72.72 35.82,72.98 33.54,72.98 33.15,72.6 33.15,71.71 32.9,71.71 32.9,74.25 33.15,74.5 41.79,74.5 42.04,74.25 42.04,70.82 41.66,70.44
3P3V on BOTTOM: 196.88,57.03 197.85,56.06 198.51,56.06 198.74,55.83 198.74,54.79 198.64,54.69 195.54,54.69 195.23,54.99 195.23,57.08 195.49,57.33 195.49,58.75 195.66,58.93 196.68,58.93 196.88,58.73
3P3V on BOTTOM: 74.68,36.5 74.68,38.69 73.67,39.7 72.47,39.7 72.04,39.27 72.04,37.26 73.21,36.1 74.28,36.1
3P3V on BOTTOM: 49.28,105.23 49.66,104.85 50.3,104.85 50.43,104.98 50.43,106.63 50.3,106.76 50.3,107.65 50.05,107.9 47.76,107.9 47.51,107.65 47.51,106 48.14,106 48.39,105.74 48.39,105.49 48.65,105.23
3P3V on BOTTOM: 228.61,50.35 228.43,50.17 228.2,50.17 228.07,50.04 228.07,49.63 228.18,49.53 228.58,49.53 228.71,49.41 229.27,49.41 229.37,49.51 229.75,49.51 229.83,49.43 230.28,49.43 230.66,49.81 230.66,49.89 230.33,50.22 230.21,50.22 229.93,49.94 229.78,49.94 229.29,50.42 229.29,52.17 229.34,52.23 229.34,52.66 229.27,52.73 228.78,52.73 228.61,52.56
3P3V on BOTTOM: 66.17,70.44 66.17,71.25 65.72,71.71 64.9,71.71 64.6,71.4 64.55,71.4 64.42,71.28 62.01,71.28 60.97,70.23 60.97,65.43 62.39,64.01 62.39,62.79 62.77,62.41 64.04,62.41 64.32,62.69 64.32,65.74 63.46,66.6 62.72,66.6 62.44,66.88 62.44,68.28 64.45,70.28 66.02,70.28
3P3V on L05_SIG2: 195.08,20.4 199.14,16.33 210.95,16.33 212.99,18.37 217.56,18.37 217.81,18.62 217.81,23.45 217.3,23.95 211.34,23.95 203.72,31.57 203.72,35.82 202.65,36.88 193.35,36.88 192.03,35.56 192.03,29.16 195.08,26.11
3P3V on L07_SIG3: 70.49,57.89 70.49,56.72 70.8,56.42 71.53,56.42 71.76,56.19 71.76,55.63 72.04,55.35 73.77,55.35 73.9,55.48 73.9,57.38 73.62,57.66 73.03,57.66 72.73,57.97 72.73,58.83 72.5,59.06 71.84,59.06 71.66,58.88 71.66,58.04 70.64,58.04
3P3V on L07_SIG3: 232.29,86.64 237.78,86.64 238.77,85.65 238.77,83.72 237.8,82.76 233.79,82.76 231.76,80.72 231.76,76.2 240.27,67.69 249.54,67.69 251.72,65.51 251.72,62.64 250.76,61.67 241.05,61.67 241.04,61.69 240.95,61.6 233.43,61.6 228,67.03 228,81.28 230.11,83.39 230.11,84.46
3P3V on L09_PWR1: 55.13,25.86 47.76,25.86 47.76,55.96 57.03,55.96 57.03,76.79 43.06,76.79 43.06,68.4 14.99,68.4 14.99,97.61 29.73,97.61 35.19,103.08 44.58,103.08 47.38,105.87 47.38,109.88 65.41,109.88 65.41,99.77 70.37,99.77 70.37,102.06 111.01,102.06 113.55,104.6 146.06,104.6 149.87,100.79 192.29,100.79 197.24,95.84 225.94,95.84 225.94,68.28 229.12,68.28 229.12,63.58 237.52,63.58 237.95,64.01 237.95,68.81 238.26,69.12 245.17,69.12 245.63,68.66 245.63,52.53 246.67,52.53 246.69,52.5 247.43,52.5 247.86,52.07 247.86,49.3 247.33,48.77 245.63,48.77 245.63,27.13 222.13,27.13 222.13,22.43 129.29,22.43 123.83,16.97 55.13,16.97 ; 2 cut-outs
3P3V on L16_SIG6: 217.76,32.97 217.76,37.11 219.01,38.36 219.01,43.36 220.45,44.81 229.01,44.81 229.75,44.07 235.13,44.07 235.44,44.38 244.36,44.38 245.07,43.67 245.07,38.03 244.81,37.77 243.62,37.77 243.31,38.08 241.51,38.08 241.43,38 241.43,36.48 242.25,35.66 244.43,35.66 245.7,34.39 245.7,31.32 241.15,26.77 239.68,26.77 239.02,27.43 239.02,30.56 238.06,31.52 236.48,31.52 235.9,32.11 225.71,32.11 224.72,31.12 224.72,21.01 222.82,19.1 213.95,19.1 211.54,21.52 211.54,29.62 213.9,31.98 216.77,31.98
3P3V_AGND on TOP: 227.79,18.11 227.79,16.94 228.35,16.39 233.38,16.39 233.61,16.61 233.61,18.47 233.15,18.93 233.15,19.43 233.05,19.54 232.65,19.54 232.52,19.41 232.52,18.39 231.81,17.68 231.38,17.68 231.25,17.81 231.25,19.33 231.12,19.46 230.56,19.46 230.46,19.36 230.46,17.83 230.31,17.68 229.6,17.68 229.01,18.27 227.95,18.27
3P3V_AGND on L12_SIG4: 228.1,19.18 228.1,17.63 228.28,17.45 234.17,17.45 234.27,17.55 234.27,19.46 234.14,19.59 228.51,19.59
3P3V_LDO3 on BOTTOM: 17.61,42.23 17.61,43.39 17.53,43.47 17.53,46.18 17.79,46.43 20.33,46.43 20.33,44.66 20.71,44.27 20.71,43.37 19.65,43.37 18.5,42.23
3P3V_STBY on TOP: 254.39,41.99 254.39,40.59 254.52,40.46 254.52,37.67 257.44,37.67 257.69,37.92 257.69,40.21 255.79,42.12 254.52,42.12
3P3V_STBY on TOP: 7.3,19.18 8.62,19.18 8.9,18.9 8.9,17.6 9.61,16.89 14.33,16.89 14.61,17.17 14.61,18.09 14.92,18.39 18.3,18.39 18.37,18.32 36.28,18.32 36.81,17.78 36.81,15.06 36.35,14.61 22.11,14.61 21.95,14.76 21.95,16.72 21.14,17.53 18.68,17.53 17.99,16.84 17.99,15.32 17.53,14.86 7.68,14.86 6.87,15.67 6.87,18.75
3P3V_STBY on BOTTOM: 22.61,30.94 24.9,30.94 25.15,30.69 25.15,28.91 22.61,28.91
3P3V_STBY on BOTTOM: 254.77,41.1 254.77,37.92 255.02,37.67 256.8,37.67 257.06,37.92 257.06,41.1 256.8,41.35 255.02,41.35
3P3V_STBY on L14_SIG5: 273.06,110.06 273.06,14.05 245.37,14.05 245.37,37.42 254.52,37.42 254.52,67.13 255.79,67.13 255.79,92.79 228.66,92.79 226.27,95.18 216.39,95.18 215.91,94.69 202.06,94.69 199.14,91.77 159.65,91.77 158.5,92.92 137.8,92.92 130.31,100.41 117.23,100.41 114.94,98.12 72.27,98.12 71.64,97.49 71.64,91.26 72.27,90.63 74.81,90.63 75.45,89.99 75.45,82.37 74.81,81.74 55.76,81.74 55.13,82.37 55.13,96.34 54.49,96.98 22.49,96.98 22.11,96.6 22.11,43.39 32.9,43.39 32.9,48.72 40.77,48.72 40.77,14.05 1.28,14.05 1.28,110.06 ; 4 cut-outs
3P3V_USBPHY on TOP: 7.88,21.54 10.17,21.54 10.42,21.29 10.42,19.64 7.63,19.64 7.63,21.29
3P3V_USBPHY on L09_PWR1: 21.72,31.57 1.28,31.57 1.28,14.18 21.72,14.18
ENET_1.2V_AVDDL on TOP: 27.49,89.11 29.34,89.11 29.47,89.23 29.47,90.5 29.34,90.63 25.79,90.63 25.79,89.61 26.68,89.61 26.68,88.8 27.19,88.8
ENET_1.2V_AVDLL_PLL on BOTTOM: 18.17,81.1 15.88,81.1 15.88,82.25 16.14,82.5 17.91,82.5 18.17,82.25
ENET_1.2V_AVDLL_PLL on L07_SIG3: 15.12,81.23 15.12,98.38 26.17,98.38 26.17,86.57 18.04,86.57 18.04,81.23
ENET_1.2V_DVDDL on BOTTOM: 37.85,83.01 39.89,83.01 40.01,83.14 40.01,84.28 39.89,84.41 37.85,84.41 37.73,84.28 37.73,83.14
ENET_1.2V_DVDDL on L14_SIG5: 25.28,89.11 25.28,77.93 38.36,77.93 38.36,82.88 40.27,82.88 40.27,89.11
ENET_1.8V_DVDDH on BOTTOM: 17.53,77.29 17.53,79.07 17.28,79.33 15.25,79.33 14.99,79.07 14.99,77.29
ENET_1.8V_DVDDH on L07_SIG3: 37.98,80.85 35.19,80.85 35.19,86.57 37.35,86.57 37.35,91.65 26.55,91.65 26.55,86.18 18.42,86.18 18.42,80.85 15.12,80.85 15.12,75.52 37.98,75.52
ENET_3.3V_AVDDH on BOTTOM: 36.96,83.01 34.81,83.01 34.68,83.14 34.68,84.28 34.81,84.41 36.84,84.41 36.96,84.28
ENET_3.3V_AVDDH on L03_SIG1: 36.71,88.09 32.52,92.28 30.11,92.28 28.46,90.63 26.3,90.63 25.28,89.61 25.28,86.18 30.36,81.1 35.31,81.1 36.71,82.5
ENET_VDD1.2V on TOP: 23.38,90.76 23.63,91.01 25.03,91.01 25.28,90.76 25.28,89.64 25.25,89.61 23.63,89.61 23.38,89.87
ENET_VDD1.2V on BOTTOM: 52.2,94.44 52.2,92.53 52.08,92.41 52.08,91.26 49.28,91.26 49.03,91.52 49.03,93.68 50.55,93.68 50.68,93.8 50.68,94.19 50.93,94.44 ; 2 cut-outs
ENET_VDD1.2V on L12_SIG4: 25.92,90.76 26.55,90.12 26.55,81.74 23.38,78.56 14.36,78.56 13.85,79.07 13.85,87.45 17.15,90.76
ENET_VDD1.2V on L14_SIG5: 54.49,96.22 54.49,72.21 22.49,72.21 22.49,96.22 22.87,96.6 54.11,96.6 ; 1 cut-out
FPGA_VCC on TOP: 84.46,74.5 84.46,75.52 84.34,75.64 80.4,75.64 80.4,74.63 80.53,74.5
FPGA_VCC on TOP: 156.73,37.29 155.58,38.43 155.58,47.7 155.2,48.08 146.31,48.08 145.93,47.7 145.93,40.08 145.42,39.58 140.47,39.58 138.82,37.92 113.55,37.92 112.78,37.16 97.92,37.16 97.8,37.04 95.77,37.04 95.77,38.56 95.51,38.81 89.03,38.81 87.38,40.46 87.38,85.42 87.51,85.55 99.07,85.55 99.07,87.67 112.15,87.67 112.15,85.55 119.51,85.55 119.51,86.95 120.91,86.95 120.91,85.8 132.98,85.8 134.5,87.33 134.5,87.58 138.44,87.58 138.44,85.04 143.77,79.71 143.77,76.15 144.28,75.64 147.45,75.64 148.34,74.75 150.88,74.75 152.03,75.9 152.03,78.69 152.41,79.07 154.95,79.07 155.58,79.71 157.23,79.71 158,80.47 158,86.31 158.25,86.57 169.04,86.57 169.93,87.45 176.33,87.45 176.92,86.87 176.92,79.89 175.27,78.23 175.27,74.32 177.02,72.57 177.02,66.35 175.27,64.59 175.27,59.9 176.89,58.27 176.89,51.29 175.27,49.66 175.27,44.35 176.85,42.76 176.85,35.91 174.61,33.66 166.5,33.66 165.87,34.29 165.87,36.63 165.21,37.29 ; 1 cut-out
FPGA_VCC on BOTTOM: 112.56,36.33 110.36,36.33 109.76,36.93 104.27,36.93 104.15,37.05 104.15,38.56 104.27,38.69 112.4,38.69 112.56,38.53
FPGA_VCC on BOTTOM: 99.26,87.73 108.66,87.73 108.96,87.43 108.96,85.43 99.36,85.43 99.16,85.63 99.16,87.63
FPGA_VCC on BOTTOM: 103,36.93 97.52,36.93 97.29,37.16 97.29,38.43 97.54,38.69 103,38.69 103.13,38.56 103.13,37.05
FPGA_VCC on BOTTOM: 158.63,85.55 159.01,85.93 166.91,85.93 167.29,86.31 167.29,87.23 167.95,87.89 174.76,87.89 175.14,87.51 175.14,36.02 174.89,35.77 159.42,35.77 158.63,36.55
FPGA_VCC on BOTTOM: 120.78,68.02 120.78,55.83 121.04,55.58 122.69,55.58 122.94,55.83 122.94,68.02 122.69,68.28 121.04,68.28
FPGA_VCC on BOTTOM: 111.39,67.13 111.39,56.72 108.72,56.72 108.59,56.85 108.59,67.01 108.72,67.13
FPGA_VCC on L03_SIG1: 168.51,70.46 168.51,37.87 169.25,37.14 174.1,37.14 174.86,37.9 174.86,70.61 174.43,71.05 169.09,71.05
FPGA_VCC on L07_SIG3: 174.43,70.89 168.03,70.89 167.27,70.13 167.27,57.56 168.89,55.93 174.78,55.93 175.5,56.64 175.5,69.83
FPGA_VCC on L09_PWR1: 80.68,87.63 80.68,35.31 175.42,35.31 175.42,87.63 ; 1 cut-out
FPGA_VCC on L16_SIG6: 160.33,49.94 166.94,43.34 166.94,35.51 168.92,33.53 174.12,33.53 175.8,35.21 175.8,69.85 173.9,71.76 170.29,71.76 170.29,71.78 169.64,72.43 169.64,73.54 170.07,73.97 174.89,73.97 175.42,74.5 175.42,84.18 174.23,85.37 166.3,85.37 160.33,79.4
FT232R_3V3OUT on BOTTOM: 22.36,72.85 22.36,73.99 22.49,74.12 23.76,74.12 23.88,74.25 23.88,75.14 25.79,75.14 25.79,72.98 22.74,72.98 22.61,72.85
FT232R_VCCIO on BOTTOM: 26.3,74.63 26.42,74.75 28.58,74.75 28.58,72.47 26.42,72.47 26.3,72.6
FT232R_VCCIO on BOTTOM: 16.52,66.37 16.52,68.91 16.77,69.17 18.55,69.17 18.55,66.25 16.64,66.25
FT232R_VCCIO on L10_PWR2: 24.52,65.74 11.56,65.74 11.56,102.19 18.3,102.19 18.3,99.65 16.01,99.65 16.01,75.01 28.46,75.01 28.46,68.4 24.52,68.4
IIN-_1 on TOP: 239.53,72.06 239.53,74.81 238.94,75.39 233.56,75.39 232.42,74.25 228.48,74.25 228.1,73.87 228.1,69.93 228.48,69.55 232.42,69.55 232.93,69.04 232.93,64.47 232.24,63.78 231.07,63.78 230.89,63.6 230.89,62.44 231.15,62.18 237.42,62.18 237.78,61.83 238.21,61.83 238.49,62.11 238.49,62.46 238.18,62.77 237.75,62.77 237.5,63.02 237.5,70.97 237.93,71.4 238.87,71.4
IIN-_1 on BOTTOM: 234.35,76.63 234.96,76.02 239.53,76.02 239.53,71.83 239.4,71.83 239.02,71.45 237.88,71.45 237.5,71.07 237.5,62.56 237.12,62.18 231.15,62.18 230.61,62.72 230.61,66.14 231.48,67.01 232.62,67.01 233.84,68.23 233.84,69.17 233.56,69.45 233.56,73.48 233.79,73.71 234.35,73.71 234.58,73.94 234.58,75.54 234.45,75.67 234.02,75.67 233.71,75.97 233.71,76.56 233.79,76.63
IIN-_1 on L12_SIG4: 227.97,75.42 227.97,69.9 230.72,67.16 230.72,62.64 231.02,62.33 238.64,62.33 239.35,63.05 239.35,75.11 238.69,75.77 228.33,75.77
IN1+_3P3V on TOP: 240.88,36.5 241.56,35.82 241.56,31.73 241.03,31.19 236.99,31.19 236.79,31.4 235.69,31.4 235.03,32.06 229.65,32.06 229.01,31.42 222,31.42 221.14,32.29 221.14,35.54 222.1,36.5
IO_1P8V on TOP: 71.23,41.76 71.23,36.53 71.46,36.3 72.42,36.3 72.65,36.53 72.65,39.86 73.01,40.21 75.5,40.21 75.72,40.44 75.72,41.56 75.24,42.04 71.51,42.04
IO_1P8V on TOP: 85.99,51.13 83.45,51.13 83.32,51.01 83.32,49.99 83.45,49.86 85.99,49.86 86.11,49.99 86.11,51.01
IO_1P8V on TOP: 67.06,41.86 67.06,36.4 66.81,36.15 62.26,36.15 61.68,36.73 61.68,44.71 62.24,45.27 64.42,45.27 65.03,44.66 65.03,42.37 65.29,42.12 66.81,42.12
IO_1P8V on BOTTOM: 16.52,76.66 16.52,75.64 18.17,75.64 18.42,75.9 18.42,76.41 18.17,76.66
IO_1P8V on BOTTOM: 212.53,25.48 212.53,24.72 212.91,24.34 217,24.34 217.15,24.49 217.15,25.45 217,25.61 212.66,25.61
IO_1P8V on BOTTOM: 48.14,30.43 48.14,32.21 48.39,32.46 49.28,32.46 49.54,32.21 49.54,30.69 49.28,30.43
IO_1P8V on BOTTOM: 207.4,104.35 207.65,104.09 208.52,104.09 208.82,104.4 208.82,106.23 208.46,106.58 206.74,106.58 206.56,106.4 206.56,105.13 207.35,104.35
IO_1P8V on BOTTOM: 131.2,40.24 131.2,39.58 131.86,38.92 137.07,38.92 137.37,38.61 137.37,36.73 137.27,36.63 137.27,36.6 137.57,36.3 138.16,36.3 138.28,36.17 138.28,35.03 138.67,34.65 139.91,34.65 140.01,34.75 140.01,39.53 139.12,40.41 131.38,40.41
IO_1P8V on BOTTOM: 53.98,20.14 55.76,20.14 56.01,19.89 56.01,18.87 55.76,18.62 54.11,18.62 53.86,18.87 53.86,20.02
IO_1P8V on L05_SIG2: 207.68,25.2 208.54,24.34 219.46,24.34 220.1,24.97 220.1,68.02 221.37,69.29 221.37,79.17 220.38,80.17 219.23,80.17 219.23,80.22 219.62,80.6 219.62,86.11 218.55,87.18 216.82,87.18 216.54,87.45 216.54,89.87 216.16,90.25 216.16,93.8 207.91,102.06 207.91,103.71 208.74,104.55 208.74,106.35 208.34,106.76 202.57,106.76 200.97,105.16 200.97,87.61 211.59,76.99 211.59,58.63 212.35,57.86 212.35,55.45 211.59,54.69 211.59,50.37 204.22,43 204.22,28.65 203,27.43 203,25.58 203.38,25.2 ; 1 cut-out
IO_1P8V on L05_SIG2: 46.87,30.69 45.6,29.42 45.6,18.24 46.24,17.6 73.54,17.6 74.18,18.24 74.18,32.21 75.7,33.73 75.7,41.73 76.59,42.62 76.59,45.67 75.95,46.31 70.75,46.31 69.98,45.54 62.36,45.54 58.94,42.12 58.94,36.02 58.3,35.38 47.51,35.38 46.87,34.75
IO_1P8V on L10_PWR2: 50.43,109.93 50.43,91.52 56.4,91.52 56.4,80.34 58.3,80.34 58.3,16.97 45.85,16.97 45.85,14.18 1.28,14.18 1.28,109.93
IO_1P8V on L12_SIG4: 73.41,74.63 89.67,74.63 90.05,74.25 93.61,74.25 96.15,72.98 99.45,72.98 99.96,73.48 107.58,73.48 108.52,72.55 108.52,68.76 107.58,67.82 91.93,67.82 89.21,70.54 81.64,70.54 72.27,61.17 72.27,53.8 73.53,52.54 75.46,52.54 75.47,52.53 121.67,52.53 122.31,53.16 126.37,53.16 126.63,52.91 126.63,51.39 121.67,46.43 105.04,46.43 104.27,47.2 89.92,47.2 87.26,44.53 79.46,44.53 75.39,40.46 73.57,40.46 72.93,41.1 55.76,41.1 52.59,44.27 52.59,52.53 64.9,64.85 64.9,69.29 68.21,72.6 71.38,72.6 ; 1 cut-out
IO_1P8V on L16_SIG6: 135.14,35.26 134.88,35.51 134.88,42.24 131.07,46.06 126.28,48.47 119.36,48.47 118.6,47.7 106.2,47.7 94.01,40.2 88.02,40.2 88.02,40.21 84.08,44.15 79.38,44.15 75.95,40.72 74.43,40.72 73.72,41.43 73.72,44.33 76.59,47.2 86.95,47.2 88.02,46.13 93.49,46.13 102.12,51.12 102.12,72.34 102.62,72.85 109.23,72.85 110.24,71.83 110.24,51.51 111.26,50.5 118.37,50.5 119.51,51.64 119.51,52.78 121.17,54.43 134.63,54.43 136.75,52.31 138.4,52.31 141.7,49.01 141.7,41.1 140.47,39.87 140.47,36.78 139.58,35.89 139.58,35.51 139.33,35.26
IO_3P3V on BOTTOM: 41.54,65.86 34.81,65.86 32.9,67.77 32.9,70.44 33.15,70.44 33.15,69.42 33.54,69.04 33.54,68.15 33.79,67.9 35.44,67.9 35.95,68.4 37.09,68.4 37.22,68.53 37.22,69.67 42.43,69.67 42.43,75.9 42.68,76.15 46.24,76.15 46.24,70.56 45.35,70.56 45.09,70.31 45.09,69.42 44.97,69.29 43.7,69.29 43.57,69.17 43.57,66.25 43.7,66.12 44.46,66.12 44.71,66.37 44.71,66.75 44.97,67.01 46.24,67.01 46.24,64.72 45.98,64.47 42.93,64.47
IO_3P3V on BOTTOM: 54.49,94.44 57.16,94.44 57.67,93.93 57.67,91.52 57.41,91.26 55.63,91.26 55.63,92.41 54.49,93.55
IO_3P3V on BOTTOM: 46.24,45.8 45.35,45.8 45.09,45.54 45.09,44.66 44.97,44.53 43.7,44.53 43.57,44.4 43.57,41.48 43.7,41.35 44.46,41.35 44.71,41.61 44.71,41.99 44.97,42.24 46.24,42.24 46.24,39.96 43.06,39.96 42.81,40.21 42.81,51.13 43.06,51.39 46.24,51.39
IO_3P3V on BOTTOM: 36.84,92.28 38.23,92.28 38.23,93.55 37.98,93.8 36.84,93.8 36.58,93.55 36.58,92.92 36.71,92.79 36.71,92.41
IO_3P3V on BOTTOM: 47,107.39 47,106.38 43.95,106.38 43.82,106.5 43.82,107.01 44.08,107.01 44.08,107.39
IO_3P3V on L03_SIG1: 184.54,24.97 226.19,24.97 240.67,39.45 251.47,39.45 255.53,43.51 255.53,43.89 255.53,57.64 256.14,58.24 262.72,58.24 264.04,59.57 264.04,100.66 262.14,102.57 224.16,102.57 216.54,94.95 200.67,94.95 199.91,95.71 199.91,97.36 200.03,97.49 200.29,97.49 201.68,96.09 203.08,96.09 203.59,96.6 203.59,98 203.97,98.38 203.97,106.5 204.6,107.14 205.11,107.14 205.75,106.5 205.75,103.2 206.38,102.57 207.65,102.57 209.43,104.35 209.43,108.79 210.19,109.55 273.06,109.55 273.06,14.05 176.54,14.05 176.16,14.43 176.16,16.59 ; 1 cut-out
IO_3P3V on L05_SIG2: 124.21,18.87 131.83,18.87 133.48,20.53 162.57,20.53 163.08,20.02 163.08,14.43 162.69,14.05 139.2,14.05 135.77,10.62 129.67,10.62 124.85,5.79 61.98,5.79 58.05,9.73 48.14,9.73 47.51,10.37 47.51,15.7 48.14,16.33 60.33,16.33 60.59,16.08 64.27,16.08 67.06,13.29 88.65,13.29 92.21,9.73 108.59,9.73 111.89,13.03 118.37,13.03
IO_3P3V on L07_SIG3: 91.32,102.19 100.85,102.19 101.48,102.82 101.48,105.74 100.97,106.25 98.56,106.25 95,109.81 30.74,109.81 30.74,103.2 26.55,103.2 26.55,92.03 37.73,92.03 37.73,86.18 35.57,86.18 35.57,81.23 38.36,81.23 38.36,71.2 38.74,70.82 52.84,70.82 53.6,71.58 53.6,89.11 54.49,89.99 79.13,89.99
IO_3P3V on L09_PWR1: 40.27,14.18 40.27,31.96 1.28,31.96 1.28,109.93 47,109.93 47,106 44.46,103.46 35.06,103.46 29.6,98 14.61,98 14.61,68.02 43.44,68.02 43.44,76.41 56.65,76.41 56.65,56.34 47.38,56.34 47.38,25.48 54.74,25.48 54.74,16.97 45.85,16.97 45.85,14.18
IO_3P3V on L12_SIG4: 44.97,35.26 44.97,39.39 44.52,39.83 42.93,39.83 42.55,40.21 42.55,44.53 45.47,47.45 48.39,47.45 48.46,47.39 48.84,47.39 55.89,40.34 73.12,40.34 76.08,37.38 76.08,35.26 77.22,34.11 77.22,31.83 78.62,30.43 78.62,24.08 80.65,22.05 80.65,20.65 80.53,20.53 76.21,20.53 75.32,21.41 75.32,30.69 73.92,32.08 64.9,32.08 64.02,31.19 64.02,10.37 63.38,9.73 46.74,9.73 46.24,10.24 46.24,14.43 42.17,18.49 42.17,28.65 43.7,30.18 43.7,33.99
IO_3P3V on L14_SIG5: 159.9,20.53 180.86,20.53 181.49,19.89 181.49,14.81 180.86,14.18 159.9,14.18 159.27,14.81 159.27,19.89 ; 1 cut-out
IO_3P3V on L16_SIG6: 159.52,14.18 159.01,14.68 159.01,21.41 159.65,22.05 180.35,22.05 180.98,21.41 180.98,14.81 180.35,14.18
MAX10_AGND on TOP: 251.21,33.61 259.34,33.61 259.6,33.35 259.6,31.96 259.85,31.7 262.9,31.7 263.15,31.96 263.15,36.91 263.02,37.04 251.34,37.04 250.96,36.65 250.96,33.86
MAX10_AGND on L16_SIG6: 255.18,35.07 255.18,31.07 256.28,31.07 256.28,35.07
PCIE_EP_3P3V on TOP: 52.33,3.25 52.33,5.79 52.08,6.05 52.08,8.59 52.2,8.71 53.22,8.71 53.35,8.59 53.35,6.17 52.97,5.79 52.97,3.25
PCIE_EP_3P3V on BOTTOM: 53.35,3.51 53.35,5.67 52.08,6.94 52.08,8.97 53.35,10.24 53.35,10.75 53.47,10.87 53.98,10.87 53.98,9.6 53.73,9.35 53.73,7.32 55,6.05 55,3.51
PCIE_EP_3P3V on L07_SIG3: 53.6,5.54 52.08,5.54 51.7,5.92 51.7,8.97 52.08,9.35 53.6,9.35 53.98,8.97 53.98,5.92
PCIE_EP_12V on TOP: 258.83,78.39 258.83,78.31 259.09,78.06 261.88,78.06 262.26,77.68 262.26,74.32 263.05,73.54 263.05,72.6 262.8,72.34 255.66,72.34 255.4,72.6 255.4,78.41 255.43,78.39
PCIE_EP_12V on TOP: 45.73,2.87 45.6,3 45.6,8.46 45.85,8.71 47.89,8.71 48.14,8.46 48.14,6.05 48.01,5.92 48.01,2.87
PCIE_EP_12V on BOTTOM: 259.07,78.07 259.09,78.06 261.88,78.06 262.26,77.68 262.26,72.6 262.01,72.34 255.66,72.34 255.4,72.6 255.4,78.06 259.06,78.06
PCIE_EP_12V on BOTTOM: 46.36,2.49 46.36,5.79 46.11,6.05 46.11,8.46 46.36,8.71 47.89,8.71 48.14,8.46 48.14,6.05 48.01,5.92 48.01,2.49
PCIE_EP_12V on L09_PWR1: 46.27,5.79 46.27,10.92 46.26,11.16 46.24,11.4 46.24,16.59 124.21,16.59 129.67,22.05 242.73,22.05 242.8,21.98 244.25,21.98 244.32,22.05 255.79,22.05 255.79,58.24 255.4,58.24 255.4,79.45 273.06,79.45 273.06,14.02 140.78,14.02 138.64,13.14 137.76,11 137.76,10.26 130.66,10.26 128.8,9.48 128.03,7.62 128.03,6.3 59.37,6.3 59.37,7.45 57.15,9.67 54.93,7.45 54.93,5.79
PCIE_EP_12V on L10_PWR2: 46.27,5.79 46.27,10.92 46.26,11.16 46.24,11.4 46.24,16.59 124.21,16.59 129.67,22.05 242.73,22.05 242.73,22.04 242.8,21.98 244.25,21.98 244.32,22.05 255.79,22.05 255.79,58.24 255.4,58.24 255.4,79.45 273.06,79.45 273.06,14.02 140.78,14.02 138.64,13.14 137.76,11 137.76,10.26 130.66,10.26 128.8,9.48 128.03,7.62 128.03,6.3 59.37,6.3 59.37,7.45 57.15,9.67 54.93,7.45 54.93,5.79
PHY_25M_3.3V on BOTTOM: 39.76,88.98 37.98,88.98 37.73,89.23 37.73,91.52 37.85,91.65 39.76,91.65 39.89,91.52 39.89,89.11
PWR_M10_VCCA on BOTTOM: 254.26,21.92 254.26,18.75 253.12,18.75 252.86,19 252.86,20.91 252.61,21.16 251.98,21.16 251.98,21.67 252.23,21.92
PWR_M10_VCCA on L03_SIG1: 247.53,30.3 247.53,19.64 248.04,19.13 260.36,19.13 260.87,19.64 260.87,30.56 260.48,30.94 248.17,30.94
PWR_M10_VCCIO1A on L05_SIG2: 259.21,30.94 253.88,30.94 253.25,31.57 253.25,33.48 253.88,34.11 262.77,34.11 263.41,33.48 263.41,31.07 262.9,30.56 259.6,30.56
QSFPDD0_VCC on BOTTOM: 57.67,68.91 57.92,69.17 57.92,69.67 57.67,69.93 57.03,69.93 56.52,70.44 54.74,70.44 54.49,70.69 54.49,72.6 54.24,72.85 54.24,75.9 53.98,76.15 47.25,76.15 47.25,73.61 47.38,73.48 51.95,73.48 52.46,72.98 52.46,69.17 52.71,68.91
QSFPDD0_VCCR on BOTTOM: 51.7,67.64 52.08,68.02 52.08,68.91 49.66,68.91 48.52,70.06 48.52,73.1 47.12,73.1 47.12,67.64
QSFPDD0_VCCT on BOTTOM: 47.51,67.26 47.25,67.01 47.25,64.98 47.38,64.85 48.65,64.85 48.78,64.98 48.78,65.61 53.73,65.61 53.73,66.63 54.36,67.26 57.67,67.26 57.92,67.52 57.92,68.28 57.67,68.53 53.09,68.53 51.82,67.26
QSFPDD1_VCC on BOTTOM: 57.67,44.15 57.92,44.4 57.92,44.91 57.67,45.16 57.03,45.16 56.52,45.67 54.74,45.67 54.49,45.93 54.49,47.83 54.24,48.08 54.24,51.13 53.98,51.39 47.25,51.39 47.25,48.85 47.38,48.72 51.95,48.72 52.46,48.21 52.46,44.4 52.71,44.15
QSFPDD1_VCCR on BOTTOM: 51.7,42.88 51.95,43.13 51.95,43.89 51.7,44.15 48.9,44.15 48.52,44.53 48.52,48.34 47.12,48.34 47.12,42.88
QSFPDD1_VCCT on BOTTOM: 47.51,42.5 47.25,42.24 47.25,40.21 47.38,40.08 48.65,40.08 48.78,40.21 48.78,40.85 53.73,40.85 53.73,41.86 54.36,42.5 58.17,42.5 58.43,42.75 58.43,43.51 58.17,43.77 53.09,43.77 51.82,42.5
SD_3.3V on BOTTOM: 40.9,107.39 43.06,107.39 43.06,107.01 43.31,107.01 43.31,104.09 41.16,104.09 40.9,104.35
SD_3.3V on L05_SIG2: 35.82,105.23 36.46,105.87 50.05,105.87 50.68,105.23 50.68,95.07 50.05,94.44 36.46,94.44 35.82,95.07
