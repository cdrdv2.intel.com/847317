# Allegro board TS28247BC0_FM61_agilex_PCIe_DEVKIT_ADI_REVB1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_DIMM_CH2_ALERT_N: length 87.1
  L14_SIG5 w0.081: v1(125.31,49.43) 124.36,49.43 123.74,50.05 123.31,50.05 122.87,50.49 122.47,50.49 122.22,50.24 122.22,47.8 122.58,47.44 122.88,47.44 123.08,47.24 123.08,46.36 123.17,46.27 123.33,46.27 123.42,46.36 123.42,46.88 123.51,46.97 123.67,46.97 123.76,46.88 123.76,46 123.59,45.82 123.28,45.82 123.16,45.7 123.16,42.23 123.39,42 123.88,42 124.22,42.34 124.72,42.34 124.9,42.16 124.9,41.23 125.16,40.97 125.87,40.97 126.12,40.72 126.12,40.12 126.55,39.69 126.55,39.17 126.83,38.9 127.64,38.9 127.9,38.65 127.9,37.65 128.38,37.16 128.38,36.23 128.65,35.96 129.44,35.96 130.35,35.06 131.11,35.06 131.55,34.62 133.25,34.62 133.81,34.06 134.57,34.06 134.92,33.7 137.34,33.7 137.62,33.42 137.62,33.11 137.97,32.76 137.97,32.16 138.19,31.94 138.56,31.94 138.84,32.21 138.84,33.1 138.97,33.23 139.11,33.23 139.26,33.09 139.26,32.26 139.35,32.17 139.55,32.17 139.64,32.26 139.64,32.67 139.77,32.8 140.7,32.8 141.11,33.22 142.99,33.22 143.41,32.8 144.53,32.8 144.82,32.51 144.82,31.53 145.03,31.33 145.75,31.33 147.2,29.88 147.53,29.88 147.63,29.78 147.63,29.49 147.73,29.4 147.87,29.4 147.97,29.49 147.97,29.78 148.07,29.88 148.2,29.88 148.3,29.78 148.3,29.49 148.4,29.4 148.54,29.4 148.64,29.49 148.64,29.78 148.74,29.88 148.88,29.88 148.97,29.78 148.97,29.49 149.07,29.4 149.21,29.4 149.31,29.49 149.31,29.78 149.41,29.88 149.55,29.88 149.64,29.78 149.64,29.49 149.74,29.4 149.88,29.4 149.98,29.49 149.98,29.78 150.08,29.88 150.22,29.88 150.31,29.78 150.31,29.49 150.41,29.4 150.55,29.4 150.65,29.49 150.65,29.78 150.75,29.88 150.89,29.88 150.99,29.78 150.99,29.49 151.08,29.4 151.22,29.4 151.32,29.49 151.32,29.78 151.42,29.88 151.85,29.88 151.99,29.73 151.99,28.72 152.09,28.63 152.23,28.63 152.33,28.72 152.33,29.78 152.42,29.88 152.56,29.88 152.66,29.78 152.66,28.72 152.76,28.63 152.9,28.63 153,28.72 153,29.91 153.09,30.01 153.23,30.01 153.33,29.91 153.33,28.72 153.43,28.63 153.57,28.63 153.67,28.72 153.67,29.91 153.77,30 153.9,30 154,29.91 154,28.25 153.9,28.14 151.92,28.14 151.1,28.96 145.82,28.96 144.72,27.86 144.13,27.86 143.28,27.01 142.26,27.01 141.6,26.35 140.87,26.35 140.38,26.84 139.71,26.84 v1(139.29,26.42)
DDR4_DIMM_CH2_BA0: length 89
  L03_SIG1 w0.081: v4(125.31,47.43) 125.31,46.96 124.64,46.3 124.28,46.3 124.07,46.09 124.07,45.77 124.22,45.62 124.22,45.24 124.03,45.05 124.03,44.8 124.27,44.56 124.27,44.3 124.03,44.05 124.03,43.36 123.72,43.05 123.4,43.05 123.18,43.27 123.18,43.6 123.37,43.79 123.37,44.06 122.89,44.54 122.45,44.54 122.24,44.33 122.24,43.85 122.48,43.61 122.48,43.27 122.24,43.03 122.24,42.3 121.99,42.05 121.66,42.05 121.46,42.25 121.46,42.62 121.67,42.83 121.67,43.04 121.46,43.25 121.46,44.07 121.23,44.3 120.72,44.3 120.52,44.11 120.33,44.11 120.23,44.01 120.23,43.86 120.33,43.76 120.57,43.76 120.74,43.59 120.74,43.26 120.55,43.07 120.55,42.81 120.76,42.59 120.76,42.28 120.55,42.06 120.55,41.77 121,41.32 121,38.27 120.9,38.17 120.77,38.17 120.67,38.27 120.67,38.62 120.54,38.75 120.38,38.75 120.28,38.85 120.28,38.99 120.38,39.09 120.56,39.09 120.67,39.2 120.67,39.65 120.55,39.76 120.34,39.76 120.23,39.86 120.23,39.99 120.34,40.1 120.57,40.1 120.67,40.2 120.67,40.93 120.57,41.03 119.98,41.03 119.74,41.28 119.74,41.65 119.92,41.84 119.92,42.06 119.77,42.21 119.52,42.21 119.42,42.32 119.42,42.5 119.52,42.6 119.7,42.6 119.91,42.81 119.91,43.08 119.43,43.55 119.03,43.55 118.63,43.16 118.63,42.9 118.99,42.55 118.99,42.33 118.75,42.08 118.75,41.89 118.91,41.72 118.91,41.47 118.75,41.3 118.75,41.13 118.85,41.03 119.46,41.03 119.56,40.93 119.56,40.77 119.46,40.66 118.87,40.66 118.77,40.57 118.77,40.43 118.87,40.33 119.69,40.33 119.79,40.23 119.79,40.09 119.69,39.99 118.67,39.99 118.58,39.9 118.58,39.76 118.67,39.66 119.63,39.66 119.73,39.56 119.73,39.42 119.63,39.32 118.79,39.32 118.69,39.22 118.69,39.09 118.79,38.99 119.8,38.99 119.9,38.89 119.9,38.75 119.8,38.65 118.85,38.65 118.75,38.55 118.75,38.42 118.85,38.32 119.7,38.32 119.8,38.22 119.8,38.08 119.7,37.98 118.69,37.98 118.6,37.88 118.6,37.74 118.69,37.65 119.76,37.65 119.86,37.55 119.86,37.41 119.76,37.31 118.78,37.31 118.69,37.21 118.69,37.07 118.78,36.98 119.27,36.98 119.37,36.88 119.37,36.74 119.27,36.64 118.5,36.64 117.99,37.15 117.99,37.89 117.84,38.04 117.05,38.04 116.95,37.94 116.95,37.79 117.05,37.69 117.49,37.69 117.59,37.59 117.59,37.45 117.49,37.34 117.3,37.34 117.2,37.24 117.2,37.1 117.3,37 117.59,37 117.69,36.9 117.69,36.75 117.59,36.65 117.4,36.65 117.3,36.55 117.3,36.41 117.4,36.31 119.24,36.31 119.34,36.21 119.34,36.07 119.24,35.97 118.7,35.97 118.6,35.87 118.6,35.73 118.7,35.64 119.26,35.64 119.36,35.54 119.36,35.4 119.26,35.3 118.87,35.3 118.51,34.94 118.51,32.86 118.61,32.76 118.75,32.76 118.85,32.86 118.85,34.79 118.94,34.89 119.08,34.89 119.18,34.79 119.18,33.72 119.28,33.63 119.42,33.63 119.52,33.72 119.52,34.61 119.61,34.71 119.75,34.71 119.85,34.61 119.85,33.08 119.29,32.51 119.29,32.25 118.82,31.79 118.82,30.86 118.44,30.48 118.44,29.82 116.45,27.82 116.22,27.82 115.09,26.69 115.09,26.16 115.39,25.87 115.53,25.87 118.11,28.45 118.11,28.69 118.89,29.46 118.89,30.15 119.19,30.45 119.19,31.13 119.5,31.44 119.5,31.91 119.74,32.16 v4(119.74,32.42)
DDR4_DIMM_CH2_BA1: length 83.3
  L12_SIG4 w0.089: v1(120.59,26.42) 120.17,26.84 118.4,26.84 118.13,27.1 118.13,28.43 118.22,28.52 118.39,28.52 118.48,28.43 118.48,27.93 118.56,27.84 119.39,27.84 119.56,28.01 119.56,28.46 119.65,28.55 119.82,28.55 119.9,28.46 119.9,27.34 119.99,27.25 120.16,27.25 120.25,27.34 120.25,28.41 120.34,28.5 120.5,28.5 120.59,28.41 120.59,27.07 121.67,25.98 121.8,25.98 121.93,26.12 121.93,26.25 120.93,27.25 120.93,28.04 121.03,28.14 121.18,28.14 121.28,28.04 121.28,27.9 121.38,27.8 121.52,27.8 121.62,27.9 121.62,28.06 121.72,28.16 121.86,28.16 121.96,28.06 121.96,26.89 122.06,26.79 122.2,26.79 122.3,26.89 122.3,29.57 122.41,29.67 122.55,29.67 122.65,29.57 122.65,26.6 122.75,26.49 122.89,26.49 122.99,26.6 122.99,27.65 123.09,27.75 123.23,27.75 123.33,27.65 123.33,26.09 123.43,25.99 123.58,25.99 123.68,26.09 123.68,27.49 123.78,27.59 123.92,27.59 124.02,27.49 124.02,26.09 124.12,25.99 124.26,25.99 124.36,26.09 124.36,27.59 124.46,27.69 124.6,27.69 124.71,27.59 124.71,26.09 124.81,25.99 124.95,25.99 125.05,26.09 125.05,28.16 125.24,28.35 125.24,30.81 125.14,30.91 124.81,30.91 124.71,31.01 124.71,31.16 124.81,31.26 125.14,31.26 125.24,31.36 125.24,31.5 125.14,31.6 124.59,31.6 124.49,31.7 124.49,31.84 124.59,31.94 125.14,31.94 125.24,32.04 125.24,32.55 125.34,32.65 125.48,32.65 125.58,32.55 125.58,29.05 125.68,28.95 125.82,28.95 125.92,29.05 125.92,33.57 127.86,35.5 128.27,35.5 128.37,35.6 128.37,35.75 128.27,35.85 127.86,35.85 127.76,35.95 127.76,36.09 127.86,36.19 128.27,36.19 128.37,36.29 128.37,36.44 128.27,36.54 127.86,36.54 127.76,36.64 127.76,38.31 127.86,38.41 128.08,38.41 128.18,38.51 128.18,38.65 128.08,38.75 127.86,38.75 127.76,38.85 127.76,40.75 127.45,41.05 126.84,41.05 126.66,41.23 126.66,41.55 126.77,41.8 126.77,42.17 126.66,42.27 126.66,42.53 126.78,42.82 126.78,43.15 126.66,43.27 126.66,43.58 126.8,43.72 126.8,44.01 126.66,44.34 126.66,44.53 126.76,44.77 126.76,45.17 126.6,45.33 126.6,46.14 126.43,46.3 124.38,46.3 123.97,46.71 123.97,47.86 124.07,47.96 124.32,47.96 124.42,47.86 124.42,46.84 124.53,46.74 124.67,46.74 124.76,46.83 124.76,47.88 124.87,47.99 125.02,47.99 125.1,47.9 125.1,46.82 125.21,46.71 125.36,46.71 125.45,46.8 125.45,47.86 125.55,47.97 125.7,47.97 125.79,47.88 125.79,47.54 125.93,47.41 126.53,47.41 126.62,47.32 126.62,47.02 126.53,46.93 v1(126.17,46.93)
DDR4_DIMM_CH2_BG0: length 85.4
  L03_SIG1 w0.081: v1(126.17,47.93) 126.17,47.47 126.55,47.1 126.85,47.1 126.95,46.99 126.95,46.85 126.85,46.75 126.61,46.75 126.51,46.66 126.51,46.23 126.62,46.12 126.82,46.12 126.92,46.03 126.92,45.86 126.82,45.77 126.6,45.77 126.52,45.68 126.52,45.39 126.83,45.08 126.83,44.88 126.57,44.62 126.57,44.3 126.78,44.1 126.78,43.83 126.57,43.63 126.57,43.32 126.85,43.04 126.85,42.82 126.39,42.37 125.92,42.37 125.49,41.93 125.18,41.93 124.69,41.45 124.04,41.45 123.94,41.35 123.94,41.21 124.04,41.11 125.06,41.11 125.15,41.01 125.15,40.87 125.06,40.78 124.03,40.78 123.93,40.68 123.93,40.54 124.03,40.44 125.27,40.44 125.37,40.34 125.37,40.2 125.27,40.11 123.77,40.11 123.67,40.01 123.67,39.87 123.77,39.77 124.85,39.77 124.94,39.67 124.94,39.53 124.85,39.43 124.03,39.43 123.93,39.34 123.93,39.2 124.03,39.1 125.12,39.1 125.22,39 125.22,38.86 125.12,38.76 124.03,38.76 123.94,38.67 123.94,38.53 124.03,38.43 124.84,38.43 124.94,38.33 124.94,38.19 124.84,38.09 123.75,38.09 123.65,38 123.65,37.86 123.75,37.76 124.84,37.76 124.94,37.66 124.94,37.52 124.84,37.42 124.03,37.42 123.93,37.33 123.93,37.19 124.03,37.09 124.45,37.09 124.55,36.99 124.55,35.18 124.44,35.08 124.31,35.08 124.21,35.18 124.21,36.65 124.11,36.75 123.98,36.75 123.88,36.65 123.88,35.91 123.77,35.81 123.64,35.81 123.54,35.91 123.54,36.95 123.44,37.05 122.22,37.05 122.12,36.95 122.12,36.72 122.22,36.61 123.08,36.61 123.18,36.51 123.18,36.38 123.08,36.28 122.23,36.28 122.13,36.18 122.13,36.05 122.23,35.94 123.07,35.94 123.18,35.84 123.18,35.71 123.07,35.61 122.32,35.61 122.22,35.51 122.22,35.38 122.32,35.27 123.19,35.27 123.29,35.17 123.29,35.04 123.19,34.94 122.06,34.94 121.95,34.84 121.95,34.7 122.06,34.6 123.58,34.6 123.68,34.5 123.68,34.37 123.58,34.27 121.99,34.27 121.89,34.17 121.89,34.03 121.99,33.93 123.58,33.93 123.68,33.83 123.68,33.7 123.58,33.6 122.25,33.6 122.15,33.5 122.15,33.36 122.25,33.26 123.6,33.26 123.7,33.16 123.7,33.02 123.6,32.93 122.66,32.93 122.57,32.83 122.57,32.69 122.66,32.59 123.58,32.59 123.68,32.49 123.68,32.35 123.58,32.26 122.69,32.26 122.59,32.16 122.59,32.02 122.69,31.92 123.59,31.92 123.69,31.82 123.69,31.68 123.59,31.59 122.32,31.59 122.22,31.49 122.22,31.35 122.32,31.25 124.54,31.25 125.22,30.57 125.22,28.76 125.32,28.66 125.45,28.66 125.55,28.76 125.55,30.08 125.65,30.18 125.79,30.18 125.89,30.08 125.89,29.43 125.99,29.33 126.12,29.33 126.22,29.43 126.22,29.56 126.35,29.68 130.3,29.68 131.55,30.94 134.27,30.94 135.04,31.7 136.3,31.7 136.64,32.05 137.75,32.05 137.96,32.26 137.96,32.49 138.3,32.83 139.65,32.83 v1(140.06,32.41)
DDR4_DIMM_CH2_BG1: length 91.5
  L14_SIG5 w0.081: v1(140.14,26.42) 139.92,26.42 139.55,26.05 139.14,26.05 138.85,26.33 138.85,26.95 139.1,27.2 140.19,27.2 140.27,27.29 140.27,27.71 140.19,27.8 138.26,27.8 138.05,28.01 138.05,29.06 137.95,29.16 137.81,29.16 137.72,29.06 137.72,27.65 137.62,27.56 137.48,27.56 137.38,27.65 137.38,29.06 137.28,29.16 137.14,29.16 137.05,29.06 137.05,27.65 136.95,27.56 136.81,27.56 136.71,27.65 136.71,29.02 136.57,29.17 133.87,29.17 133.32,29.72 129.82,29.72 129.59,29.95 129.59,30.48 129.49,30.58 129.36,30.58 129.26,30.48 129.26,29.84 129.16,29.74 129.02,29.74 128.92,29.84 128.92,30.61 128.82,30.7 128.69,30.7 128.59,30.61 128.59,29.84 128.49,29.74 128.35,29.74 128.25,29.84 128.25,30.59 128.15,30.69 128.01,30.69 127.92,30.59 127.92,29.83 127.82,29.74 127.68,29.74 127.58,29.83 127.58,30.91 127.48,31.01 127.34,31.01 127.25,30.91 127.25,29.82 127.15,29.72 127.01,29.72 126.91,29.82 126.91,31.19 126.81,31.29 126.67,31.29 126.58,31.19 126.58,29.83 126.48,29.73 126.34,29.73 126.24,29.83 126.24,31.22 126.14,31.31 126,31.31 125.9,31.22 125.9,29.8 125.81,29.7 125.67,29.7 125.57,29.8 125.57,31.48 125.77,31.68 126.42,31.68 126.51,31.77 126.51,32.8 126.42,32.89 126.26,32.89 126.17,32.8 126.17,32.14 126.08,32.05 125.93,32.05 125.84,32.14 125.84,32.84 125.75,32.93 125.59,32.93 125.5,32.84 125.5,32.14 125.41,32.05 125.25,32.05 125.16,32.14 125.16,32.8 125.07,32.89 124.92,32.89 124.83,32.8 124.83,31.69 124.74,31.61 124.58,31.61 124.49,31.69 124.49,32.8 124.4,32.89 124.25,32.89 124.16,32.8 124.16,31.67 124.07,31.58 123.91,31.58 123.82,31.67 123.82,32.77 123.73,32.86 123.58,32.86 123.49,32.77 123.49,31.72 123.4,31.64 123.24,31.64 123.15,31.72 123.15,33.17 123.06,33.25 122.9,33.25 122.82,33.17 122.82,31.48 122.73,31.39 122.57,31.39 122.48,31.48 122.48,31.93 122.39,32.02 122.23,32.02 122.15,31.93 122.15,31.45 122.06,31.36 121.9,31.36 121.81,31.45 121.81,32.75 121.72,32.84 121.56,32.84 121.47,32.75 121.47,32.44 121.39,32.35 121.23,32.35 121.14,32.44 121.14,33.19 121.05,33.27 120.89,33.27 120.8,33.19 120.8,32.47 120.72,32.38 120.52,32.38 120.43,32.47 120.43,34.88 120.34,34.97 120.14,34.97 120.05,34.88 120.05,32.48 119.96,32.39 119.78,32.39 119.69,32.48 119.69,35.12 119.6,35.21 119.43,35.21 119.34,35.12 119.34,34.5 119.25,34.41 119.08,34.41 118.99,34.5 118.99,35.1 118.9,35.19 118.73,35.19 118.64,35.1 118.64,34.58 118.55,34.49 118.02,34.49 117.93,34.58 117.93,44.21 117.67,44.46 117.24,44.46 116.74,44.96 116.58,44.96 116.2,45.35 116.2,46.17 115.78,46.59 v1(115.78,46.93)
DDR4_DIMM_CH2_C2: length 91.4
  L03_SIG1 w0.081: v4(111.24,26.42) 112.05,27.22 112.05,27.83 111.68,28.2 111.68,30.02 112.49,30.82 112.49,31.59 112.23,31.84 111.83,31.84 111.7,31.7 111.7,30.93 111.58,30.81 111.43,30.81 111.31,30.93 111.31,31.88 111.93,32.5 111.93,32.69 111.81,32.81 111.04,32.81 110.72,33.13 108.53,33.13 108.31,32.91 108.31,31 108.21,30.91 108.07,30.91 107.98,31 107.98,31.22 107.88,31.32 107.74,31.32 107.64,31.22 107.64,30.76 107.54,30.66 107.4,30.66 107.31,30.76 107.31,31.25 107.21,31.34 107.07,31.34 106.97,31.25 106.97,30.75 106.87,30.65 106.73,30.65 106.64,30.75 106.64,31.6 106.54,31.7 106.4,31.7 106.3,31.6 106.3,30.79 106.2,30.69 106.06,30.69 105.96,30.79 105.96,31.67 105.87,31.77 105.73,31.77 105.63,31.67 105.63,30.76 105.53,30.67 105.39,30.67 105.29,30.76 105.29,31.38 105.2,31.48 105.06,31.48 104.96,31.38 104.96,30.6 104.86,30.5 104.72,30.5 104.62,30.6 104.62,31.95 104.53,32.04 104.39,32.04 104.29,31.95 104.29,29.79 104.19,29.69 104.05,29.69 103.95,29.79 103.95,31.96 103.85,32.06 103.72,32.06 103.62,31.96 103.62,29.79 103.52,29.69 103.38,29.69 103.28,29.79 103.28,31.51 103.18,31.61 103.05,31.61 102.95,31.51 102.95,29.79 102.85,29.69 102.71,29.69 102.61,29.79 102.61,31.45 102.51,31.55 102.37,31.55 102.28,31.45 102.28,29.79 102.18,29.69 102.04,29.69 101.94,29.79 101.94,31.93 101.84,32.03 101.7,32.03 101.61,31.93 101.61,31.49 101.47,31.35 100.66,31.35 99.76,32.25 99.76,32.68 100.22,33.14 100.22,41.2 100.95,41.93 101.18,41.93 101.67,42.41 102,42.41 102.54,42.95 102.96,42.95 103.46,43.45 103.87,43.45 104.28,43.87 104.74,43.87 105.12,43.48 105.56,43.48 105.81,43.73 105.81,44.88 105.92,44.98 106.57,44.98 106.67,44.88 106.67,43.51 106.88,43.3 107.36,43.3 107.57,43.51 107.57,45.57 107.96,45.96 108.29,45.96 108.73,46.4 108.99,46.4 109.43,46.84 109.94,46.84 110.23,46.55 110.79,46.55 111.12,46.89 111.73,46.89 112.07,46.55 112.52,46.55 112.87,46.91 113.39,46.91 113.78,47.3 114.32,47.3 114.56,47.05 115.22,47.05 115.46,47.3 115.99,47.3 116.23,47.05 116.8,47.05 117.27,47.52 117.76,47.52 118.22,47.05 118.82,47.05 119.07,47.3 119.4,47.3 119.9,46.8 120.32,46.8 120.96,47.44 121.22,47.44 121.66,47.88 121.97,47.88 122.71,48.61 v4(122.71,48.93)
DDR4_DIMM_CH2_CK_N0: length 88.7
  L16_SIG6 w0.079: v1(129.94,32.42) 130.27,32.09 130.27,31.87 130.52,31.62 131.11,31.62 132.09,32.6 133.08,32.6 133.51,33.02 133.51,33.8 133.13,34.18 130.83,34.18 130.42,33.76 130.19,33.76 129.77,34.18 129.15,34.18 128.87,33.89 128.87,32.22 128.69,32.04 127.09,32.04 125.82,33.31 123.78,33.31 123.59,33.5 123.59,33.74 123.79,33.94 126.07,33.94 126.36,34.23 126.36,34.73 126.45,34.82 126.95,34.82 127.04,34.73 127.04,33.27 127.26,33.05 127.91,33.05 128.14,33.27 128.14,34.68 128.26,34.81 133.35,34.81 133.59,35.05 133.59,35.83 133.36,36.05 127.76,36.05 127.67,36.14 127.67,36.72 127.76,36.81 133.35,36.81 133.59,37.04 133.59,37.81 133.36,38.03 129.48,38.03 129.37,38.14 129.37,38.72 129.46,38.81 133.69,38.81 133.97,39.09 133.97,39.8 133.72,40.05 129.43,40.05 129.2,40.28 129.2,40.55 129.43,40.79 133.27,40.79 133.58,41.09 133.58,41.49 133.72,41.82 133.72,41.94 arc(133.68,42.15) 133.56,42.32 133.51,42.37 arc(133.32,42.5) 133.09,42.54 133.05,42.54 arc(132.83,42.49) 132.65,42.35 132.5,42.16 arc(132.4,42.07) 132.27,42.04 132.2,42.04 arc(132.07,42.07) 131.97,42.15 131.82,42.35 arc(131.64,42.49) 131.41,42.54 131.32,42.54 arc(131.1,42.49) 130.92,42.35 130.77,42.16 arc(130.66,42.07) 130.54,42.04 130.51,42.04 arc(130.37,42.07) 130.25,42.15 130.23,42.17 arc(130.15,42.29) 130.12,42.43 130.12,42.53 130.24,42.82 130.24,43.04 130.12,43.33 130.12,43.52 130.24,43.8 130.24,44.07 130.12,44.34 130.12,44.52 130.24,44.81 130.24,44.95 arc(130.2,45.16) 130.08,45.34 130.02,45.4 arc(129.86,45.51) 129.68,45.54 129.59,45.54 arc(129.47,45.57) 129.37,45.65 129.22,45.85 arc(129.04,45.99) 128.81,46.04 128.72,46.04 arc(128.6,46.07) 128.5,46.15 128.35,46.34 arc(128.17,46.49) 127.94,46.54 127.85,46.54 arc(127.73,46.57) 127.63,46.65 127.48,46.84 arc(127.3,46.99) 127.07,47.04 126.99,47.04 arc(126.87,47.07) 126.77,47.15 126.62,47.34 arc(126.44,47.49) 126.21,47.54 124.55,47.54 arc(124.28,47.49) 124.04,47.33 123.88,47.17 arc(123.74,47.07) 123.58,47.04 123.53,47.04 arc(123.4,47.07) 123.3,47.15 123.15,47.34 arc(122.97,47.49) 122.74,47.54 122.66,47.54 arc(122.43,47.49) 122.26,47.35 122.1,47.15 arc(122,47.07) 121.88,47.04 121.8,47.04 arc(121.58,46.99) 121.4,46.85 121.25,46.65 arc(121.15,46.57) 121.02,46.54 120.78,46.54 arc(120.49,46.6) 120.24,46.77 119.78,47.23 119.71,47.38 119.56,47.54 119.37,47.54 119.24,47.67 v1(119.24,47.93)
DDR4_DIMM_CH2_CK_N1: length 87.1
  L12_SIG4 w0.081: v1(126.17,49.93) 126.17,49.64 126.04,49.51 125.85,49.51 125.69,49.36 125.57,49.06 125.57,48.79 125.66,48.58 125.83,48.4 126.03,48.32 126.21,48.32 126.41,48.24 126.66,47.93 126.89,47.82 127.08,47.82 127.25,47.75 127.36,47.63 127.41,47.51 127.41,47.33 127.3,47.05 127.3,46.77 127.41,46.5 127.41,46.33 127.3,46.06 127.3,45.79 127.43,45.48 127.43,45.36 127.3,45.05 127.3,44.78 127.42,44.48 127.42,44.36 127.3,44.06 127.3,43.81 127.41,43.52 127.41,43.33 127.3,43.04 127.3,42.81 127.42,42.51 127.42,42.36 127.3,42.06 127.3,41.81 127.39,41.59 127.69,41.28 128.09,41.12 128.39,40.81 128.39,39.33 129.17,38.55 129.17,38.24 128.55,37.62 128.55,37.19 129.17,36.56 129.17,35.71 129.48,35.4 129.48,35.13 129.33,34.98 128.7,34.98 128.01,34.7 127.26,33.95 127.26,33.27 127.72,32.82 128.58,32.82 129.46,33.69 131.51,33.69 131.78,33.43 131.78,33.27 131.37,32.86 131.37,32.25 131.82,31.8 133.3,31.8 133.44,31.66 133.44,30.9 133.34,30.8 131.2,30.8 131.07,30.92 131.07,31.65 130.76,31.96 130.04,31.96 129.74,31.66 129.74,31.09 129.65,31 127.01,31 126.63,30.62 126.63,29.92 127.03,29.52 131.75,29.52 132.3,28.97 133.26,28.97 133.98,29.69 135.29,29.69 136.46,28.52 136.46,27.17 136.81,26.81 137.52,26.81 137.87,27.17 137.87,28.93 138,29.07 138.32,29.07 138.84,28.54 138.84,27.03 137.02,25.21 136.62,25.21 136.31,25.51 136.31,26.2 135.36,27.15 135.36,28.52 135.07,28.81 134.15,28.81 133.86,28.52 133.86,27.09 133.66,26.9 133.16,26.9 131.15,28.91 129.44,28.91 128.78,28.26 128.18,28.26 127.52,28.92 126.73,28.92 125.65,27.84 125.65,26.44 126.4,25.69 128.51,25.69 129.02,26.2 129.02,26.32 129.97,27.26 130.23,27.26 130.34,27.16 130.34,26.65 130.11,26.42 v1(129.94,26.42)
DDR4_DIMM_CH2_CK_P0: length 88.5
  L16_SIG6 w0.079: v1(130.79,32.42) 130.49,32.12 130.49,31.96 130.61,31.84 131.01,31.84 131.38,32.21 131.38,32.35 131.3,32.43 131.3,32.57 131.39,32.67 131.53,32.67 131.61,32.58 131.75,32.58 131.99,32.82 132.99,32.82 133.28,33.12 133.28,33.7 133.04,33.95 130.92,33.95 130.51,33.53 130.09,33.53 129.68,33.95 129.24,33.95 129.09,33.8 129.09,32.12 128.78,31.81 127,31.81 125.72,33.08 123.69,33.08 123.36,33.41 123.36,33.84 123.7,34.17 125.98,34.17 126.13,34.32 126.13,34.83 126.35,35.05 127.04,35.05 127.27,34.83 127.27,33.37 127.35,33.28 127.82,33.28 127.91,33.37 127.91,34.78 128.17,35.04 133.26,35.04 133.36,35.14 133.36,35.73 133.27,35.82 127.66,35.82 127.44,36.04 127.44,36.81 127.66,37.04 133.26,37.04 133.36,37.14 133.36,37.71 133.27,37.8 129.38,37.8 129.14,38.05 129.14,38.82 129.36,39.04 133.59,39.04 133.74,39.18 133.74,39.71 133.62,39.82 129.34,39.82 128.97,40.19 128.97,40.65 129.34,41.01 133.18,41.01 133.35,41.19 133.35,41.53 133.49,41.87 133.49,41.94 arc(133.46,42.06) 133.4,42.16 133.35,42.21 arc(133.23,42.29) 133.09,42.32 133.05,42.32 arc(132.93,42.29) 132.83,42.21 132.68,42.01 arc(132.5,41.87) 132.27,41.82 132.2,41.82 arc(131.97,41.87) 131.79,42.01 131.64,42.21 arc(131.54,42.29) 131.41,42.32 131.32,42.32 arc(131.2,42.29) 131.1,42.21 130.95,42.01 arc(130.76,41.87) 130.54,41.82 130.51,41.82 arc(130.28,41.86) 130.09,41.99 130.06,42.01 arc(129.94,42.2) 129.89,42.43 129.89,42.58 130.01,42.87 130.01,43 129.89,43.28 129.89,43.57 130.01,43.85 130.01,44.02 129.89,44.3 129.89,44.56 130.01,44.85 130.01,44.95 arc(129.99,45.07) 129.92,45.18 129.86,45.24 arc(129.78,45.29) 129.68,45.31 129.59,45.31 arc(129.37,45.37) 129.19,45.51 129.04,45.7 arc(128.94,45.79) 128.81,45.81 128.72,45.81 arc(128.5,45.87) 128.32,46.01 128.17,46.2 arc(128.07,46.28) 127.94,46.31 127.85,46.31 arc(127.63,46.37) 127.45,46.51 127.3,46.7 arc(127.2,46.78) 127.07,46.81 126.99,46.81 arc(126.77,46.87) 126.59,47.01 126.44,47.2 arc(126.34,47.28) 126.21,47.31 125.32,47.31 125.23,47.22 125.23,47.04 125.13,46.95 124.99,46.95 124.89,47.04 124.89,47.22 124.8,47.31 124.55,47.31 arc(124.36,47.28) 124.21,47.17 124.04,47.01 arc(123.83,46.86) 123.58,46.81 123.53,46.81 arc(123.3,46.87) 123.12,47.01 122.97,47.2 arc(122.87,47.28) 122.74,47.31 122.66,47.31 arc(122.53,47.28) 122.43,47.2 122.28,47.01 arc(122.1,46.87) 121.88,46.81 121.8,46.81 arc(121.68,46.78) 121.58,46.7 121.43,46.51 arc(121.25,46.37) 121.02,46.31 120.78,46.31 arc(120.4,46.39) 120.08,46.6 119.59,47.1 119.52,47.25 119.46,47.31 119.34,47.31 119.24,47.21 v1(119.24,46.93)
DDR4_DIMM_CH2_CK_P1: length 86.6
  L12_SIG4 w0.081: v1(126.17,48.93) 126.17,49.2 126.09,49.28 125.94,49.28 125.89,49.23 125.8,49.01 125.8,48.84 125.85,48.71 125.96,48.59 126.07,48.55 126.26,48.55 126.55,48.43 126.81,48.11 126.94,48.05 127.12,48.05 127.38,47.94 127.56,47.76 127.64,47.56 127.64,47.28 127.53,47.01 127.53,46.82 127.64,46.55 127.64,46.29 127.53,46.01 127.53,45.84 127.65,45.53 127.65,45.32 127.53,45.01 127.53,44.83 127.65,44.53 127.65,44.31 127.53,44.01 127.53,43.86 127.64,43.57 127.64,43.28 127.52,42.99 127.52,42.85 127.65,42.55 127.65,42.31 127.52,42.01 127.52,41.86 127.58,41.72 127.69,41.61 128.32,41.35 128.72,40.95 128.72,39.41 129.49,38.64 129.49,38.11 128.87,37.48 128.87,37.33 129.5,36.7 129.5,35.84 129.81,35.53 129.81,35 129.47,34.66 128.76,34.66 128.2,34.42 127.59,33.82 127.59,33.41 127.85,33.14 128.44,33.14 129.32,34.02 131.64,34.02 132.1,33.56 132.1,33.13 131.69,32.72 131.69,32.39 131.95,32.13 133.44,32.13 133.77,31.8 133.77,30.77 133.48,30.48 131.06,30.48 130.75,30.79 130.75,31.51 130.63,31.64 130.17,31.64 130.07,31.53 130.07,30.96 129.78,30.68 127.14,30.68 126.95,30.48 126.95,30.06 127.16,29.84 131.89,29.84 132.44,29.29 133.12,29.29 133.84,30.01 135.43,30.01 136.78,28.66 136.78,27.3 136.94,27.14 137.38,27.14 137.54,27.3 137.54,29.07 137.86,29.39 138.46,29.39 139.17,28.68 139.17,26.9 137.16,24.89 136.48,24.89 135.99,25.38 135.99,26.06 135.04,27.01 135.04,28.38 134.94,28.48 134.28,28.48 134.18,28.38 134.18,26.96 133.8,26.57 133.03,26.57 131.02,28.58 129.57,28.58 128.92,27.93 128.05,27.93 127.38,28.59 126.87,28.59 125.98,27.7 125.98,26.57 126.54,26.01 128.37,26.01 128.7,26.34 128.7,26.45 129.83,27.59 130.37,27.59 130.66,27.3 130.66,26.55 v1(130.79,26.42)
DDR4_DIMM_CH2_CKE0: length 88.1
  L14_SIG5 w0.081: v1(142.69,32.42) 141.62,32.42 141.04,31.83 139.94,31.83 139.66,31.55 139.66,30.91 139.57,30.82 138.99,30.82 138.9,30.91 138.9,31.52 138.81,31.61 138.65,31.61 138.56,31.52 138.56,30.31 138.47,30.22 138.32,30.22 138.23,30.31 138.23,31.5 138.14,31.59 137.98,31.59 137.89,31.5 137.89,30.29 137.8,30.2 137.64,30.2 137.56,30.29 137.56,31.87 137.47,31.96 137.31,31.96 137.22,31.87 137.22,31.12 137,30.9 136.55,30.9 136.33,31.12 136.33,31.83 136.24,31.92 136.07,31.92 135.99,31.83 135.99,31.09 135.84,30.94 133.84,30.94 133.75,31.04 133.75,31.36 133.65,31.46 133.51,31.46 133.41,31.36 133.41,31.04 133.31,30.94 133.17,30.94 133.08,31.04 133.08,31.36 132.98,31.46 132.84,31.46 132.74,31.36 132.74,31.04 132.64,30.94 132.5,30.94 132.4,31.04 132.4,31.36 132.31,31.46 132.17,31.46 132.07,31.36 132.07,31.04 131.97,30.94 131.58,30.94 130.35,32.17 130.23,32.17 130.11,32.05 130.11,31.93 130.91,31.13 130.91,31 130.78,30.87 130.65,30.87 129.52,32.01 129.52,32.3 129.41,32.4 128.86,32.4 127.64,33.62 127.64,33.92 127.53,34.04 123.96,34.04 123.87,34.13 123.87,34.29 123.96,34.37 127.6,34.37 127.69,34.46 127.69,34.62 127.6,34.71 123.69,34.71 123.6,34.8 123.6,34.96 123.69,35.04 127.49,35.04 127.71,35.27 127.71,35.79 127.48,36.02 126.8,36.02 126.65,35.86 126.65,35.56 126.56,35.47 126.4,35.47 126.31,35.56 126.31,36.3 126.22,36.39 126.06,36.39 125.98,36.3 125.98,35.64 125.89,35.55 125.73,35.55 125.64,35.64 125.64,35.72 125.54,35.82 123.6,35.82 123.51,35.91 123.51,36.07 123.6,36.15 125.55,36.15 125.64,36.24 125.64,36.4 125.55,36.49 123.66,36.49 123.57,36.58 123.57,36.74 123.66,36.83 124.39,36.83 124.48,36.91 124.48,37.08 124.39,37.17 124.16,37.17 124.07,37.26 124.07,37.42 124.16,37.51 124.71,37.51 124.81,37.4 124.81,37.01 124.92,36.9 125.48,36.9 125.7,37.11 125.7,37.61 125.39,37.92 124.99,37.92 124.89,38.02 124.89,38.93 124.79,39.03 124.66,39.03 124.56,38.93 124.56,38.02 124.46,37.92 123.46,37.92 122.98,38.4 122.37,38.4 121.97,38 120.73,38 120.64,38.09 120.64,38.33 120.73,38.41 121.15,38.41 121.24,38.5 121.24,38.66 121.15,38.75 120.63,38.75 120.54,38.84 120.54,39 120.63,39.08 121.66,39.08 121.75,39.17 121.75,39.33 121.66,39.42 120.6,39.42 120.5,39.52 120.5,39.66 120.6,39.76 120.96,39.76 121.06,39.85 121.06,39.99 120.96,40.09 120.6,40.09 120.5,40.19 120.5,40.33 120.6,40.43 120.96,40.43 121.06,40.52 121.06,40.66 120.96,40.76 120.6,40.76 120.5,40.86 120.5,41 120.6,41.1 120.96,41.1 121.06,41.19 121.06,41.35 120.93,41.48 120.67,41.48 120.54,41.62 120.54,45.63 120.25,45.92 119.99,45.92 119.48,46.43 v1(118.38,46.43)
DDR4_DIMM_CH2_CKE1: length 88.9
  L14_SIG5 w0.081: v1(118.38,47.43) 117.61,46.66 116.88,46.66 116.26,47.28 116.26,47.99 115.95,48.3 115.62,48.3 115.4,48.08 115.4,47.78 115.58,47.59 115.58,47.27 115.4,47.09 115.4,46.77 115.57,46.6 115.57,46.24 115.4,46.08 115.4,45.77 115.64,45.53 115.71,45.53 116.15,45.1 116.15,44.32 116.54,43.93 116.84,43.93 117.06,43.71 117.06,41.51 117.15,41.41 117.49,41.41 117.59,41.32 117.59,41.18 117.49,41.08 116.85,41.08 116.76,40.98 116.76,40.84 116.85,40.74 117.49,40.74 117.59,40.64 117.59,40.51 117.49,40.41 117.1,40.41 117,40.31 117,40.17 117.1,40.07 117.49,40.07 117.59,39.97 117.59,39.84 117.49,39.74 117.12,39.74 117.02,39.64 117.02,39.5 117.12,39.4 117.49,39.4 117.59,39.3 117.59,39.16 117.49,39.07 116.88,39.07 116.79,38.97 116.79,38.83 116.88,38.73 117.49,38.73 117.59,38.63 117.59,38.49 117.49,38.4 117.09,38.4 116.99,38.3 116.99,38.16 117.09,38.06 117.49,38.06 117.59,37.96 117.59,37.82 117.49,37.73 117.12,37.73 117.02,37.63 117.02,37.49 117.12,37.39 117.49,37.39 117.59,37.29 117.59,37.15 117.49,37.05 116.68,37.05 116.58,36.96 116.58,36.82 116.68,36.72 117.49,36.72 117.59,36.62 117.59,36.48 117.49,36.38 116.7,36.38 116.6,36.29 116.6,36.15 116.7,36.05 117.49,36.05 117.59,35.95 117.59,35.81 117.49,35.71 117.15,35.71 117.06,35.62 117.06,35.48 117.15,35.38 117.49,35.38 117.59,35.28 117.59,35.14 117.49,35.04 116.68,35.04 116.6,34.95 116.6,34.8 116.68,34.71 117.43,34.71 117.52,34.62 117.52,34.46 117.43,34.37 116.69,34.37 116.6,34.28 116.6,34.13 116.69,34.04 119.18,34.04 119.27,33.95 119.27,33.79 119.18,33.7 117.62,33.7 117.54,33.61 117.54,33.46 117.62,33.37 118.77,33.37 118.86,33.28 118.86,33.03 119.34,32.56 119.34,32.33 119.72,31.95 121.22,31.95 121.46,31.71 121.46,31.22 121.67,31.01 123.13,31.01 123.35,31.23 125.04,31.23 125.17,31.11 125.17,28.74 125.3,28.6 125.45,28.6 125.58,28.74 125.58,29.26 125.69,29.37 126.09,29.37 126.18,29.27 126.18,28.68 126.28,28.59 126.42,28.59 126.52,28.68 126.52,29.32 126.62,29.42 126.76,29.42 126.86,29.32 126.86,28.68 126.95,28.59 127.09,28.59 127.19,28.68 127.19,29.31 127.29,29.41 127.43,29.41 127.53,29.31 127.53,28.68 127.62,28.59 127.76,28.59 127.86,28.68 127.86,29.27 127.96,29.37 128.1,29.37 128.2,29.27 128.2,28.68 128.29,28.59 128.43,28.59 128.53,28.68 128.53,29.27 128.63,29.37 128.77,29.37 128.87,29.27 128.87,28.68 128.96,28.59 129.1,28.59 129.2,28.68 129.2,29.27 129.3,29.37 129.44,29.37 129.54,29.27 129.54,28.68 129.64,28.59 129.77,28.59 129.87,28.68 129.87,29.27 129.97,29.37 130.11,29.37 130.21,29.27 130.21,28.68 130.31,28.59 130.44,28.59 130.54,28.68 130.54,29.27 130.64,29.37 130.78,29.37 130.88,29.27 130.88,28.68 130.98,28.59 131.12,28.59 131.21,28.68 131.21,29.27 131.31,29.37 131.45,29.37 131.55,29.27 131.55,28.68 131.65,28.59 131.79,28.59 131.88,28.68 131.88,29.27 131.98,29.37 132.12,29.37 132.22,29.27 132.22,28.92 132.32,28.82 132.46,28.82 132.55,28.92 132.55,29.27 132.65,29.37 132.79,29.37 132.89,29.27 132.89,29.02 132.99,28.92 133.58,28.92 133.83,28.66 133.83,28.55 133.92,28.46 134.08,28.46 134.17,28.55 134.17,28.7 134.26,28.79 134.41,28.79 134.5,28.7 134.5,27.98 134.59,27.89 134.75,27.89 134.84,27.98 134.84,28.72 134.93,28.81 135.08,28.81 135.17,28.72 135.17,27.95 135.26,27.86 135.42,27.86 135.51,27.95 135.51,28.63 135.68,28.8 136.03,28.8 136.28,28.55 136.28,27.35 136.46,27.17 138.05,27.17 138.49,26.74 138.49,26.21 139,25.69 139.68,25.69 140,26.01 141.75,26.01 142.34,26.6 143.35,26.6 v1(143.54,26.42)
DDR4_DIMM_CH2_CS_N0: length 93.5
  L03_SIG1 w0.081: v4(117.19,32.42) 115.98,32.42 115.88,32.31 115.88,32.18 115.98,32.08 116.17,32.08 116.28,31.98 116.28,31.86 116.17,31.76 116.07,31.76 115.93,31.62 115.93,31.07 115.83,30.96 115.7,30.96 115.59,31.07 115.59,31.92 115.49,32.02 115.36,32.02 115.26,31.92 115.26,30.67 115.16,30.57 115.03,30.57 114.92,30.67 114.92,31.93 114.82,32.03 114.69,32.03 114.59,31.93 114.59,30.7 114.49,30.6 114.34,30.6 114.24,30.7 114.24,31.79 113.24,32.79 112.81,32.79 111.65,33.94 109.73,33.94 109.5,34.17 103.55,34.17 103.45,34.27 103.45,34.4 103.55,34.51 104.77,34.51 104.87,34.61 104.87,34.74 104.77,34.84 102.68,34.84 102.58,34.94 102.58,35.87 102.68,35.97 102.87,35.97 102.97,35.87 102.97,35.31 103.07,35.21 103.2,35.21 103.31,35.31 103.31,36.04 103.41,36.14 103.56,36.14 103.66,36.04 103.66,35.36 103.76,35.25 103.92,35.25 104.03,35.36 104.03,35.73 104.22,35.92 105,35.92 105.22,35.71 105.22,34.65 105.32,34.55 105.49,34.55 105.59,34.65 105.59,36.16 105.49,36.26 104.15,36.26 104.05,36.36 104.05,36.49 104.15,36.6 105.42,36.6 105.52,36.7 105.52,39.56 105.42,39.66 105.23,39.66 105.12,39.56 105.12,39.29 105.03,39.2 104.84,39.2 104.74,39.1 104.74,38.96 104.84,38.86 105.03,38.86 105.12,38.76 105.12,38.18 105.03,38.08 104.73,38.08 104.63,37.98 104.63,37.85 104.73,37.75 105.03,37.75 105.12,37.65 105.12,37.03 105.03,36.93 104.35,36.93 104.13,37.15 104.13,39.5 104.03,39.6 103.89,39.6 103.79,39.5 103.79,36.78 103.69,36.68 103.55,36.68 103.45,36.78 103.45,39.04 103.35,39.14 103.15,39.14 103.06,39.04 103.06,37.94 102.96,37.84 102.82,37.84 102.72,37.94 102.72,38.61 102.62,38.7 102.48,38.7 102.39,38.61 102.39,36.33 102.29,36.23 102.15,36.23 102.05,36.33 102.05,38.61 101.95,38.7 101.51,38.7 101.41,38.81 101.41,38.94 101.51,39.04 102.23,39.04 102.33,39.15 102.33,39.28 102.23,39.38 101.75,39.38 101.65,39.48 101.65,39.61 101.75,39.71 102.49,39.71 102.59,39.82 102.59,39.95 102.49,40.05 101.68,40.05 101.58,40.15 101.58,40.28 101.68,40.38 103.02,40.38 103.12,40.49 103.12,40.62 103.02,40.72 101.91,40.72 101.8,40.82 101.8,40.95 101.91,41.06 102.96,41.06 103.4,41.49 103.86,41.49 104.23,41.87 104.68,41.87 105.05,41.5 105.61,41.5 105.95,41.84 106.5,41.84 106.8,41.54 107.43,41.54 107.76,41.87 108.23,41.87 108.57,41.52 108.99,41.52 109.26,41.79 109.26,44.69 109.48,44.91 109.93,44.91 110.46,45.44 110.93,45.44 111.3,45.81 111.62,45.81 112.1,45.33 112.62,45.33 112.89,45.05 113.33,45.05 113.58,45.3 113.58,45.99 113.89,46.3 114.31,46.3 114.56,46.05 115.2,46.05 115.46,46.3 116.52,46.3 v4(116.65,46.43)
DDR4_DIMM_CH2_CS_N1: length 88.3
  L03_SIG1 w0.081: v4(112.94,32.42) 113.42,31.94 113.42,30.76 113.31,30.66 113.05,30.66 112.95,30.76 112.95,31.76 112.5,32.2 112.5,32.62 111.52,33.6 109.53,33.6 109.34,33.79 108.75,33.79 108.66,33.7 108.66,33.59 108.56,33.49 108.42,33.49 108.32,33.59 108.32,33.7 108.22,33.79 108.03,33.79 107.93,33.7 107.93,32.89 107.83,32.79 107.69,32.79 107.6,32.89 107.6,33.71 107.5,33.81 107.36,33.81 107.26,33.71 107.26,32.48 107.82,31.92 107.82,31.78 107.73,31.68 107.58,31.68 106.93,32.34 106.93,33.7 106.83,33.79 106.69,33.79 106.59,33.7 106.59,32.81 106.49,32.71 106.35,32.71 106.26,32.81 106.26,33.7 106.16,33.79 106.02,33.79 105.92,33.7 105.92,32.75 105.82,32.65 105.68,32.65 105.59,32.75 105.59,33.7 105.49,33.79 105.35,33.79 105.25,33.7 105.25,32.29 105.15,32.19 105.01,32.19 104.91,32.29 104.91,33.7 104.82,33.79 104.68,33.79 104.58,33.7 104.58,32.89 104.48,32.79 104.34,32.79 104.24,32.89 104.24,33.7 104.15,33.79 104.01,33.79 103.91,33.7 103.91,32.88 103.81,32.78 103.67,32.78 103.57,32.88 103.57,33.74 103.48,33.83 103.34,33.83 103.24,33.74 103.24,32.56 103.14,32.47 103,32.47 102.9,32.56 102.9,34.04 102.8,34.14 102.67,34.14 102.57,34.04 102.57,32.57 102.47,32.47 102.33,32.47 102.23,32.57 102.23,35.75 102.13,35.85 102,35.85 101.9,35.75 101.9,32.88 101.8,32.78 101.66,32.78 101.56,32.88 101.56,34.03 101.46,34.12 101.32,34.12 101.23,34.03 101.23,32.29 101.13,32.19 100.99,32.19 100.89,32.29 100.89,33.96 100.63,34.21 100.63,34.65 100.85,34.87 100.85,36.92 100.95,37.02 101.09,37.02 101.19,36.92 101.19,34.9 101.3,34.8 101.43,34.8 101.53,34.9 101.53,36.08 101.71,36.26 101.71,38.05 101.56,38.2 101.4,38.2 101.27,38.07 101.27,37.94 101.15,37.83 100.77,37.83 100.62,37.98 100.62,38.57 100.82,38.77 100.82,39.13 100.62,39.33 100.62,39.55 100.83,39.76 100.83,40.13 100.62,40.34 100.62,40.6 100.98,40.97 101.28,40.97 101.87,41.56 102.22,41.56 102.62,41.96 102.98,41.96 103.45,42.43 103.85,42.43 104.35,42.93 104.7,42.93 105.16,42.47 105.63,42.47 106.06,42.9 106.4,42.9 106.87,42.43 107.27,42.43 107.64,42.81 108.2,42.81 108.55,43.16 108.55,43.62 108.41,43.76 108.41,44.06 108.62,44.27 108.62,44.59 108.41,44.79 108.41,45.08 108.74,45.41 109.07,45.41 109.57,45.9 109.87,45.9 110.26,46.3 111,46.3 111.25,46.05 111.65,46.05 111.9,46.3 112.61,46.3 112.87,46.04 113.33,46.04 113.84,46.55 114.42,46.55 114.67,46.8 115.15,46.8 115.4,46.55 116.17,46.55 116.41,46.8 116.86,46.8 117.36,47.31 117.66,47.31 118.17,46.8 118.8,46.8 119.17,46.43 v4(120.11,46.43)
DDR4_DIMM_CH2_CS_N2: length 89.9
  L03_SIG1 w0.081: v4(109.54,32.42) 109.54,31.17 108.29,29.92 105.41,29.92 105.09,29.6 105.09,27.08 104.86,26.85 104.86,25.24 104.75,25.14 104.6,25.14 104.5,25.24 104.5,26.49 104.4,26.59 104.25,26.59 104.15,26.49 104.15,25.16 104.05,25.06 103.92,25.06 103.82,25.16 103.82,25.91 103.71,26.02 103.58,26.02 103.48,25.91 103.48,25.21 103.38,25.1 103.25,25.1 103.14,25.21 103.14,25.96 103.04,26.06 102.91,26.06 102.81,25.96 102.81,25.27 102.71,25.17 99.48,25.17 99.38,25.27 99.38,25.43 99.48,25.54 102.14,25.54 102.32,25.72 102.32,26.62 101.97,26.97 101.97,27.85 101.87,27.94 101.73,27.94 101.63,27.85 101.63,26.76 101.53,26.66 101.4,26.66 101.3,26.76 101.3,27.84 101.2,27.94 101.06,27.94 100.96,27.84 100.96,26.86 100.86,26.76 100.73,26.76 100.63,26.86 100.63,27.86 100.53,27.96 100.39,27.96 100.29,27.86 100.29,26.89 100.19,26.79 100.05,26.79 99.96,26.89 99.96,27.88 99.86,27.98 99.72,27.98 99.62,27.88 99.62,26.89 99.52,26.79 99.38,26.79 99.29,26.89 99.29,27.89 99.19,27.99 99.05,27.99 98.95,27.89 98.95,26.82 98.85,26.72 98.71,26.72 98.62,26.82 98.62,27.98 98.52,28.07 98.38,28.07 98.28,27.98 98.28,26.75 98.18,26.65 98.04,26.65 97.94,26.75 97.94,30.6 98.27,30.93 98.27,31.76 98.01,32.02 98.01,32.67 98.57,33.23 98.57,35.64 98.89,35.95 98.89,42.61 99.23,42.95 99.54,42.95 100.04,43.45 100.42,43.45 100.91,43.94 101.21,43.94 101.72,44.45 102.12,44.45 102.67,45 103.05,45 103.46,45.42 103.79,45.42 104.31,45.94 104.79,45.94 105.26,46.41 105.6,46.41 106.15,46.95 106.43,46.95 106.9,47.43 107.25,47.43 107.81,47.99 108.13,47.99 108.58,48.43 109.03,48.43 109.48,48.88 109.9,48.88 110.32,48.46 110.84,48.46 111.26,48.88 111.62,48.88 112.1,48.41 112.52,48.41 112.94,48.82 113.41,48.82 113.83,48.4 114.34,48.4 114.68,48.05 115.31,48.05 115.56,48.3 116.09,48.3 116.34,48.05 117.02,48.05 117.26,48.3 117.67,48.3 118.17,47.8 118.68,47.8 118.92,47.55 119.46,47.55 119.96,47.05 120.27,47.05 120.58,47.36 120.58,48.17 120.83,48.42 121.07,48.42 121.55,48.9 121.55,49.14 v4(121.84,49.43)
DDR4_DIMM_CH2_CS_N3: length 90.3
  L03_SIG1 w0.081: v4(109.54,26.42) 109.54,25.39 108.39,24.25 105.14,24.25 104.9,24 102.89,24 102.79,23.91 102.79,23.77 102.89,23.67 104.71,23.67 104.81,23.57 104.81,23.43 104.71,23.33 102.55,23.33 102.46,23.43 102.46,23.91 102.36,24 100.55,24 100.45,23.91 100.45,23.77 100.55,23.67 101.9,23.67 102,23.57 102,23.43 101.9,23.33 99.98,23.33 99.88,23.43 99.88,23.91 99.78,24 97.66,24 97.56,23.91 97.56,23.77 97.66,23.67 99.19,23.67 99.28,23.57 99.28,23.43 99.19,23.33 97.43,23.33 96.36,24.4 96.36,25.47 96.46,25.57 96.77,25.57 96.87,25.67 96.87,25.81 96.77,25.91 96.46,25.91 96.36,26.01 96.36,26.14 96.46,26.24 96.77,26.24 96.87,26.34 96.87,26.48 96.77,26.58 96.46,26.58 96.36,26.68 96.36,27.33 96.46,27.43 97.16,27.43 97.26,27.53 97.26,27.67 97.16,27.77 96.46,27.77 96.36,27.87 96.36,28 96.46,28.1 97.13,28.1 97.23,28.2 97.23,28.34 97.13,28.44 96.46,28.44 96.36,28.54 96.36,28.68 96.46,28.77 97.12,28.77 97.22,28.87 97.22,29.01 97.12,29.11 96.46,29.11 96.36,29.21 96.36,29.35 96.46,29.44 97.12,29.44 97.22,29.54 97.22,29.68 97.12,29.78 96.46,29.78 96.36,29.88 96.36,30.02 96.46,30.11 97.07,30.11 97.17,30.21 97.17,30.35 97.07,30.45 96.46,30.45 96.36,30.55 96.36,30.69 96.46,30.79 96.77,30.79 96.87,30.88 96.87,31.02 96.77,31.12 96.46,31.12 96.36,31.22 96.36,31.36 96.46,31.46 97.02,31.46 97.12,31.55 97.12,31.69 97.02,31.79 96.46,31.79 96.36,31.89 96.36,32.66 97.13,33.43 97.13,38.62 97.56,39.05 97.56,40.91 97.13,41.33 97.13,43.57 97.57,44 97.83,44 98.29,44.47 98.73,44.47 99.26,45 99.59,45 100.05,45.46 100.41,45.46 100.89,45.95 101.3,45.95 101.78,46.44 102.14,46.44 102.65,46.95 103,46.95 103.48,47.44 103.87,47.44 104.39,47.96 104.76,47.96 105.23,48.44 105.61,48.44 106.15,48.97 106.54,48.97 107.06,49.49 107.39,49.49 107.88,49.98 108.21,49.98 108.68,50.46 109.09,50.46 109.55,50.91 109.93,50.91 110.38,50.47 110.74,50.47 111.2,50.93 111.62,50.93 112.07,50.48 112.59,50.48 113.03,50.92 113.39,50.92 113.86,50.45 114.17,50.45 114.7,49.92 115.13,49.92 115.64,49.42 115.97,49.42 116.36,49.81 116.86,49.81 117.36,50.31 117.71,50.31 118,50.02 118,49.28 118.22,49.05 118.53,49.05 119.02,49.54 119.56,49.54 119.88,49.85 120.32,49.85 120.76,50.3 121.71,50.3 v4(121.84,50.43)
DDR4_DIMM_CH2_DBI_N0: length 74.5
  L12_SIG4 w0.085: v1(136.56,48.93) 136.56,49.21 136.66,49.31 136.87,49.31 137.04,49.48 137.17,49.8 137.17,50.06 137.05,50.35 137.05,50.51 137.11,50.66 137.21,50.75 137.36,50.81 137.46,50.81 arc(137.68,50.86) 137.86,50.98 arc(137.93,51.06) 137.98,51.15 138.01,51.22 arc(138.02,51.25) 138.04,51.27 arc(138.09,51.31) 138.16,51.32 138.36,51.32 arc(138.54,51.36) 138.69,51.46 138.74,51.51 138.83,51.64 138.84,51.66 arc(138.85,51.68) 138.86,51.69 138.92,51.75 arc(138.99,51.8) 139.07,51.82 139.26,51.82 arc(139.33,51.8) 139.39,51.77 139.43,51.73 arc(139.46,51.68) 139.49,51.63 arc(139.55,51.52) 139.63,51.42 arc(139.75,51.34) 139.9,51.31 140.08,51.31 arc(140.29,51.35) 140.46,51.46 arc(140.5,51.52) 140.54,51.58 140.55,51.61 arc(140.59,51.68) 140.64,51.75 arc(140.72,51.8) 140.81,51.82 140.95,51.82 arc(141.15,51.86) 141.32,51.97 141.33,51.98 arc(141.37,52.03) 141.41,52.09 141.45,52.16 arc(141.56,52.27) 141.7,52.3 141.85,52.3 arc(141.98,52.33) 142.08,52.4 142.23,52.55 142.29,52.64 arc(142.45,52.77) 142.64,52.81 157.78,52.81 158.09,52.5 158.09,52.02 158.72,51.39 159.07,51.39 159.79,50.67 159.79,50.18 160.59,49.39 161.26,49.39 167.49,43.16 169.53,43.16 170.02,42.67 170.02,41.96 170.68,41.3 172.53,41.3 174.51,39.32 176.37,39.32 176.94,38.75 176.94,35.84 177.63,35.16 180.47,35.16 180.83,35.51 180.83,36.74 181.02,36.93 181.32,36.93 181.51,36.74 181.51,35.33 181.75,35.09 182.41,35.09 182.64,35.33 182.64,36.6 182.83,36.79 183.13,36.79 183.32,36.6 183.32,35.33 183.56,35.1 184.13,35.1 184.37,35.33 184.37,35.83 184.47,35.93 184.85,35.93 184.95,35.83 184.95,34.24 185.66,33.54 186.07,33.54 186.18,33.43 186.18,32.13 186.66,31.65 187.2,31.65 187.42,31.88 187.42,32.09 v1(187.74,32.42)
DDR4_DIMM_CH2_DBI_N1: length 65.7
  L14_SIG5 w0.079: v1(178.39,32.42) 178.07,32.1 178.07,31.89 177.83,31.65 177.23,31.65 176.92,31.96 176.92,34.85 176.48,35.29 175.83,35.29 175.23,35.89 170.5,35.89 167.84,38.55 167.84,39.36 166.07,41.14 164.49,41.14 160.51,45.12 155.61,45.12 155.38,45.35 155.38,45.93 155.61,46.16 159.81,46.16 159.94,46.29 159.94,46.62 159.81,46.75 154.27,46.75 153.99,47.02 153.99,48.61 153.78,48.83 146.17,48.83 144.16,46.81 142.57,46.81 arc(142.49,46.8) 142.41,46.74 142.15,46.47 arc(141.99,46.35) 141.79,46.31 141.71,46.31 arc(141.62,46.3) 141.55,46.24 141.29,45.97 arc(141.12,45.85) 140.93,45.81 140.84,45.81 arc(140.66,45.85) 140.51,45.96 140.26,46.23 arc(140.17,46.29) 140.06,46.31 139.98,46.31 arc(139.89,46.3) 139.81,46.24 139.56,45.97 arc(139.39,45.85) 139.2,45.81 139.11,45.81 arc(138.93,45.85) 138.78,45.96 138.52,46.23 arc(138.44,46.29) 138.33,46.31 138.24,46.31 arc(138.16,46.3) 138.08,46.24 137.82,45.97 arc(137.66,45.85) 137.46,45.81 137.39,45.81 137.3,45.79 137.2,45.75 137.12,45.68 137.06,45.52 137.06,45.33 137.17,45.05 137.17,44.82 137.04,44.5 136.86,44.31 136.66,44.31 136.56,44.21 v1(136.56,43.93)
DDR4_DIMM_CH2_DBI_N2: length 56.3
  L12_SIG4 w0.085: v1(136.56,41.93) 136.96,42.39 137.05,42.51 137.11,42.64 137.19,42.73 137.27,42.78 137.31,42.79 137.38,42.81 137.47,42.81 arc(137.66,42.85) 137.83,42.96 137.88,43.01 137.96,43.14 137.97,43.16 arc(137.98,43.18) 137.99,43.19 138.05,43.25 arc(138.12,43.3) 138.21,43.32 138.34,43.32 arc(138.54,43.36) 138.71,43.47 138.73,43.49 138.88,43.68 arc(139,43.77) 139.16,43.81 139.16,43.81 arc(139.4,43.85) 139.61,43.99 139.67,44.06 139.69,44.11 139.75,44.19 139.76,44.19 arc(139.89,44.28) 140.04,44.31 140.11,44.31 arc(140.18,44.3) 140.25,44.26 140.35,44.15 140.45,44.01 140.49,43.97 arc(140.67,43.85) 140.89,43.8 140.99,43.8 arc(141.11,43.83) 141.21,43.9 141.36,44.05 141.43,44.14 arc(141.58,44.27) 141.77,44.31 arc(141.9,44.29) 142.01,44.22 142.03,44.19 arc(142.09,44.13) 142.15,44.05 142.17,44.01 142.22,43.97 arc(142.38,43.86) 142.57,43.82 143.27,43.82 144.02,43.07 144.66,43.07 145.03,43.44 145.03,43.72 146.09,44.78 146.88,44.78 147.23,45.13 147.23,45.62 147.41,45.8 153.13,45.8 153.85,45.08 154.5,45.08 158.02,41.56 158.02,39.19 157.76,38.93 157.76,37.81 158.74,36.83 163.95,36.83 164.05,36.72 164.05,35.99 163.73,35.66 163.28,35.66 162.89,36.04 160.25,36.04 160,35.79 160,34.81 160.24,34.57 164.15,34.57 164.99,35.41 165.58,35.41 166.19,34.81 166.19,34.09 166.58,33.7 167.37,33.7 167.5,33.57 167.5,31.95 167.85,31.6 168.43,31.6 168.73,31.9 168.73,32.11 v1(169.04,32.42)
DDR4_DIMM_CH2_DBI_N3: length 54.4
  L14_SIG5 w0.079: v1(130.5,41.43) 130.5,41.72 130.57,41.79 130.69,41.79 130.81,41.67 131.05,41.1 132.04,40.11 132.36,40.11 133.64,38.82 143.88,38.82 145.14,40.08 145.28,40.08 145.59,39.77 145.59,39.63 145.28,39.33 145.28,38.16 145.18,38.05 143.3,38.05 142.96,37.72 142.96,37.13 143.3,36.8 145.38,36.8 147.83,34.34 154.05,34.34 154.31,34.6 154.31,36.12 154.44,36.25 154.9,36.25 155.02,36.12 155.02,34.6 155.28,34.34 155.93,34.34 156.19,34.6 156.19,37.69 156.32,37.81 156.88,37.81 157.01,37.69 157.01,37.09 157.27,36.83 157.9,36.83 158.01,36.72 158.01,36.2 157.84,36.03 157.25,36.03 157.01,35.78 157.01,34.6 157.27,34.34 158.09,34.34 158.29,34.14 158.29,31.94 158.59,31.64 159.12,31.64 159.38,31.91 159.38,32.16 v1(159.64,32.42)
DDR4_DIMM_CH2_DBI_N4: length 44.1
  L16_SIG6 w0.079: v1(124.44,43.93) 124.44,44.17 124.54,44.28 124.69,44.28 124.73,44.23 124.81,44.04 124.81,43.82 124.7,43.55 124.7,43.3 124.81,43.03 124.81,42.83 124.69,42.53 124.69,42.33 124.82,42.02 124.82,41.84 124.7,41.56 124.7,41.44 124.6,41.34 124.43,41.34 124.34,41.24 124.34,41.11 124.43,41.01 124.6,41.01 124.7,40.91 124.7,40 123.74,39.05 123.22,39.05 122.22,38.05 122.22,37.7 120.58,36.06 119.81,36.06 118.81,35.05 114.62,35.05 113.49,33.93 110.07,33.93 109.6,33.45 105.93,33.45 105.37,32.89 105.37,32.3 105.68,31.99 105.68,31.14 106.4,30.43 106.4,28.06 106.3,27.96 105.91,27.96 105.81,28.06 105.81,29.77 105.58,30.01 105,30.01 104.77,29.77 104.77,28.06 104.67,27.96 104.25,27.96 104.14,28.06 104.14,31.31 104.24,31.41 104.34,31.41 104.44,31.51 104.44,31.65 104.34,31.74 104.24,31.74 104.14,31.84 104.14,32.12 v1(104.44,32.42)
DDR4_DIMM_CH2_DBI_N5: length 51.7
  L12_SIG4 w0.085: v1(95.09,32.42) 94.77,32.09 94.77,31.93 94.93,31.77 95.24,31.77 95.82,32.36 95.82,32.49 95.71,32.61 95.71,32.74 95.82,32.85 95.95,32.85 96.07,32.74 96.2,32.74 96.54,33.07 100.54,33.07 100.86,32.75 100.86,32.23 100.38,31.74 100.38,31.22 99.34,30.18 99.34,30.03 99.71,29.66 99.85,29.66 101.81,31.62 102.14,31.62 102.56,31.21 102.56,30.87 101.07,29.38 101.07,29.24 101.38,28.93 101.52,28.93 105.68,33.08 109.24,33.08 109.61,32.71 119.3,32.71 121.6,35.02 121.98,35.02 122.24,35.28 122.24,35.94 122.94,36.63 122.94,37.66 123.32,38.04 123.73,38.04 124.06,38.37 124.06,38.67 123.96,38.77 123.8,38.77 123.71,38.86 123.71,39 123.8,39.1 123.96,39.1 124.06,39.2 124.06,39.95 124.68,41.45 124.68,41.56 124.7,41.58 124.81,41.85 124.81,42.04 124.73,42.24 124.68,42.29 124.62,42.31 124.54,42.31 124.44,42.21 v1(124.44,41.93)
DDR4_DIMM_CH2_DBI_N6: length 58
  L12_SIG4 w0.085: v1(118.38,41.43) 118.38,41.71 118.28,41.81 118.18,41.81 118.08,41.72 117.94,41.37 117.94,40.85 116.92,39.83 116.31,39.83 115.93,40.21 115.59,40.21 115.21,39.83 114.58,39.83 114.21,40.2 113.86,40.2 113.49,39.83 112.83,39.83 112.44,40.22 112.1,40.22 111.98,40.09 111.98,39.91 111.72,39.65 111.2,39.65 110.94,39.91 110.94,40.11 110.8,40.25 110.51,40.25 110.09,39.83 109.38,39.83 108.98,40.23 108.64,40.23 108.24,39.83 107.73,39.83 107.34,40.22 106.9,40.22 106.51,39.83 100.8,39.83 100.42,40.21 99.98,40.21 99.59,39.83 99.05,39.83 98.69,40.19 97.5,40.19 97.14,39.83 93.79,39.83 91.63,37.66 91.63,37.24 90.95,36.57 90.58,36.57 90.25,36.9 90.07,36.9 89.83,36.66 89.83,36.48 90.16,36.15 90.16,35.78 88.59,34.2 88.2,34.2 87.59,34.81 86.82,34.81 86.3,34.3 86.3,34.15 86.58,33.88 86.72,33.88 86.98,34.13 87.39,34.13 87.73,33.79 87.73,33.35 87.14,32.76 87.14,32.08 87.47,30.41 87.47,29.19 87.24,28.96 86.3,28.96 85.88,28.53 85.44,28.53 85.07,28.9 85.07,29.74 85.35,30.02 86.2,30.02 86.3,30.12 86.3,30.57 86.2,30.67 85.7,30.67 85.47,30.91 85.47,31.61 86.09,32.23 86.09,32.87 85.8,33.16 85.48,33.16 85.37,33.05 85.37,32.76 v1(85.72,32.42)
DDR4_DIMM_CH2_DBI_N7: length 73
  L16_SIG6 w0.079: v1(118.38,44.43) 118.38,44.71 118.48,44.81 118.58,44.81 118.67,44.72 118.75,44.52 118.75,44.36 118.64,44.07 118.64,43.82 118.75,43.54 118.75,43.36 118.69,43.21 118.59,43.11 arc(118.51,43.06) 118.42,43.04 118.34,43.04 arc(118.11,42.99) 117.93,42.84 117.78,42.65 arc(117.68,42.57) 117.55,42.54 117.47,42.54 arc(117.24,42.49) 117.06,42.34 116.91,42.15 arc(116.81,42.07) 116.69,42.04 116.61,42.04 arc(116.38,41.99) 116.2,41.84 116.05,41.65 arc(115.95,41.57) 115.83,41.54 115.74,41.54 arc(115.61,41.57) 115.51,41.65 115.36,41.85 arc(115.18,41.99) 114.96,42.04 114.9,42.04 arc(114.65,41.99) 114.45,41.83 114.37,41.72 arc(114.37,41.72) 114.36,41.72 113.68,41.03 112.92,41.03 112.82,41.13 112.82,41.32 112.72,41.42 112.59,41.42 112.49,41.32 112.49,41.13 112.39,41.03 107.69,41.03 106.72,40.05 105.28,40.05 103.31,38.08 102.58,38.08 101.1,36.6 100.89,36.6 99.34,35.05 98.93,35.05 97.93,34.05 94.98,34.05 93.41,32.49 93.41,31.99 93.8,31.6 93.8,31.24 92.68,30.12 86.98,30.12 86.75,30.35 86.75,30.59 86.98,30.82 91.74,30.82 92.39,31.47 92.39,31.99 91.33,33.05 86.95,33.05 85.62,31.72 85.62,29.32 85.52,29.22 84.93,29.22 84.83,29.32 84.83,31.94 83.72,33.05 77.57,33.05 77.43,32.91 77.29,32.91 77.2,33 77.07,33 76.97,32.9 76.97,32.76 77.06,32.67 77.06,32.53 76.35,31.83 76.17,31.83 76.07,31.93 76.07,32.09 v1(76.39,32.42)
DDR4_DIMM_CH2_DBI_N8: length 42
  L12_SIG4 w0.085: v1(150.29,32.42) 150.03,32.16 150.03,31.91 149.8,31.67 149.43,31.67 148.27,32.83 147.41,32.83 146.42,33.82 146.42,34.65 146.25,34.82 145.9,34.82 145.7,34.62 145.7,33.97 145.46,33.73 144.82,33.73 144.22,34.33 144.22,34.66 144.61,35.05 144.61,35.34 144.52,35.43 143.3,35.43 143.21,35.34 143.21,34.93 142.95,34.67 142.4,34.67 142.14,34.93 142.14,35.65 142.05,35.74 141.6,35.74 141.51,35.65 141.51,34.88 141.23,34.61 140.77,34.61 140.16,35.22 139.85,35.22 139.24,34.61 136.55,34.61 136.25,34.91 136.25,35.48 136.48,35.72 138.45,35.72 138.56,35.82 138.56,36.2 138.45,36.3 138.04,36.3 137.78,36.57 137.78,37.07 137.65,37.2 137.32,37.2 137.13,37.01 137.13,36.6 136.89,36.37 136.33,36.37 135.89,36.81 135.55,36.81 135.13,36.39 134.77,36.39 134.36,36.8 134.36,37.59 134.17,37.78 134.17,38.12 134.36,38.31 134.36,38.51 134.06,38.81 133.67,38.81 131.95,40.52 131.63,41.3 131.63,41.58 131.74,41.86 131.74,42 131.63,42.28 131.63,42.55 131.74,42.82 131.74,43.01 131.68,43.15 131.59,43.24 131.4,43.32 131.24,43.32 131.01,43.42 130.87,43.56 130.76,43.82 130.76,44.06 130.88,44.35 130.88,44.52 130.8,44.71 130.72,44.8 130.6,44.8 130.5,44.7 v1(130.5,44.43)
DDR4_DIMM_CH2_DQ0: length 77.5
  L12_SIG4 w0.089: v1(133.97,50.43) 134.18,50.21 134.18,49.87 134.52,49.53 135,49.53 135.29,49.82 135.29,50.44 135.46,50.86 135.46,51.01 135.32,51.35 135.32,51.52 135.37,51.65 135.64,51.92 135.87,51.92 136.33,52.37 136.69,52.37 137.21,52.89 137.54,52.89 138.08,53.43 138.44,53.43 138.82,53.81 139.51,53.81 139.77,53.55 140.34,53.55 140.71,53.93 141.01,53.93 141.5,54.42 141.87,54.42 142.55,55.09 148.14,55.09 148.97,55.92 153.01,55.92 153.12,55.8 153.12,55.08 153.24,54.97 153.4,54.97 153.52,55.08 153.52,55.8 153.63,55.92 153.8,55.92 153.91,55.8 153.91,55.08 154.03,54.97 154.19,54.97 154.31,55.08 154.31,55.8 154.42,55.92 154.96,55.92 155.53,55.34 159,55.34 159.65,54.69 159.65,54.07 160.56,53.16 169.68,46.96 169.92,46.71 169.92,46.04 170.59,45.37 171.34,45.06 172.34,44.05 174.51,43.16 175.44,42.22 176.3,41.86 178.63,41.86 180.75,40.98 181.18,40.55 181.18,40.39 180.88,40.09 180.88,39.93 181,39.81 181.16,39.81 181.81,40.46 181.97,40.46 182.09,40.35 182.09,40.18 181.82,39.92 181.82,39.75 182.85,38.72 184.21,38.72 184.88,38.45 187.87,35.46 187.87,34.39 187.97,34.29 188.16,34.29 188.26,34.39 188.26,34.51 188.38,34.62 188.54,34.62 188.65,34.51 188.65,33.56 188.76,33.45 188.95,33.45 189.05,33.56 189.05,33.87 189.16,33.99 189.33,33.99 189.44,33.87 v1(189.44,32.41)
