# Allegro board TS28247BC0_FM61_agilex_PCIe_DEVKIT_ADI_REVB1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N42040218: length 8.8
  TOP w0.149: U79.34 189.05,41.52 189.24,41.71 v1(189.64,41.71)
  L16_SIG6 w0.081: v1(190.11,48.72) 190.11,48.68 189.67,48.24 189.67,44.19 190.11,43.74 190.11,42.17 190.02,42.07 190.01,42.07 v1(189.64,41.71)
N42120524: length 2.4
  TOP w0.149: U47.6 196.06,62.24 v1(195.49,62.82)
  BOTTOM w0.149: v1(195.49,62.82) 196.1,63.43 R6114.2
N42120776: length 7.4
  TOP w0.149: U47.7 195.83,61.84 v1(195.56,62.11)
  L12_SIG4 w0.089: v1(195.56,62.11) 195.21,62.11 195,61.9 192.22,61.9 v1(190.34,63.78)
N42308013: length 2.9
  TOP w0.149: U46.25 231.63,21.22 230.82,20.4 C7761.1
N42308046: length 4.7
  TOP w0.149: U46.24 231.13,21.47 R6262.2 229.2,20.08 228.71,19.59 C7763.2
N42308122: length 2.7
  TOP w0.149: U46.27 232.63,21.43 232.85,21.21 R6263.1
N42308126: length 2.9
  TOP w0.149: U46.23 230.63,21.7 v1(230.54,21.61)
  BOTTOM w0.149: R6264.2 R6266.2 v1(230.54,21.61)
N42308130: length 1.7
  BOTTOM w0.149: R6271.2 230.55,22.48 C7764.2 R6266.1
N42308290: length 2.9
  TOP w0.149: U46.1 234.47,23.42 235.49,22.41 TP1005.1
N42308292: length 2.2
  TOP w0.149: U46.22 228.85,23.42 v1(228.75,23.52)
  BOTTOM w0.203: v1(228.75,23.52) 228.28,23.52 228.21,23.46 R6293.1
N42308326: length 1.2
  TOP w0.149: U46.3 234.93,24.42 v1(235.05,24.31)
N42531609: length 2.9
  TOP w0.149: R6291.2 230.28,37.1 C7778.1 229.04,37.1 228.58,37.56 U126.1
N42531612: length 2.8
  TOP w0.149: R6292.2 230.31,37.99 C7778.2 229.04,37.99 228.82,38.21 U126.2
N42533175: length 6.9
  TOP w0.149: U126.8 223.14,37.56 222.59,37.01 R6287.2 221.57,37.29 221.37,37.49 220.35,37.49 220.12,37.72 220.12,38.37 R6289.2
N42533585: length 4.4
  TOP w0.149: U126.7 222.21,38.21 222.03,38.03 R6288.2 R6290.2
N42744699:
  vias: v1(66.17,104.35) v1(66.19,103.65) v1(66.19,100.41) v1(66.17,99.65)
N42745359: length 3.2
  TOP w0.149: v1(145.68,102.69) 146.11,103.13 146.79,103.13 146.94,103.28 J2.234
  BOTTOM w0.149: v1(145.68,102.69) R793.2
N42746504:
  vias: v1(192.84,105.06)
N42837491: length 0.9
  TOP w0.149: R6262.1 229.75,18.3 C7762.2
N43345615: length 1
  BOTTOM w0.203: R6293.2 228.19,22.57 228.26,22.49 R6264.1
N43346477: length 0.9
  BOTTOM w0.203: R6294.2 58.68,58.26 R6067.1
N359525652: length 2.3
  BOTTOM w0.149: R161.1 33.03,90.93 Y1.3
N359847316:
  vias: v1(51.82,88.72)
N363486630: length 1
  BOTTOM w0.254: R830.2 C681.1

## Copper pours and planes (outline as drawn)
5V on TOP: 244.1,51.26 244.1,47.88 244.53,47.45 257.18,47.45 257.64,47.91 257.64,50.42 257.18,50.88 249.56,50.88 248.04,52.4 245.37,52.4 245.24,52.28 245.24,51.64 245.12,51.51 244.36,51.51
5V on BOTTOM: 249.56,42.75 251.09,42.75 251.34,43 251.34,45.29 251.09,45.54 249.56,45.54 249.31,45.29 249.31,43
5V on BOTTOM: 244.74,48.21 254.77,48.21 255.02,48.47 255.02,50.62 254.77,50.88 249.56,50.88 248.04,52.4 245.63,52.4 244.48,51.26 244.48,48.47
5V on L03_SIG1: 255.15,43.64 251.34,39.83 240.42,39.83 225.94,25.35 184.41,25.35 175.78,16.72 175.78,14.43 175.39,14.05 154.82,14.05 154.44,14.43 154.44,16.46 160.41,22.43 161.3,22.43 172.35,33.48 197.29,33.48 198.41,34.6 198.41,43.16 204.99,49.74 226.42,49.74 227.72,51.03 227.72,57.1 228.86,58.24 254.57,58.24 255.15,57.66
5V on L07_SIG3: 50.68,11.25 46.24,15.7 46.24,18.87 46.62,19.26 65.41,19.26 69.1,15.57 129.04,15.57 130.18,16.72 137.42,16.72 138.44,17.73 156.73,17.73 157.11,17.35 157.11,14.05 140.34,14.05 136.66,10.37 129.29,10.37 126.37,7.44 60.21,7.44 56.4,11.25
5V on L14_SIG5: 41.16,14.18 41.16,49.1 32.52,49.1 32.52,43.77 22.49,43.77 22.49,71.83 49.54,71.83 49.54,35.51 48.39,34.37 48.39,30.3 50.43,28.27 50.43,23.19 51.32,22.3 51.32,14.81 50.68,14.18
5V_AGND on TOP: 243.16,53.88 241.89,53.88 241.43,53.42 241.43,50.37 241.69,50.12 242.83,50.12 242.96,49.99 242.96,48.08 242.7,47.83 239.53,47.83 239.15,48.21 239.15,54.69 239.78,55.32 243.24,55.32 243.67,54.89 243.67,54.38
5V_AGND on BOTTOM: 243.72,55.2 243.97,54.94 243.97,54.43 243.85,54.31 243.47,54.31 242.7,53.55 242.7,53.29 242.45,53.29 242.07,52.91 242.07,52.4 242.7,51.77 242.7,50.37 242.96,50.12 242.96,48.08 242.7,47.83 239.53,47.83 239.15,48.21 239.15,54.43 239.91,55.2
5V_LDO1 on TOP: 252.1,42.12 249.55,42.12 249.42,41.99 249.42,39.15 249.55,39.02 250.79,39.02 250.96,39.19 250.96,40.21 252.1,41.35
5V_LDO1 on BOTTOM: 249.56,41.99 251.09,41.99 251.34,41.73 251.34,39.32 251.04,39.02 249.55,39.02 249.31,39.26 249.31,41.73
5V_LDO2 on BOTTOM: 25.87,42.23 25.87,43.39 25.79,43.47 25.79,46.18 26.04,46.43 28.58,46.43 28.58,44.66 28.96,44.27 28.96,43.37 27.9,43.37 26.76,42.23
12V_AUX on TOP: 252.56,93.98 252.56,92.08 253.5,91.14 253.5,83.31 255,81.82 264.27,81.82 265.64,83.19 265.64,97.34 264.55,98.43 256.12,98.43 255.48,97.79 255.48,96.75 254.01,95.28 254.01,94.03 252.61,94.03
12V_AUX on BOTTOM: 253.96,101.42 253.96,99.47 254.05,99.38 254.05,86.32 255.2,85.17 265.26,85.17 265.64,85.55 265.64,97.39 260.38,102.64 260.38,106.28 259.9,106.76 257.97,106.76 257.31,106.1 257.31,102.92 256.14,101.76 254.29,101.76
12V_G1 on TOP: 243.52,92.97 245.09,92.97 245.09,94.82 246.31,96.04 248.52,96.04 248.75,96.27 248.75,98.45 247.12,100.08 247.12,100.13 247.11,100.14 247.11,100.45 246.26,101.3 238.94,101.3 237.62,99.98 237.62,84.38 236.71,83.47 234.91,83.47 232.14,80.7 232.14,79.61 232.29,79.45 232.54,79.45 232.93,79.07 232.93,76.15 233.05,76.02 239.78,76.02 240.19,76.43 240.19,82.32 242.75,84.89 242.75,92.2
12V_G1 on TOP: outline of 89 points within 186.54,32.92 206.43,90.81
12V_G1 on TOP: 201.02,52.15 204.35,52.15 204.86,51.64 204.86,49.99 204.6,49.74 202.06,49.74 200.57,51.23 200.57,51.69
12V_G1 on BOTTOM: 200.82,49.61 200.26,50.17 200.26,50.42 200.08,50.6 197.92,50.6 197.72,50.4 197.72,49.94 197.37,49.58 196.63,49.58 195.76,50.45 195.76,50.96 195.31,51.41 193.61,51.41 193.4,51.62 193.4,52.66 193.56,52.81 195.33,52.81 195.76,52.38 205.77,52.38 206.15,52 206.15,51.06 205.85,50.75 204.2,50.75 203.05,49.61
12V_G1 on BOTTOM: 235.26,100.82 235.26,93.32 238.28,90.3 243.11,90.3 245.35,92.53 245.35,97.23 243.59,98.99 243.59,100.82 243.01,101.4 235.85,101.4
12V_G1 on BOTTOM: 234.32,74.12 234.32,75.26 233.31,75.26 233.18,75.39 233.18,76.91 233.31,77.04 234.58,77.04 234.7,76.91 234.7,76.53 234.96,76.28 239.02,76.28 239.15,76.41 239.15,82.12 238.59,82.68 230.97,82.68 229.24,80.95 229.24,68.15 229.37,68.02 233.23,68.02 233.55,68.34 233.55,69.05 233.31,69.29 233.31,73.66 233.64,73.99 234.2,73.99
12V_G1 on BOTTOM: 70.62,104.09 70.87,103.84 70.87,100.54 71.89,99.52 71.89,97.49 70.87,96.47 70.87,92.53 70.62,92.28 68.08,92.28 67.83,92.53 67.83,103.84 68.08,104.09
12V_G1 on BOTTOM: 192.64,70.79 192.16,71.28 192.16,74.68 192.95,75.47 206.08,75.47 206.48,75.06 206.48,71.15 206.13,70.79
12V_G1 on BOTTOM: 200.21,57.23 201.43,57.23 201.48,57.28 201.48,58.98 201.89,59.39 202.39,59.39 203.21,60.2 203.21,65.05 202.7,65.56 202.7,69.22 202.45,69.47 201.28,69.47 201.05,69.24 201.05,65.94 200.16,65.05 200.16,57.48 200.15,57.47 200.16,57.46 200.16,57.28
12V_G1 on L03_SIG1: 71.64,92.53 64.78,92.53 64.14,93.17 64.14,103.33 64.78,103.96 71.64,103.96 72.27,103.33 72.27,93.17
12V_G1 on L03_SIG1: 226.19,102.31 261.91,102.31 263.28,100.94 263.28,59.51 262.77,59.01 228.86,59.01 228.73,58.88 228.71,58.88 226.96,57.13 226.96,52.07 225.51,50.62 204.99,50.62 195.59,41.23 180.22,41.23 180.09,41.35 180.09,50.37 180.86,51.13 191.65,51.13 192.54,52.02 192.54,55.83 192.03,56.34 181.74,56.34 180.09,57.99 180.09,66.12 180.73,66.75 193.94,66.75 194.95,67.77 194.95,69.88 193.99,70.84 181.34,70.84 180.09,72.09 180.09,78.44 180.22,78.44 181.03,79.25 193.86,79.25 195.21,80.6 195.21,81.74 194.95,81.99 193.05,81.99 192.67,82.37 192.67,83.09 192.49,83.26 182.89,83.26 182,84.15 182,87.25 184.61,89.87 193.3,89.87 194.57,91.14 216.67,91.14 217.05,91.52 217.05,94.69 217.69,95.33 222.64,95.33 223.15,95.84 223.15,98.38 223.91,99.14 223.91,100.03 ; 2 cut-outs
12V_G1 on L07_SIG3: 206.89,109.81 273.06,109.81 273.06,64.01 272.24,63.2 252.71,63.2 252.1,63.81 252.1,65.71 251.19,66.63 239.4,66.63 238.64,65.86 238.64,64.7 238.03,64.09 222.26,64.09 218.38,67.96 218.38,75.83 215.88,78.34 215.88,84.28 216.26,84.66 216.26,86.82 216.62,87.18 216.62,87.66 216.54,87.73 216.42,87.73 216.24,87.56 214.69,87.56 214.1,88.14 212.25,88.14 206.26,94.14 206.26,109.17 ; 4 cut-outs
12V_G1 on L09_PWR1: 65.79,109.81 65.79,100.15 69.98,100.15 69.98,102.44 110.75,102.44 113.29,104.98 146.31,104.98 150.12,101.17 192.54,101.17 197.49,96.22 226.32,96.22 226.32,68.66 229.5,68.66 229.5,63.96 237.37,63.96 237.55,64.14 237.55,68.94 237.9,69.29 245.4,69.29 245.63,69.52 245.63,79.83 273.06,79.83 273.06,109.81
12V_G1 on L10_PWR2: 65.79,109.81 65.79,100.15 69.98,100.15 69.98,102.44 110.75,102.44 113.29,104.98 146.31,104.98 150.12,101.17 192.54,101.17 197.49,96.22 226.32,96.22 226.32,68.66 229.5,68.66 229.5,63.96 238.89,63.96 238.89,67.13 245.5,67.13 245.5,79.83 273.06,79.83 273.06,109.81
12V_G1 on L12_SIG4: 258.33,102.69 272.42,102.69 273.06,102.06 273.06,23.95 272.42,23.32 265.95,23.32 265.31,23.95 265.31,38.56 262.77,41.1 262.77,97.61 262.14,98.25 258.33,98.25 257.69,98.88 257.69,102.06 ; 1 cut-out
12V_G1 on L16_SIG6: 195.56,20.02 186.24,20.02 184.67,21.59 184.67,34.6 185,34.93 185,43.18 184.67,43.51 184.67,50.32 185.1,50.75 185.1,59.67 184.67,60.1 184.67,66.45 185.02,66.8 185.02,74.96 184.67,75.31 184.67,79.23 184.92,79.48 184.92,87.23 185.43,87.73 192.64,87.73 194.57,85.8 211.92,85.8 213.52,87.4 236.4,87.4 239.22,84.58 239.22,70.3 238.64,70.06 237.88,69.29 227.21,69.29 221.5,63.58 221.5,46.43 220.86,45.8 198.51,45.8 196.6,43.89 196.6,21.06 ; 6 cut-outs
12V_G2 on TOP: 252.86,78.06 254.52,78.06 254.9,77.68 254.9,72.6 254.64,72.34 240.8,72.34 240.42,72.72 240.42,76.28 240.67,76.53 240.67,77.22 241.13,77.68 249.94,77.68 250.71,78.44 250.71,79.23 250.96,79.48 252.56,79.48 252.66,79.38 252.66,78.26
12V_G2 on TOP: 68.21,42.24 68.59,42.24 68.84,41.99 68.84,40.59 68.97,40.46 69.22,40.46 69.35,40.59 69.35,41.86 70.06,42.57 70.06,44.61 69.93,44.73 68.26,44.73 68.08,44.55 68.08,42.37
12V_G2 on TOP: 210.57,65.31 211.94,65.31 212.1,65.15 212.1,64.44 212.22,64.32 215.07,64.32 217.01,62.37 219.44,62.37 219.64,62.17 219.64,60.45 220.12,59.97 227.24,59.97 227.79,60.53 227.79,61.8 228.3,62.31 230.39,62.31 230.79,61.9 233.92,61.9 234.64,61.18 234.64,60.85 234.63,60.84 234.63,60.33 235.13,59.82 237.8,59.82 239,61.01 243.47,61.01 245.55,58.93 245.55,58.47 246.13,57.89 246.46,57.89 246.49,57.86 249.44,57.86 251.01,59.44 253.7,59.44 255.28,57.86 255.28,55.2 243.72,55.2 241.31,57.61 232.93,57.61 232.72,57.81 232.72,58.68 232.52,58.88 227.72,58.88 227.41,58.58 227.41,58.08 227.06,57.72 216.94,57.72 216.49,58.17 216.49,60.56 215.6,61.45 215.6,62.31 215.25,62.66 213.88,62.66 213.57,62.36 213.57,60.71 213.21,60.35 209.23,60.35 208.9,60.68 208.9,61.37 209.86,62.33 209.86,64.59
12V_G2 on TOP: 50.81,54.61 50.81,56.54 51.44,57.18 54.74,57.18 54.85,57.28 54.85,58.27 54.74,58.37 50.27,58.37 49.33,57.43 49.33,54.64 49.51,54.46 50.65,54.46
12V_G2 on TOP: 230.16,25.61 229.22,25.61 228.94,25.89 224.49,25.89 224.04,25.43 224.04,23.32 224.52,22.84 227.36,22.84 229.27,24.74 230.16,24.74 230.31,24.89 230.31,25.45
12V_G2 on TOP: 68.71,33.35 68.71,37.8 68.84,37.92 69.35,37.92 69.48,37.8 69.48,36.15 69.6,36.02 70.37,36.02 71.13,35.26 71.13,33.35 70.75,32.97 69.1,32.97
12V_G2 on TOP: 210.27,95.74 212.86,95.74 213.67,96.55 217.1,96.55 217.74,97.18 218.78,97.18 219.03,96.93 219.03,92.43 218.22,91.62 216.31,91.62 215.78,92.15 215.78,93.75 215.35,94.19 214.89,94.19 213.88,95.2 211.59,95.2 211.34,94.95 211.34,94.57 211.08,94.31 210.22,94.31 210.09,94.44 210.09,95.56
12V_G2 on TOP: 246.9,23.9 246.9,17.1 246.13,16.33 238.64,16.33 238.01,16.97 238.01,23.24 237.29,23.95 235.77,23.95 235.64,24.08 235.64,24.59 235.49,24.74 233.56,24.74 233.48,24.82 233.48,25.5 233.59,25.61 234.25,25.61 234.75,26.11 235.97,26.11 236.18,26.32 239.58,26.32 241.05,24.84 245.96,24.84
12V_G2 on BOTTOM: 211.84,65.43 209.91,65.43 209.81,65.33 209.81,62.28 209.46,61.93 209.46,61.24 209.1,60.89 209.1,60.58 209.2,60.48 210.57,60.48 211,60.91 212.78,60.91 213.11,61.24 213.11,61.75 213.8,62.44 215.22,62.44 215.58,62.08 215.58,58.98 215.78,58.78 220.4,58.78 220.68,59.06 220.68,61.55 217.86,64.37 212.91,64.37
12V_G2 on BOTTOM: 210.07,94.44 210.07,96.47 217.18,96.47 217.18,94.44 216.92,94.19 215.27,94.19 214.51,94.95 211.97,94.95 211.34,94.31 210.19,94.31
12V_G2 on BOTTOM: outline of 86 points within 196.22,71.35 216.34,85.32
12V_G2 on BOTTOM: 228.3,62.31 230.39,62.31 230.79,61.9 233.92,61.9 234.63,61.19 234.63,59.69 235.29,59.03 253.7,59.03 254.52,58.22 254.52,56.21 254.13,55.83 247.81,55.83 247.61,55.63 245.78,55.63 245.6,55.81 245.6,56.42 245.47,56.54 244.99,56.54 244.91,56.62 239.96,56.62 238.97,57.61 233.31,57.61 232.87,58.04 232.87,58.52 232.44,58.96 229.8,58.96 229.62,58.78 228.05,58.78 227.01,57.74 223.25,57.74 222.99,57.99 222.99,59.51 223.39,59.86 226.61,59.86 227.79,61.04 227.79,61.8
12V_G2 on BOTTOM: 208.67,39.45 208.29,39.07 207.91,39.07 207.65,38.81 207.65,36.78 208.03,36.4 212.35,36.4 212.73,36.78 212.73,38.69 211.34,40.08 211.34,42.6 211.59,42.85 212.05,42.85 212.2,42.7 212.2,42.09 212.55,41.73 213.88,41.73 214.13,41.48 214.13,35.89 213.49,35.26 199.19,35.26 197.54,36.91 195.43,36.91 194.83,37.52 194.83,39.65 195.38,40.21 199.14,40.21 199.78,40.85 199.78,42.34 200.18,42.75 200.69,42.75 201.18,42.27 201.18,39.96 200.54,39.32 200.16,39.32 199.91,39.07 199.91,37.16 200.16,36.91 201.68,36.91 202.06,37.29 202.06,38.81 202.62,39.37 203.26,39.37 203.59,39.7 203.59,42.32 203.97,42.7 204.68,42.7 204.99,42.4 204.99,39.91 204.4,39.32 203.99,39.32 203.72,39.04 203.72,37.16 204.1,36.78 205.62,36.78 206,37.16 206,39.09 206.48,39.58 207.02,39.58 207.27,39.83 207.27,42.32 207.68,42.73 208.34,42.73 208.67,42.4
12V_G2 on BOTTOM: 254.9,76.84 254.9,72.6 254.64,72.34 240.72,72.34 240.42,72.65 240.42,77.07 241.03,77.68 254.06,77.68
12V_G2 on BOTTOM: 236.1,37.16 244.48,37.16 245.37,36.27 245.37,29.19 246.31,28.25 246.31,26.55 244.1,24.34 244.1,19.33 245.09,18.34 245.09,17.58 244.36,16.84 238.64,16.84 238.13,17.35 238.13,17.73 237.88,17.99 237.88,23.57 237.62,23.83 237.04,23.83 236.35,24.51 236.35,25.96 236.66,26.27 237.9,26.27 238.92,27.28 238.92,30.48 238.01,31.4 236.51,31.4 236.3,31.6 236.3,33.98 235.85,34.43 235.85,36.91 ; 2 cut-outs
12V_G2 on BOTTOM: 49.64,56.37 51.09,56.37 51.77,55.68 51.77,53.37 52.28,52.86 54.11,52.86 54.24,52.99 54.24,54.49 54.31,54.56 54.67,54.56 54.82,54.41 54.82,53.47 55.48,52.81 58.25,52.81 60.26,50.8 62.49,50.8 62.92,50.37 62.92,45.14 63.91,44.15 70.01,44.15 71.66,42.5 76.21,42.5 77.35,41.35 77.35,34.5 75.95,33.1 62.29,33.1 60.97,34.42 60.97,48.62 60.33,49.25 59.09,49.25 58.43,49.91 56.14,49.91 55.86,50.19 55.86,51.95 55.56,52.25 54.31,52.25 54.16,52.1 51.39,52.1 50.83,52.66 50.83,54.1 50.58,54.36 49.69,54.36 49.44,54.61 49.44,56.16 ; 1 cut-out
12V_G2 on L03_SIG1: 194.85,39.14 194.85,38 195.28,37.57 196.88,37.57 197.37,38.05 197.37,39.19 197.19,39.37 195.08,39.37
12V_G2 on L03_SIG1, L07_SIG3: 241.59,20.25 241.59,19.13 241.71,19 242.4,19 242.55,19.15 242.55,20.3 242.42,20.42 241.76,20.42
12V_G2 on L03_SIG1, L07_SIG3: 238.06,22.15 238.06,17.53 238.72,16.87 242.27,16.87 243.06,17.66 244.46,17.66 244.58,17.78 244.58,17.91 244.05,18.44 244.05,24.54 243.92,24.67 243.26,24.67 243.14,24.54 243.14,18.75 242.96,18.57 241.15,18.57 241,18.72 241,21.49 240.88,21.62 239.71,21.62 239.48,21.85 239.48,22.13 239.35,22.25 238.16,22.25
12V_G2 on L05_SIG2: 264.04,75.39 264.04,40.46 246.26,40.46 246.26,32.21 245.37,31.32 245.37,16.79 223.2,16.79 220.48,19.51 220.48,67.77 239.53,67.77 239.53,79.2 262.14,79.2 262.14,75.39
12V_G2 on L07_SIG3: 194.8,39.17 194.8,38.05 195.28,37.57 196.88,37.57 197.37,38.05 197.37,39.17 197.16,39.37 195,39.37
12V_G2 on L09_PWR1: 67.55,32.64 182.25,32.64 186.85,37.24 202.39,37.24 204.91,39.75 204.91,44.61 203.82,45.7 197.16,45.7 194.7,43.23 177.22,43.23 175.98,41.99 175.98,35.92 175.24,35.18 72.52,35.18 70.92,36.78 70.92,44.05 70.29,44.68 66.86,44.68 66.35,44.17 66.35,33.84
12V_G2 on L09_PWR1: 246.01,79.45 246.01,52.63 247.5,52.63 248.01,52.12 248.01,49.33 247,48.31 246.01,48.31 246.01,26.75 222.51,26.75 222.51,22.43 242.64,22.43 242.74,22.34 244.22,22.34 244.31,22.43 255.4,22.43 255.4,57.86 255.02,57.86 255.02,79.45
12V_G2 on L10_PWR2: 245.88,79.45 245.88,56.17 245.74,56.03 245.74,55.59 245.88,55.45 245.88,26.75 222.51,26.75 222.51,22.43 242.89,22.43 242.96,22.36 244.23,22.36 244.3,22.43 255.4,22.43 255.4,57.86 255.02,57.86 255.02,79.45
12V_G2 on L14_SIG5: 210.83,97.23 219.23,97.23 221.5,94.97 226.47,94.97 229.95,91.49 236.3,91.49 238.31,89.49 238.31,87.15 243.25,82.21 253.66,82.21 255.4,80.47 255.4,67.52 254.13,67.52 254.13,37.8 244.99,37.8 244.99,14.05 222,14.05 222,22.38 211.39,33 198.97,33 194.49,37.47 194.49,43.69 197.31,46.51 211.06,46.51 213.93,43.64 225.48,43.64 227.59,45.75 227.59,49.46 225.31,51.74 225.31,56.77 224.54,57.53 216.87,57.53 215.48,58.93 209.38,58.93 208.57,59.74 208.57,61.78 208.97,62.18 208.97,64.47 208.99,64.48 208.99,67.43 195.97,80.44 195.97,84.66 197.01,85.7 210.34,85.7 216.19,91.54 216.19,93.07 215.09,94.16 209.96,94.16 209.96,96.37 ; 4 cut-outs
12V_GROUP1 on TOP (solid shape): 247.96,91.77 245.86,91.77 245.86,95.17 247.96,95.17
12V_GROUP1 on TOP (solid shape): 251.87,91.77 249.77,91.77 249.77,95.17 251.87,95.17
12V_GROUP1 on TOP: 244.36,92.03 244.28,91.95 244.28,91.42 243.67,90.81 243.67,88.65 243.72,88.6 244.05,88.6 244.1,88.65 244.1,90.5 244.28,90.68 244.79,90.68 244.96,90.5 244.96,88.65 245.02,88.6 245.37,88.6 245.4,88.62 245.4,90.53 245.63,90.76 245.63,91.14 246.45,91.96 248.91,91.96 249.26,91.62 249.26,90.99 249.28,90.96 249.28,89.16 249.49,88.95 252.64,88.95 252.71,89.03 252.71,90.93 252.08,91.57 252.08,95.28 252.33,95.53 253.68,95.53 255.2,97.06 255.2,97.95 256.45,99.19 256.45,102.82 256.29,102.97 255.15,102.97 255.1,103.03 254.11,103.03 253.52,102.44 247.78,102.44 247.56,102.21 247.56,99.9 249.1,98.35 249.1,96.04 248.27,95.2 246.34,95.2 245.83,94.69 245.83,92.48 245.37,92.03
12V_GROUP1 on BOTTOM: 245.63,96.57 245.63,89.36 246.13,88.85 252.84,88.85 253.68,89.69 253.68,102.19 253.25,102.62 247.91,102.62 247.45,102.16 247.45,96.85 247.33,96.73 245.78,96.73
12V_GROUP1 on L05_SIG2: 241.18,79.83 262.52,79.83 262.52,75.77 264.04,75.77 264.04,105.23 263.41,105.87 241.18,105.87 240.55,105.23 240.55,80.47
12V_GROUP1 on L12_SIG4: 247.61,102.59 247.12,102.11 247.12,98.58 245.93,97.39 245.93,91.16 247.66,89.44 252.41,89.44 253.3,90.33 253.3,96.62 254.6,97.93 254.93,97.93 255.18,98.17 255.18,101.93 254.52,102.59
12V_GROUP1 on L14_SIG5: 254.52,92.41 241.05,92.41 240.55,91.9 240.55,88.72 242.73,86.54 242.73,86.44 244.41,84.76 253.09,84.76 255.15,86.82 255.15,91.77
12V_GROUP2 on TOP (solid shape): 253.8,80.2 250.4,80.2 250.4,82.3 253.8,82.3
12V_GROUP2 on TOP (solid shape): 258.76,78.67 255.36,78.67 255.36,80.77 258.76,80.77
12V_GROUP2 on TOP: 246.92,79.81 246.93,79.8 254.15,79.8 254.16,79.78 254.41,79.78 255.53,78.67 259.09,78.67 259.52,79.1 259.52,81.46 259.42,81.56 254.72,81.56 252.86,83.42 252.86,88.29 252.58,88.57 247.36,88.57 245.6,86.81 245.6,80.75 246.54,79.81
12V_GROUP2 on BOTTOM: 246.64,82.81 246.74,82.71 248.47,82.71 248.67,82.5 248.67,81.59 248.47,81.38 248.47,80.57 249.1,80.57 250.12,79.56 254.46,79.56 255.35,78.67 258.6,78.67 259.72,79.78 259.72,80.11 259.8,80.19 260.71,80.19 260.71,80.65 260.79,80.72 262.67,80.72 262.82,80.57 262.82,80.24 262.9,80.17 263.56,80.17 263.56,81.64 263.05,82.15 253.88,82.15 253.3,82.73 253.3,88.37 253.07,88.6 246.74,88.6 246.64,88.5
GND on TOP: 205.24,100.41 202.06,100.41 202.06,101.04 201.94,101.17 201.94,103.08 202.06,103.2 204.99,103.2 204.99,102.44 205.24,102.19 ; 4 cut-outs
GND on TOP: 45.6,35.64 45.6,51.01 45.83,51.23 58.55,51.23 58.81,50.98 58.81,45.72 56.09,45.72 56.09,41.28 58.81,41.28 58.81,35.61 58.55,35.36 45.88,35.36 ; 3 cut-outs
GND on TOP: 206.82,24.42 206.82,21.97 206.31,21.46 205.04,21.46 204.79,21.2 204.79,18.18 205.37,17.6 208.17,17.6 208.72,18.16 208.72,19.93 209.11,19.93 209.11,20.19 208.72,20.19 208.72,24.13 208.43,24.42
GND on TOP: 62.92,74.2 70.14,74.2 70.47,73.87 70.47,73.18 70.7,72.95 72.45,72.95 72.68,73.18 72.68,78.29 72.14,78.82 69.73,78.82 66.86,75.95 63.18,75.95 62.64,75.42 62.64,74.48
GND on TOP: 208.54,97.36 209.05,97.36 209.18,97.49 209.18,98.5 209.05,98.63 208.16,98.63 207.53,98 207.53,97.23 206.38,96.09 206.38,95.2 206.13,94.95 204.73,94.95 204.1,95.58 202.32,95.58 202.32,96.73 202.57,96.98 205.75,96.98 206.26,97.49 206.26,98.88 208.41,101.04 214,101.04 214.51,100.54 216.8,100.54 217.18,100.15 217.18,96.98 216.8,96.6 212.61,96.6 212.05,96.04 210.14,96.04 209.76,95.66 209.76,94.66 208.68,93.58 208.44,93.82 209.2,94.58 209.2,96.45 208.92,96.73 208.52,96.73 208.41,96.83 208.41,97.23
GND on TOP: 232.16,65.48 232.67,65.99 232.67,67.57 231.07,69.17 227.85,69.17 227.59,69.42 227.59,74.04 228.3,74.75 231.4,74.75 231.66,75.01 231.66,76.48 232.21,77.04 232.54,77.04 232.67,77.17 232.67,78.06 232.54,78.18 232.21,78.18 231.86,78.54 231.86,80.8 234.96,83.9 234.96,86.57 234.7,86.82 231.15,86.82 230.64,86.31 230.64,83.62 230.03,83.01 226.85,83.01 226.55,82.71 226.55,80.83 225.31,79.58 225.31,74.78 224.77,74.25 223.02,74.25 222.77,73.99 222.77,71.96 222.89,71.83 223.65,71.83 225.56,69.93 225.56,64.34 225.05,63.83 225.05,60.35 225.18,60.23 226.32,60.23 226.47,60.38 226.47,62.13 226.9,62.56 229.9,62.56 230.23,62.89 230.23,65.07 230.63,65.48
GND on TOP: 197.05,90.07 213.67,90.07 216.69,87.05 218.7,87.05 219.26,86.49 219.26,80.39 218.75,79.89 215.93,79.89 215.25,79.2 213.32,79.2 212.86,79.66 212.86,81.59 212.63,81.82 210.67,81.82 210.37,81.51 210.37,80.14 209.96,79.73 209.53,79.73 209.43,79.83 209.43,81.49 209.05,81.87 206.94,81.87 206.48,81.41 206.48,80.04 206.15,79.71 205.75,79.71 205.54,79.91 205.54,81.56 205.26,81.84 203.28,81.84 202.95,81.51 202.95,80.44 202.22,79.71 201.84,79.71 201.66,79.89 201.66,81.73 201.78,81.89 201.81,81.92 201.81,82.68 201.38,83.11 197.62,83.11 196.58,84.15 196.58,89.6
GND on TOP: 245.47,102.87 253.35,102.87 253.98,103.51 256.62,103.51 257.11,103.03 257.11,102.16 257.23,102.03 257.41,102.03 257.56,102.19 257.56,104.96 256.62,105.9 238.13,105.9 237.5,105.26 237.5,103.03 237.83,102.69 245.29,102.69
GND on TOP: 230.64,25.48 230.64,23.45 233.1,23.45 233.1,25.5 233.36,25.76 234.2,25.76 235.01,26.57 236.02,26.57 236.25,26.8 240.14,26.8 240.57,26.37 245.5,26.37 245.83,26.7 245.83,31.85 247.68,33.71 247.68,36.2 247.12,36.76 243.06,36.76 242.25,35.94 242.25,32.54 240.47,30.76 237.04,30.76 236.79,31.02 235.06,31.02 234.47,30.43 234.47,27.54 233.97,27.03 233.18,27.03 233.05,26.9 230.72,26.9 230.6,27.02 229.81,27.02 229.6,27.23 229.6,28.02 229.28,28.34 229.28,30.56 229.27,30.56 228.84,30.99 223.5,30.99 222.61,30.1 222.61,28.32 224.59,26.34 229.01,26.34 229.6,25.76 230.36,25.76
GND on TOP: 228.07,58.75 232.29,58.75 232.54,58.5 232.54,57.64 232.82,57.36 237.75,57.36 237.88,57.23 237.88,49.1 237.5,48.72 233.2,48.72 232.67,48.19 232.67,47.55 232.06,46.94 228.45,46.94 227.59,47.81 227.59,48.57 227.31,48.85 215.48,48.85 215.07,49.25 215.07,52.99 214.79,53.27 213.75,53.27 213.49,53.52 213.49,54.54 213.82,54.87 215.4,54.87 216.03,55.5 216.03,57.48 225.61,57.48 227.31,55.78 228.51,55.78 228.76,56.04 228.76,56.72 227.72,57.76 227.72,58.4 ; 1 cut-out
GND on TOP: 83.62,51.77 85.12,51.77 85.2,51.84 85.2,53.42 84.92,53.7 83.62,53.7 83.47,53.55 83.47,51.92
GND on TOP: outline of 83 points within 175.67,33.35 186.49,88.85
GND on TOP: 58.55,76.02 58.81,75.77 58.81,70.51 56.09,70.51 56.09,66.07 58.81,66.07 58.81,60.4 58.55,60.15 45.85,60.15 45.6,60.4 45.6,75.77 45.85,76.02 ; 3 cut-outs
GND on TOP: 205.77,77.65 205.77,77.17 206.97,75.97 208.08,75.97 208.08,76 208.52,76.43 208.52,77.5 208.13,77.88 206,77.88
GND on TOP: 73.67,44.88 75.47,44.88 75.83,44.53 75.83,43.56 75.62,43.36 74.1,43.36 73.06,42.32 71.41,42.32 71,41.91 71,40.34 71.13,40.21 71.13,36.73 70.67,36.27 69.88,36.27 69.6,36.55 69.6,37.8 69.35,38.05 68.71,38.05 68.59,37.92 68.59,33.73 67.95,33.1 63.58,33.1 62.97,33.71 62.97,34.67 63.3,35 66.02,35 67.19,36.17 67.19,41.99 66.94,42.24 65.41,42.24 65.29,42.37 65.29,44.02 67.09,45.82 72.73,45.82 ; 1 cut-out
GND on TOP: 62.64,54.87 62.64,52.96 63.08,52.53 70.14,52.53 70.47,52.86 77.68,52.86 78.72,53.9 78.72,56.92 78.37,57.28 77.38,57.28 77.05,56.95 77.05,55.4 76.69,55.04 73.29,55.04 72.85,54.61 72.85,54 72.5,53.65 65.54,53.65 64.09,55.1 62.87,55.1
GND on TOP: 153.3,44.02 153.3,47.07 151.39,47.07 151.39,47.7 155.07,47.7 155.07,44.02
GND on TOP: 212.15,47.02 216.03,43.13 217.56,43.13 218.45,42.24 218.45,37.04 217.66,36.25 213.9,36.25 213.09,37.06 211.67,37.06 211.49,37.24 211.49,38.51 210.93,39.07 210.34,39.07 208.24,36.96 207.88,36.96 207.78,37.06 207.78,38.79 207.12,39.45 206.13,39.45 205.87,39.19 205.44,39.19 204.99,38.74 204.99,37.29 204.73,37.04 204.1,37.04 203.97,37.16 203.97,39.09 203.38,39.68 202.67,39.68 202.19,39.19 201.68,39.19 201.3,38.81 201.3,37.29 201.05,37.04 200.29,37.04 200.03,37.29 200.03,40.03 199.54,40.53 195.09,40.53 194.8,40.82 194.8,43.49 194.81,43.5 194.81,45.74 196.1,47.02
GND on TOP: 252.48,44.91 252.48,40.97 251.47,39.96 251.47,37.92 251.72,37.67 254.01,37.67 254.01,43.39 255.66,43.39 255.91,43.13 256.67,43.13 256.67,44.66 256.42,44.91
GND on TOP: 90.43,37.67 90.43,35.26 94.37,35.26 94.37,37.67
GND on TOP: 95.76,36.33 97.76,36.33 98.06,36.63 109.86,36.63 110.06,36.43 110.06,34.13 109.86,33.93 95.86,33.93 95.66,34.13 95.66,36.23
GND on TOP: 25.18,103.15 25.18,103.1 22.82,100.74 22.82,81.46 25.43,78.84 53.32,78.84 56.93,82.45 56.93,94.14 54.54,96.52 53.09,96.52 52.36,97.26 52.36,107.88 51.24,108.99 39.5,108.99 38.72,108.21 38.72,107.27 36.25,104.8 26.83,104.8
GND on TOP: 194.29,77.45 194.29,81.16 193.63,81.82 191.12,81.82 190.56,81.26 189.9,81.26 189.75,81.41 189.75,83.64 189.97,83.87 191.45,83.87 192.13,84.56 195.23,84.56 195.89,83.9 195.89,77.57 195.51,77.19 194.55,77.19
GND on TOP: 188.14,71.88 188.86,71.88 188.91,71.83 188.91,71.78 189.54,71.15 189.9,71.15 190.48,71.73 204.73,71.73 206.61,69.85 206.61,54.18 205.26,52.83 193.66,52.83 192.89,52.07 190.11,52.07 189.48,52.71 189.48,53.46 188.91,54.03 188.2,54.03 188.09,54.13 188.09,54.31 188.14,54.36 189.11,54.36 189.36,54.1 189.67,54.1 189.8,54.23 189.8,55.5 189.67,55.63 189.47,55.63 189.11,55.98 188.2,55.98 188.09,56.09 188.09,56.29 188.17,56.37 189.11,56.37 189.52,55.96 195.74,55.96 196.22,56.44 196.22,61.34 189.8,67.77 189.8,68.63 188.88,69.55 188.2,69.55 188.09,69.65 188.09,69.85 188.2,69.95 188.81,69.95 188.91,69.85 188.91,69.8 189.52,69.19 189.95,69.19 190.08,69.32 190.08,69.67 189.97,69.78 189.97,70.54 189.8,70.72 189.52,70.72 188.63,71.61 188.14,71.61 188.12,71.63 188.12,71.86
GND on TOP: 83.83,72.72 83.7,72.6 78.62,72.6 78.49,72.72 78.49,73.61 78.62,73.74 83.83,73.74
GND on TOP: 134.76,88.33 134.76,90.13 134.86,90.23 141.26,90.23 141.46,90.03 141.46,86.83 138.96,86.83 138.96,88.23 138.86,88.33
GND on TOP: 89.92,86.06 89.92,90.12 90.18,90.38 107.96,90.38 108.21,90.12 108.21,88.22 98.43,88.22 98.43,86.06 93.73,86.06 93.73,88.09 91.19,88.09 91.19,86.06
GND on TOP: 243.54,54.18 244.1,54.18 244.1,54.82 244.23,54.94 254.52,54.94 254.9,54.56 254.9,51.39 254.64,51.13 249.69,51.13 248.17,52.66 245.14,52.66 245.14,52.4 245.08,52.34 245.07,52.35 242.45,52.35 242.27,52.53 242.27,53.04 242.81,53.57 243.29,53.57 243.54,53.83
GND on TOP: 81.8,47.83 82.05,47.58 82.05,44.4 76.46,44.4 75.83,45.04 73.82,45.04 73.69,45.16 73.69,46.21 73.92,46.43 77.48,46.43 78.87,47.83
GND on TOP: 79.76,76.28 79.51,76.53 79.51,78.18 79.76,78.44 82.81,78.44 83.07,78.18 83.07,76.53 82.81,76.28
GND on TOP: 77.35,71.07 77.99,71.07 78.24,70.82 78.24,67.49 78.37,67.36 78.37,67.39 83.83,67.39 83.83,65.86 85.99,65.86 85.99,64.72 83.83,64.72 83.83,63.2 83.57,62.94 76,62.94 75.8,63.15 75.8,64.82 75.37,65.26 72.93,65.26 72.63,64.95 72.63,62.84 72.14,62.36 65.87,62.36 65.08,63.15 65.08,65.46 63.91,66.63 63,66.63 62.62,67.01 62.62,68.53 62.87,68.79 63.76,68.79 65.16,67.39 72.52,67.39 73.03,67.9 73.03,68.53 73.41,68.91 76.46,68.91 77.1,69.55 77.1,70.82
GND on TOP: 211.59,102.44 211.59,101.55 211.84,101.3 214.26,101.3 214.64,100.92 217.3,100.92 217.81,101.42 217.81,105.23 217.43,105.62 212.86,105.62 212.73,105.49 212.73,104.98 212.99,104.73 215.65,104.73 215.78,104.6 215.78,103.71 215.91,103.58 216.67,103.58 216.92,103.33 216.92,101.81 216.8,101.68 215.4,101.68 215.27,101.81 215.27,102.82 214.51,102.82 214.13,102.44 ; 4 cut-outs
GND on TOP: 239.91,71.45 239.91,68.15 240.29,67.77 260.74,67.77 261.12,68.15 261.12,71.33 260.61,71.83 240.29,71.83
GND on BOTTOM: 151.52,48.21 150.5,49.23 150.5,57.23 152.03,58.75 152.03,61.04 152.41,61.42 152.41,63.45 150.12,63.45 150.12,61.67 149.99,61.55 148.47,61.55 148.47,68.53 148.72,68.79 150.76,68.79 151.01,69.04 151.01,69.29 147.33,69.29 147.2,69.42 147.2,71.71 147.84,71.71 148.09,71.96 148.09,72.85 147.84,73.1 146.57,73.1 146.57,74.63 148.22,74.63 148.72,74.12 149.99,74.12 150.12,73.99 150.12,72.47 150.5,72.09 152.03,72.09 152.28,71.83 152.28,71.2 152.66,70.82 155.33,70.82 155.46,70.94 155.46,79.45 155.71,79.71 157.61,79.71 157.87,79.45 157.87,44.91 151.9,44.91 151.52,45.29
GND on BOTTOM: 48.65,62.69 48.65,63.32 48.9,63.58 49.41,63.58 49.66,63.83 49.66,64.72 49.92,64.98 53.86,64.98 54.11,65.23 54.11,66.37 54.49,66.75 57.92,66.75 58.55,66.12 58.55,62.69 58.3,62.44 48.9,62.44
GND on BOTTOM: 52.71,58.4 52.71,53.29 52.94,53.06 53.65,53.06 53.96,53.37 53.96,54.56 54.08,54.69 55,54.69 55.13,54.56 55.13,53.37 55.46,53.04 56.14,53.04 56.37,53.27 56.37,58.32 56.19,58.5 55.18,58.5 55,58.32 55,57.1 54.87,56.97 54.16,56.97 54.01,57.13 54.01,58.27 53.78,58.5 52.81,58.5
GND on BOTTOM: 132.09,20.53 132.09,23.32 133.36,23.32 133.36,23.07 134.37,23.07 134.37,20.78 134.12,20.53
GND on BOTTOM: 132.09,28.15 132.09,30.94 133.36,30.94 133.36,30.69 134.37,30.69 134.37,28.4 134.12,28.15
GND on BOTTOM: 178.44,74.02 178.44,64.87 179.43,63.88 179.43,60.53 178.39,59.49 178.39,47.98 178.62,47.75 178.62,35.56 178.26,35.21 175.95,35.21 175.8,35.36 175.8,87.25 174.66,88.39 167.7,88.39 166.99,87.68 166.99,86.36 166.94,86.31 158.96,86.31 158.25,87.02 158.25,89.59 158.81,90.15 184.72,90.15 186.37,88.5 186.37,79.78 182.28,75.69 180.12,75.69
GND on BOTTOM: 127.52,31.07 127.52,32.59 127.39,32.72 126.88,32.72 126.75,32.59 126.75,31.19 126.88,31.07
GND on BOTTOM: 207.55,58.58 207.55,57.76 207.65,57.66 212.15,57.66 212.86,56.95 212.86,55.1 211.87,54.1 211.72,54.1 209.4,51.79 209.4,44.71 209.79,44.33 220,44.33 221.6,45.93 221.6,56.8 219.54,58.85 215.93,58.85 215.09,59.69 215.09,61.34 215.3,61.55 215.3,62.03 215.07,62.26 213.9,62.26 213.42,61.78 213.42,59.69 212.4,58.68 210.8,58.68 210.8,59.74 210.47,59.74 210.24,59.51 210.24,58.83 209.96,58.55 207.78,58.55 207.75,58.58
GND on BOTTOM: 112.15,67.01 113.29,67.01 113.29,65.48 118.88,65.48 118.88,67.01 120.02,67.01 120.02,56.85 118.75,56.85 118.75,58.37 113.29,58.37 113.29,56.85 112.15,56.85
GND on BOTTOM: 196.83,62.94 197.09,62.69 198.41,62.69 198.56,62.84 198.56,65.1 198.23,65.43 196.53,65.43 195.99,64.9 195.99,64.24 196.07,64.16 196.58,64.16 196.83,63.91
GND on BOTTOM: 194.09,60.45 194.09,61.55 193.63,62 193.63,62.94 193.5,63.07 192.64,63.07 192.49,62.92 192.49,61.09 193.35,60.23 193.86,60.23
GND on BOTTOM: 125.74,93.3 125.74,92.79 127.9,92.79 128.15,93.04 128.15,95.46 128.02,95.58 119.77,95.58 119.51,95.33 119.51,93.3
GND on BOTTOM: 15.37,41.86 18.77,41.86 19.53,42.62 22.23,42.62 22.23,40.32 16.47,40.32 16.34,40.2 16.34,38.73 16.52,38.56 16.52,37.8 16.39,37.67 14.61,37.67 14.36,37.92 14.36,43.77 14.61,44.02 15.12,44.02 15.12,42.12
GND on BOTTOM: 115.45,94.95 115.45,96.6 114.82,96.6 114.82,97.87 114.56,98.12 112.78,98.12 112.53,97.87 112.53,96.47 112.78,96.22 113.42,96.22 113.67,95.96 113.67,95.2 113.93,94.95
GND on BOTTOM: 60.66,61.52 60.66,59.74 60.87,59.54 62.47,59.54 62.69,59.77 62.69,60.18 62.9,60.38 68.21,60.38 68.74,60.91 69.1,60.91 69.63,60.38 70.11,60.38 70.44,60.05 70.44,59.36 70.67,59.13 72.42,59.13 72.65,59.36 72.65,65.03 72.22,65.46 70.92,65.46 67.6,62.13 61.27,62.13
GND on BOTTOM: 84.84,78.56 85.1,78.31 85.1,77.04 86.11,76.02 86.11,75.64 86.37,75.39 88.27,75.39 88.53,75.14 88.53,73.89 88.25,73.61 84.21,73.61 83.19,72.6 78.62,72.6 78.37,72.85 78.37,78.31 78.62,78.56
GND on BOTTOM: 136.05,36.63 136.28,36.4 136.28,33.35 135.95,33.03 132.6,33.03 131.18,34.45 130.49,34.45 130.16,34.78 130.16,35.84 130.94,36.63
GND on BOTTOM: 151.77,96.73 151.77,92.15 151.52,91.9 149.49,91.9 149.49,96.73 149.74,96.98 151.52,96.98
GND on BOTTOM: 206.82,19.04 206.82,20.82 205.68,20.82 205.68,21.08 206.82,21.08 206.82,24.42 210.87,24.42 211.21,24.08 211.21,22.43 208.68,22.43 208.34,22.09 208.34,20.57 209.49,20.57 209.49,20.31 208.34,20.31 208.34,16.25 208.22,16.12 206.44,16.12 206.44,16.38 207.2,16.38 207.33,16.5 207.33,17.01 207.2,17.14 206.44,17.14 206.44,18.66
GND on BOTTOM: 202.32,96.73 206.51,96.73 206.51,95.46 202.32,95.46
GND on BOTTOM: 54.49,41.99 54.11,41.61 54.11,40.46 53.86,40.21 49.92,40.21 49.66,39.96 49.66,39.07 49.41,38.81 48.9,38.81 48.65,38.56 48.65,37.16 48.9,36.91 58.3,36.91 58.55,37.16 58.55,41.35 57.92,41.99
GND on BOTTOM: 190.08,38.38 190.08,37.9 190.23,37.75 192.67,37.75 193.1,38.18 193.1,39.07 192.74,39.42 192.06,39.42 191.19,38.56 190.25,38.56
GND on BOTTOM: 248.9,80.34 247.56,80.34 247.25,80.65 247.25,81.33 247.17,81.41 246.62,81.41 246.34,81.13 246.34,79.86 246.08,79.61 246.08,79.17 246.29,78.97 246.54,78.97 246.77,79.2 246.77,79.35 247.07,79.66 248.9,79.66 249,79.76 249,80.24
GND on BOTTOM: outline of 96 points within 193.2,75.8 219.35,87.25
GND on BOTTOM: 149.49,104.22 150.76,104.22 150.76,99.01 149.49,99.01
GND on BOTTOM: 209.81,105.11 211.34,105.11 211.72,104.73 211.72,102.57 211.46,102.31 209.94,102.31 209.94,103.71 209.68,103.96 209.68,104.98
GND on BOTTOM: 240.47,71.61 240.47,68 241.71,66.75 261.25,66.75 262.08,67.59 262.08,71.4 261.4,72.09 240.95,72.09
GND on BOTTOM: 209.18,97.87 209.18,98.88 210.83,100.54 216.8,100.54 217.18,100.15 217.18,97.87 216.16,96.85 210.19,96.85
GND on BOTTOM: 15.88,22.76 15.88,23.95 11.82,23.95 11.82,27.71 11.18,27.71 11.18,28.22 11.82,28.22 11.82,28.6 11.18,28.6 11.18,29.11 11.69,29.11 11.69,29.62 10.55,29.62 10.55,30.05 15.37,30.05 15.37,29.29 15.88,29.29 15.88,29.92 16.26,29.92 16.26,29.54 18.3,29.54 18.3,29.16 17.53,29.16 17.53,24.49 18.3,24.49 18.3,24.08 17.53,24.08 17.53,23.65 17.28,23.4 16.26,23.4 16.26,22.76
GND on BOTTOM: 237.73,71.48 239.61,71.48 240.04,71.05 240.04,67.47 241.43,66.07 271.28,66.07 271.96,65.38 271.96,26.47 262.87,17.38 248.6,17.38 246.82,19.15 246.82,28.91 245.73,30 245.73,44.73 248.24,47.25 254.54,47.25 255.89,48.59 255.89,57.91 254.49,59.31 235.64,59.31 235.19,59.77 235.19,61.83 235.34,61.98 237.34,61.98 237.73,62.36 ; 13 cut-outs
GND on BOTTOM: 95.96,36.03 95.76,35.83 95.76,33.23 95.96,33.03 104.45,33.03 104.78,33.36 104.78,35.64 104.39,36.03
GND on BOTTOM: 79.51,67.77 79.51,62.31 79.76,62.05 82.68,62.05 83.19,61.55 86.75,61.55 87,61.8 87,66.25 84.08,66.25 83.83,66.5 83.83,67.52 83.57,67.77
GND on BOTTOM: 63.1,52.94 62.87,53.16 62.87,54.54 63.43,55.1 64.12,55.1 65.51,53.7 70.45,53.7 70.52,53.63 70.63,53.63 70.75,53.52 72.55,53.52 73.13,54.1 73.13,54.64 73.53,55.03 76.68,55.03 77.02,55.37 77.02,56.95 77.35,57.28 78.34,57.28 78.72,56.9 78.72,53.95 77.6,52.83 70.42,52.83 69.45,51.87 66.5,51.87 65.39,50.75 65.39,46.54 66.12,45.8 68.28,45.8 68.61,46.13 75.04,46.13 75.93,45.24 75.93,43.36 75.32,42.75 71.64,42.75 70.06,44.33 68.46,44.33 67.9,43.77 67.9,42.22 68.54,41.58 68.54,40.49 68.92,40.11 69.5,40.11 69.65,40.26 69.65,41.63 69.81,41.79 70.77,41.79 70.97,41.58 70.97,36.58 70.67,36.27 69.88,36.27 69.73,36.43 69.73,38 69.6,38.13 68.61,38.13 68.46,37.98 68.46,36.58 68.36,36.48 67.37,36.48 67.22,36.63 67.22,43.97 66.86,44.33 63.86,44.33 63.1,45.09
GND on BOTTOM: 58.94,70.69 58.68,70.44 57.28,70.44 56.52,71.2 55.63,71.2 55.63,72.34 55.25,72.72 54.87,72.72 54.74,72.85 54.74,75.9 58.68,75.9 58.94,75.64
GND on BOTTOM: 50.3,44.66 51.95,44.66 52.2,44.91 52.2,48.08 51.95,48.34 49.16,48.34 48.9,48.08 48.9,44.91 49.03,44.78 50.17,44.78
GND on BOTTOM: 236.61,26.49 237.85,26.49 238.67,27.31 238.67,30.41 237.93,31.14 236.28,31.14 235.92,31.5 235.92,33.58 234.42,35.08 216.26,35.08 215.17,33.99 215.17,32.84 216.31,31.7 218.8,31.7 220.61,29.9 220.61,21.67 223.27,19 232.65,19 236.07,22.43 236.07,25.96
GND on BOTTOM: 46.39,56.24 46.39,54.56 46.67,54.28 47.76,54.28 48.11,53.93 48.11,52.58 48.65,52.05 50.35,52.05 50.58,52.28 50.58,54 50.4,54.18 49.61,54.18 49.31,54.49 49.31,56.16 48.93,56.54 46.69,56.54
GND on BOTTOM: 51.95,69.42 52.2,69.67 52.2,72.85 51.95,73.1 49.16,73.1 48.9,72.85 48.9,70.18 49.66,69.42
GND on BOTTOM: 230.84,58.7 232.32,58.7 232.59,58.42 232.59,57.84 233.08,57.36 237.75,57.36 237.88,57.23 237.88,49.1 237.24,48.47 233.33,48.47 232.9,48.03 232.9,47.37 232.46,46.93 228.37,46.93 227.59,47.7 227.59,48.29 227.16,48.72 223.25,48.72 222.64,49.33 222.64,56.7 223.2,57.25 225.99,57.25 226.91,56.34 226.91,56.09 227.24,55.76 227.85,55.76 228.33,56.24 228.33,57.05 227.87,57.51 227.87,58.24 228.12,58.5 228.63,58.5 228.73,58.4 228.73,57.99 229.24,57.48 230.26,57.48 230.51,57.74 230.51,58.37 ; 1 cut-out
GND on BOTTOM: 234.45,105.87 234.45,102.87 234.96,102.36 243.42,102.36 243.9,101.88 246.67,101.88 246.79,102.01 246.79,102.44 246.64,102.59 245.55,102.59 245.37,102.77 245.37,103.63 244.74,104.27 244.74,105.84 244.41,106.17 234.75,106.17
GND on BOTTOM: 76.33,46.43 76.21,46.31 76.21,44.66 76.46,44.4 80.91,44.4 81.16,44.66 81.16,48.08 78.62,48.08 78.62,46.43
GND on BOTTOM: 242.83,53.16 242.83,53.55 243.47,54.18 244.1,54.18 244.1,54.82 244.36,55.07 247.91,55.07 248.04,54.94 254.52,54.94 254.9,54.56 254.9,51.39 254.64,51.13 249.69,51.13 248.17,52.66 245.5,52.66 244.48,51.64 242.96,51.64 242.32,52.28 242.32,52.91 242.58,53.16
GND on BOTTOM: 52.33,105.36 52.33,103.58 53.47,103.58 53.47,103.33 52.33,103.33 52.33,100.03 48.9,100.03 48.52,100.41 48.52,101.81 50.3,101.81 50.81,102.31 50.81,103.84 49.66,103.84 49.66,104.09 50.81,104.09 50.81,108.16 50.93,108.28 52.71,108.28 52.71,108.03 51.95,108.03 51.82,107.9 51.82,107.39 51.95,107.27 52.71,107.27 52.71,105.74
GND on BOTTOM: 140.34,87.23 140.32,87.2 138.18,87.2 137.93,87.45 137.93,90.63 138.18,90.88 140.47,90.88 140.72,90.63 140.72,87.45 140.47,87.2 140.37,87.2
GND on BOTTOM: 21.85,57.61 18.93,57.61 18.93,55.2 19.18,54.94 21.6,54.94 21.85,55.2
GND on BOTTOM: 195.71,43.26 217.18,43.26 218.32,42.12 218.32,38.94 217.23,37.85 214.59,37.85 214.38,38.05 214.38,41.33 213.85,41.86 211.67,41.86 211.31,41.51 211.31,39.75 211.84,39.22 212.17,39.22 212.86,38.53 212.86,36.81 212.57,36.52 208.12,36.52 207.78,36.86 207.78,38.74 208.69,39.65 208.69,41.58 208.41,41.86 207.8,41.86 207.35,41.4 207.35,40.03 204.48,37.16 204.1,37.16 203.97,37.29 203.97,38.94 204.96,39.93 204.96,41.48 204.58,41.86 203.84,41.86 203.46,41.48 203.46,39.78 202.88,39.19 202.7,39.19 200.67,37.16 200.16,37.16 200.03,37.29 200.03,38.69 200.41,39.07 201.3,39.07 202.06,39.83 202.06,40.34 201.81,40.59 201.78,40.59 200.92,41.46 200.92,41.73 200.67,41.99 200.03,41.99 199.65,41.61 199.65,41.07 199.42,40.85 195.46,40.85 195.21,41.1 195.21,42.75
GND on BOTTOM: 73.08,68.58 73.08,67.92 72.6,67.44 65.13,67.44 63.76,68.81 62.85,68.81 62.57,68.53 62.57,67.11 63,66.68 65.08,66.68 65.56,66.2 65.56,62.64 65.84,62.36 67.04,62.36 67.32,62.64 67.32,65.05 68.74,66.47 77.68,66.47 78.26,67.06 78.26,70.77 78.04,71 77.3,71 77.07,70.77 77.07,69.6 76.33,68.86 73.36,68.86
GND on BOTTOM: 45.09,22.81 45.09,23.32 45.85,23.32 45.85,23.83 45.09,23.83 45.09,24.34 45.93,24.34 45.93,28.78 46.44,28.78 46.44,28.15 46.82,28.15 46.82,28.78 47.33,28.78 47.33,28.15 48.27,28.15 48.27,28.78 48.78,28.78 48.78,28.15 50.3,28.15 50.3,28.78 50.68,28.78 50.68,28.15 51.44,28.15 51.44,28.78 51.95,28.78 51.95,28.02 53.22,28.02 53.22,27.64 51.57,27.64 51.57,26.37 50.93,26.37 50.93,25.99 51.65,25.99 51.65,25.48 50.93,25.48 50.93,24.72 51.65,24.72 51.65,23.95 53.22,23.95 53.35,23.83 53.35,23.19 50.73,23.19 50.73,23.83 49.79,23.83 49.79,23.19 49.28,23.19 49.28,23.8 47.76,23.8 47.76,23.19 47.25,23.19 47.25,23.83 46.36,23.83 46.36,22.81
GND on BOTTOM: 195.1,36.65 194.83,36.38 194.83,35.28 195.74,34.37 198.18,34.37 198.28,34.47 198.28,34.85 197.47,35.66 197.47,36.38 197.19,36.65
GND on BOTTOM: 26.42,53.8 23.5,53.8 23.5,56.21 23.76,56.47 26.17,56.47 26.42,56.21
GND on BOTTOM: 62.92,74.2 70.14,74.2 70.47,73.87 70.47,73.18 70.7,72.95 72.45,72.95 72.68,73.18 72.68,78.84 72.24,79.28 70.19,79.28 66.86,75.95 63.18,75.95 62.64,75.42 62.64,74.48
GND on BOTTOM: 190.1,54.59 190.1,54.05 190.35,53.8 193.22,53.8 193.48,54.05 193.48,55.27 193.15,55.6 191.85,55.6 191.07,54.82 190.33,54.82
GND on BOTTOM: 204.73,34.88 204.73,33.35 204.99,33.1 208.03,33.1 208.16,33.23 208.16,34.88 208.02,35.02 204.87,35.02
GND on BOTTOM: 118.46,36.63 112.96,36.63 112.96,35.63 110.06,35.63 109.46,36.23 106.31,36.23 106.31,36.22 105.93,35.84 105.93,34.37 106.69,33.61 109.41,33.61 109.99,33.03 118.46,33.03 118.66,33.23 118.66,36.43
GND on BOTTOM: 205.37,77.73 205.37,76.2 205.62,75.95 208.03,75.95 208.52,76.43 208.52,77.5 208.03,77.98 205.62,77.98
GND on BOTTOM: 54.11,96.47 54.11,93.3 55.13,92.28 55.13,91.26 52.59,91.26 52.59,95.71 51.06,95.71 50.81,95.96 49.92,95.96 49.92,96.47 50.05,96.6 50.68,96.6 50.93,96.85 50.93,97.49 51.19,97.74 56.52,97.74 56.78,97.49 56.78,96.73 54.36,96.73
GND on BOTTOM: 125.48,98.88 127.77,98.88 128.02,98.63 128.02,97.36 127.77,97.11 125.48,97.11
GND on BOTTOM: 58.94,49.28 58.94,45.93 58.68,45.67 57.28,45.67 56.52,46.43 55.63,46.43 55.63,47.58 55.25,47.96 54.87,47.96 54.74,48.08 54.74,51.13 55.71,51.13 55.79,51.06 55.79,50.14 56.12,49.81 58.4,49.81
GND on BOTTOM: 98.06,91.03 93.56,91.03 93.36,90.83 93.36,85.73 96.06,85.73 96.56,85.23 98.06,85.23 98.06,88.09 109.61,88.09 110.75,86.95 116.59,86.95 116.85,87.2 116.85,90.76 116.59,91.01 107.95,91.01
GND on BOTTOM: 23.63,41.86 27.03,41.86 27.79,42.62 30.49,42.62 30.49,40.32 24.73,40.32 24.6,40.2 24.6,38.73 24.77,38.56 24.77,37.67 22.99,37.67 22.74,37.92 22.74,43.89 22.99,44.15 23.38,44.15 23.38,42.12
GND on BOTTOM: 219.84,19.51 218.45,19.51 218.45,20.27 218.7,20.53 219.84,20.53 220.1,20.27 220.1,19.76
GND on L02_GND1: 45.64,5.67 45.64,10.92 44.91,12.67 43.17,13.39 0.64,13.39 0.64,110.51 273.69,110.51 273.69,13.39 140.78,13.39 139.09,12.69 138.39,11 138.39,9.7 138.39,9.63 130.66,9.63 129.25,9.03 128.66,7.62 128.66,5.67 58.74,5.67 58.74,7.45 57.15,9.04 55.56,7.45 55.56,5.67 ; 4 cut-outs
GND on L03_SIG1, L05_SIG2, L07_SIG3: 212.55,43 212.55,42.12 212.73,41.94 214.38,41.94 214.46,41.86 214.46,38.05 214.64,37.87 214.89,37.87 215.53,38.51 216.9,38.51 217.66,39.27 217.66,40.01 218.22,40.57 218.22,42.14 217.15,43.21 212.76,43.21
GND on L03_SIG1, L05_SIG2, L07_SIG3: 219.27,80.74 219.27,82.34 219.31,82.37 219.31,85.83 218.32,86.82 216.75,86.82 216.59,86.67 216.59,84.61 216.11,84.13 216.11,80.75 216.95,79.91 217.23,79.91 217.86,80.55 219.08,80.55
GND on L03_SIG1, L05_SIG2, L07_SIG3: 215.88,87.15 214.41,87.15 214.21,86.95 214.21,84.79 214.38,84.61 215.91,84.61 216.08,84.79 216.08,86.95
GND on L04_GND2: 45.64,5.67 45.64,10.92 44.91,12.67 43.17,13.39 0.64,13.39 0.64,110.51 273.69,110.51 273.69,13.39 140.78,13.39 139.09,12.69 138.39,11 138.39,9.7 138.39,9.63 130.66,9.63 129.25,9.03 128.66,7.62 128.66,5.67 58.74,5.67 58.74,7.45 57.15,9.04 55.56,7.45 55.56,5.67 ; 3 cut-outs
GND on L06_GND3: 45.64,5.67 45.64,10.92 44.91,12.67 43.17,13.39 0.64,13.39 0.64,110.51 273.69,110.51 273.69,13.39 140.78,13.39 139.09,12.69 138.39,11 138.39,9.7 138.39,9.63 130.66,9.63 129.25,9.03 128.66,7.62 128.66,5.67 58.74,5.67 58.74,7.45 57.15,9.04 55.56,7.45 55.56,5.67 ; 3 cut-outs
GND on L07_SIG3: 236.61,26.49 237.85,26.49 238.67,27.31 238.67,30.84 234.42,35.08 216.26,35.08 215.17,33.99 215.17,32.84 216.31,31.7 218.32,31.7 220.61,29.42 220.61,21.67 223.27,19 232.65,19 236.07,22.43 236.07,25.96
GND on L07_SIG3: 185.07,58.68 185.07,56.09 184.89,55.91 184.26,55.91 183.9,55.55 183.9,54.79 184.31,54.38 184.69,54.38 185.02,54.05 185.02,51.89 185.38,51.54 186.11,51.54 186.37,51.79 186.37,58.68 186.16,58.88 185.27,58.88
GND on L08_GND4, L11_GND5: 45.64,5.67 45.64,10.92 44.91,12.67 43.17,13.39 0.64,13.39 0.64,110.51 273.69,110.51 273.69,13.39 140.78,13.39 139.09,12.69 138.39,11 138.39,9.7 138.39,9.63 130.66,9.63 129.25,9.03 128.66,7.62 128.66,5.67 58.74,5.67 58.74,7.45 57.15,9.04 55.56,7.45 55.56,5.67 ; 2 cut-outs
GND on L12_SIG4: 236.61,26.49 237.85,26.49 238.67,27.31 238.67,30.84 234.42,35.08 225.2,35.08 220.61,30.48 220.61,21.67 223.27,19 232.65,19 236.07,22.43 236.07,25.96
GND on L13_GND6: 45.64,5.67 45.64,10.92 44.91,12.67 43.17,13.39 0.64,13.39 0.64,110.51 273.69,110.51 273.69,13.39 140.78,13.39 139.09,12.69 138.39,11 138.39,9.7 138.39,9.63 130.66,9.63 129.25,9.03 128.66,7.62 128.66,5.67 58.74,5.67 58.74,7.45 57.15,9.04 55.56,7.45 55.56,5.67 ; 2 cut-outs
GND on L15_GND7: 45.64,5.67 45.64,10.92 44.91,12.67 43.17,13.39 0.64,13.39 0.64,110.51 273.69,110.51 273.69,13.39 140.78,13.39 139.09,12.69 138.39,11 138.39,9.7 138.39,9.63 130.66,9.63 129.25,9.03 128.66,7.62 128.66,5.67 58.74,5.67 58.74,7.45 57.15,9.04 55.56,7.45 55.56,5.67 ; 2 cut-outs
GND on L16_SIG6: 225.33,30.81 225.33,20.25 226.6,18.98 232.59,18.98 236.07,22.46 236.07,26.01 236.58,26.52 237.78,26.52 238.67,27.41 238.67,30.38 237.9,31.14 236.28,31.14 235.77,31.65 226.17,31.65
GND on L17_GND8: 45.64,5.67 45.64,10.92 44.91,12.67 43.17,13.39 0.64,13.39 0.64,110.51 273.69,110.51 273.69,13.39 140.78,13.39 139.09,12.69 138.39,11 138.39,9.7 138.39,9.63 130.66,9.63 129.25,9.03 128.66,7.62 128.66,5.67 58.74,5.67 58.74,7.45 57.15,9.04 55.56,7.45 55.56,5.67 ; 2 cut-outs
GND_CHS on BOTTOM: 0.64,30.43 2.93,30.43 5.09,28.27 5.09,27.76 4.76,27.43 4.15,27.43 3.18,28.4 2.42,28.4 2.42,23.19 3.18,23.19 4.07,24.08 4.76,24.08 5.09,23.75 5.09,23.32 3.18,21.41 3.18,18.62 0.9,18.62 0.64,18.87
GND_ETH_PHY on BOTTOM: 12.33,82.12 13.85,83.64 13.85,95.71 12.33,97.23 10.93,97.23 10.29,97.87 10.29,99.27 10.8,99.77 12.83,99.77 14.49,98.12 15.5,98.12 15.5,96.22 15.12,95.84 15.12,82.12 12.71,79.71 9.66,79.71 8.77,78.82 7.12,78.82 6.99,78.95 6.99,80.09 9.02,82.12
GND_QSFPDD0_CAGE on TOP: 46.49,57.59 0.64,57.59 0.64,78.59 42.04,78.59 42.04,77.59 35.31,77.59 35.31,75.6 33.95,75.6 33.95,60.58 35.31,60.58 35.31,58.59 46.49,58.59
GND_QSFPDD0_CAGE on BOTTOM: 18.93,60.15 21.6,60.15 21.85,59.9 21.85,58.12 18.93,58.12
GND_QSFPDD1_CAGE on TOP: 46.49,32.79 0.64,32.79 0.64,53.8 42.04,53.8 42.04,52.8 35.31,52.8 35.31,50.81 33.95,50.81 33.95,35.79 35.31,35.79 35.31,33.8 46.49,33.8
GND_QSFPDD1_CAGE on BOTTOM: 23.5,51.26 26.17,51.26 26.42,51.51 26.42,53.29 23.5,53.29
PVCC on TOP: 202.37,47.98 202.37,49.08 201.71,49.74 196.73,49.74 196.48,49.48 195.97,49.48 195.61,49.84 195.61,51.67 196.35,52.4 196.35,53.16 195.59,53.16 195.07,52.64 193.82,52.64 193.22,52.05 193.22,47.78 193.53,47.48 201.86,47.48
PVCC on BOTTOM: 192.82,47.15 192.82,45.34 193.25,44.91 196.02,44.91 196.55,45.44 196.55,47.12 196.07,47.6 193.28,47.6
SVIN0 on L07_SIG3: 66.66,60.02 66.66,58.4 66.99,58.07 68.99,58.07 69.04,58.12 69.04,59.9 68.79,60.15 66.78,60.15
SVIN1 on L03_SIG1: 66.68,73.71 66.68,71.81 66.76,71.73 68.69,71.73 68.97,72.01 68.97,73.56 68.74,73.79 66.76,73.79
VCC_HSSI_AGND on TOP: 220.66,73.1 222.26,73.1 222.51,72.85 222.51,70.94 222.38,70.82 220.56,70.82 220.35,71.02 220.35,72.8
VCC_HSSI_AGND on BOTTOM: 222.64,74.88 223.15,74.88 223.4,74.63 223.76,74.63 223.91,74.48 223.91,72.24 223.65,71.99 223.65,71.58 223.02,71.58 223.15,71.45 223.15,69.67 223.13,69.66 223.13,68.06 222.99,67.92 221.88,67.92 221.75,67.8 221.75,66.88 221.5,66.63 218.52,66.63 218.47,66.68 217,66.68 216.59,67.08 216.59,71.61 216.95,71.96 218.88,71.96 218.93,71.91 220.66,71.91 220.71,71.96 220.71,72.88 221.14,72.88 221.29,73.03 221.29,74.68 221.39,74.78 222.54,74.78
VCCA_PLL on TOP: 206.76,95.84 207.4,96.47 208.11,96.47 208.26,96.32 208.26,92.81 208.83,92.25 212.09,92.25 212.38,92.53 212.38,94.08 212.15,94.31 211.84,94.31 211.72,94.44 211.72,94.82 211.84,94.95 213.62,94.95 214.76,93.8 215.27,93.8 215.53,93.55 215.53,91.52 215.27,91.26 202.32,91.26 202.06,91.52 202.06,93.42 202.32,93.68 204.35,93.68 204.86,94.19 206.13,94.19 206.76,94.82
VCCA_PLL on BOTTOM: 151.26,77.04 151.26,79.61 151.67,80.01 154.79,80.01 155.38,80.6 157.54,80.6 157.61,80.52 157.61,80.06 157.39,79.83 155.33,79.83 154.95,79.45 154.95,77.04 154.69,76.79 151.52,76.79
VCCA_PLL on BOTTOM: 202.32,93.55 206.38,93.55 206.51,93.42 206.51,90.76 207.65,89.61 212.35,89.61 213.75,91.01 213.75,93.42 214,93.68 215.4,93.68 215.78,93.3 215.78,90.25 213.49,87.96 206.64,87.96 203.72,90.88 202.45,90.88 202.06,91.26 202.06,93.3
VCCA_PLL on L14_SIG5: 215.4,93.68 202.83,93.68 202.06,92.92 202.06,91.39 201.05,90.38 156.85,90.38 151.29,84.81 151.29,77.32 151.44,77.17 214,77.17 215.27,78.44 215.27,87.2 216.16,88.09 216.16,92.92
VCCA_PLL_EN on L16_SIG6: 241.76,37.92 241.76,36.71 242.5,35.97 247.56,35.97 247.86,36.27 247.86,36.73 246.87,37.72 243.47,37.72 243.19,38 241.84,38
VCCA_PLL_FLTR on BOTTOM: 151.39,76.02 154.95,76.02 155.07,75.9 155.07,72.21 152.53,72.21 152.03,72.72 150.88,72.72 150.88,74.5 151.26,74.88 151.26,75.9
VCCA_PLL_FLTR on L05_SIG2: 142.88,67.39 153.47,67.39 154.44,68.36 154.44,75.14 153.93,75.64 145.93,75.64 144.53,77.04 123.93,77.04 122.03,75.14 119.9,75.14 117.61,72.85 116.09,72.85 115.96,72.72 114.13,72.72 113.6,72.19 112.94,72.19 112.66,72.47 112.02,72.47 111.64,72.09 111.64,70.56 112.53,69.67 131.2,69.67 131.71,69.17 141.1,69.17
VCCA_PLL_FLTR on L07_SIG3: 110.88,70.31 111.26,69.93 120.4,69.93 120.66,70.18 120.66,73.48 120.28,73.87 111.26,73.87 110.88,73.48
VCCA_PLL_FLTR on L16_SIG6: 134.25,77.24 155.25,77.24 155.84,76.66 155.84,71.71 155.2,71.07 143.14,71.07 142.76,71.45 134.25,71.45 131.2,68.4 131.2,56.21 129.8,54.82 121.04,54.82 119.13,52.91 119.13,51.77 118.24,50.88 111.64,50.88 110.62,51.89 110.62,71.58 112.78,73.74 126.37,73.74 128.37,74.34 130.06,74.88 132.85,76.66 ; 1 cut-out
VCCCLK_GXPL1 on TOP: 147.84,79.83 147.84,78.31 146.44,78.31 146.18,78.56 146.18,79.58 146.44,79.83
