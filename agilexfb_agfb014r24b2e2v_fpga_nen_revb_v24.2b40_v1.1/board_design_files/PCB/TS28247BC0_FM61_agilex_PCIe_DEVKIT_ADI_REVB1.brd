# Allegro board TS28247BC0_FM61_agilex_PCIe_DEVKIT_ADI_REVB1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CLK_SYS_100M_P: length 88.8
  L07_SIG3 w0.085: v1(107.99,39.43) 107.99,39.71 107.88,39.81 107.62,39.81 107.38,40.06 107.38,41.56 107.5,41.86 107.5,42.01 107.38,42.3 107.38,42.57 107.5,42.86 107.5,43.02 107.38,43.31 107.38,43.57 107.5,43.87 107.5,43.99 107.38,44.28 107.38,44.56 107.49,44.82 107.49,45.04 107.37,45.33 107.37,45.54 107.51,45.86 107.51,45.99 107.38,46.31 107.38,46.55 107.5,46.84 107.5,47.02 107.38,47.29 107.38,47.57 107.5,47.85 107.5,48 107.38,48.29 107.38,48.57 107.5,48.86 107.5,48.98 107.43,49.14 107.3,49.27 107.2,49.31 107.11,49.31 arc(106.85,49.37) 106.65,49.54 106.51,49.71 arc(106.42,49.79) 106.29,49.81 106.23,49.81 arc(106.08,49.78) 105.97,49.69 105.83,49.52 arc(105.65,49.37) 105.41,49.31 105.37,49.31 arc(105.12,49.37) 104.92,49.54 104.76,49.73 arc(104.69,49.79) 104.59,49.81 104.53,49.81 arc(104.35,49.77) 104.21,49.66 104.1,49.51 arc(103.91,49.37) 103.68,49.31 103.65,49.31 arc(103.39,49.37) 103.19,49.54 103.07,49.69 arc(102.96,49.78) 102.82,49.81 102.77,49.81 arc(102.63,49.78) 102.51,49.69 102.37,49.5 arc(102.19,49.36) 101.98,49.31 101.88,49.31 arc(101.65,49.37) 101.47,49.51 101.33,49.69 arc(101.22,49.78) 101.08,49.81 101.05,49.81 arc(100.89,49.78) 100.77,49.68 100.62,49.49 arc(100.46,49.36) 100.26,49.31 100.14,49.31 arc(99.93,49.36) 99.75,49.51 99.6,49.69 arc(99.49,49.78) 99.36,49.81 99.31,49.81 arc(99.06,49.87) 98.85,50.04 98.75,50.17 arc(98.62,50.28) 98.45,50.31 98.44,50.31 arc(98.2,50.37) 98,50.53 97.86,50.71 arc(97.77,50.79) 97.65,50.81 97.55,50.81 arc(97.32,50.87) 97.14,51.02 96.99,51.2 arc(96.89,51.28) 96.77,51.31 96.72,51.31 arc(96.46,51.37) 96.25,51.54 96.14,51.68 arc(96.02,51.78) 95.87,51.81 95.85,51.81 arc(95.69,51.78) 95.56,51.67 95.42,51.49 arc(95.26,51.36) 95.06,51.31 94.99,51.31 arc(94.73,51.37) 94.52,51.54 94.42,51.67 arc(94.29,51.78) 94.13,51.81 94.12,51.81 arc(93.96,51.78) 93.83,51.67 93.69,51.49 arc(93.53,51.36) 93.33,51.31 93.26,51.31 arc(93.1,51.28) 92.97,51.17 92.87,51.05 arc(92.66,50.87) 92.39,50.81 arc(92.13,50.87) 91.93,51.04 91.78,51.23 arc(91.7,51.29) 91.6,51.31 91.53,51.31 arc(91.27,51.37) 91.06,51.54 90.96,51.67 arc(90.83,51.77) 90.66,51.81 arc(90.5,51.78) 90.37,51.67 90.23,51.49 arc(90.07,51.36) 89.87,51.31 88.38,51.31 87.94,50.87 87.1,50.87 86.01,49.79 84.8,49.79 83.2,48.19 77.25,48.19 77.05,47.99 77.05,47.81 76.85,47.61 76.67,47.61 73.16,44.1 73.16,38.99 72.6,38.43 72.6,36.58 71.88,35.87 70.92,35.87 70.69,35.63 70.69,35.24 70.4,34.95 69.73,34.95 68.13,33.35 59.64,33.35 57.56,31.27 57.56,31.09 57.36,30.89 57.18,30.89 56.87,30.58 55.63,30.58 55.33,30.29 55.33,29.96 55.46,29.84 55.46,29.56 55.33,29.43 55.33,28.95 55.51,28.77 55.85,28.77 55.95,28.87 v1(55.95,29.16)
  BOTTOM w0.102: v1(107.99,39.43) 108.01,39.43 108.41,39.83 108.69,39.83 109.01,40.15 109.01,40.73 109.46,41.81 109.46,42.05 109.33,42.36 109.33,42.5 109.47,42.82 109.47,43.03 109.33,43.36 109.33,43.5 109.46,43.81 109.46,44.04 109.33,44.37 109.33,44.49 109.41,44.67 109.5,44.77 109.62,44.77 109.72,44.67 v1(109.72,44.43)
CLK_SYS_BAK_50M_N: length 175
  L16_SIG6 w0.079: v1(85.8,77) 85.54,77.24 84.34,77.24 84.21,77.37 78.47,77.37 77.02,78.82 71.81,78.82 71.71,78.72 71.43,78.72 71.33,78.82 69.81,78.82 66.1,82.53 56.92,82.53 56.31,83.15 56.03,83.15 55.9,83.02 55.62,83.02 55.49,83.15 44.49,83.15 43.16,81.81 43.16,81.54 42.27,80.65 42.27,80.3 42.4,80.18 42.4,79.9 42.27,79.77 42.27,77.81 39.86,75.4 39.86,74.84 39.99,74.72 39.99,74.44 39.86,74.31 39.86,68.97 39.15,68.26 39.15,67.99 39.28,67.86 39.28,67.58 39.15,67.45 39.15,66.33 40.38,65.1 40.38,62.43 41.38,61.42 41.38,58.77 41.51,58.65 41.51,58.37 41.38,58.24 41.38,57.93 43.17,56.14 43.17,41.21 43.3,41.09 43.3,40.81 43.17,40.68 43.17,40.37 43.95,39.6 43.95,37.65 46.11,35.49 46.11,30.44 44.86,29.19 44.86,22.22 44.99,22.09 44.99,21.81 44.86,21.68 44.86,19.84 45.74,18.97 45.74,17.75 47.06,16.43 47.34,16.43 47.47,16.56 47.75,16.56 47.87,16.43 54.55,16.43 54.67,16.56 54.95,16.56 55.08,16.43 55.36,16.43 58.12,19.19 58.12,28.36 58,28.49 58,28.77 58.12,28.9 58.12,29.4 57.58,29.94 57.45,29.94 57.3,29.79 57.16,29.79 57.07,29.89 57.07,30.03 57.21,30.17 57.21,30.31 56.95,30.57 56.05,30.57 55.99,30.51 v1(55.95,30.18)
  BOTTOM w0.102: v1(111.45,78.43) 111.45,78.68 arc(111.4,78.78) 111.3,78.82 arc(111.23,78.8) 111.19,78.75 111.09,78.57 arc(110.9,78.38) 110.64,78.31 110.53,78.31 arc(110.27,78.38) 110.08,78.57 110.03,78.66 arc(109.91,78.77) 109.76,78.81 109.68,78.81 arc(109.52,78.77) 109.4,78.66 109.36,78.57 arc(109.17,78.38) 108.91,78.31 108.8,78.31 arc(108.54,78.38) 108.35,78.57 108.3,78.66 arc(108.18,78.77) 108.02,78.81 107.95,78.81 arc(107.79,78.77) 107.67,78.66 107.62,78.57 arc(107.43,78.38) 107.17,78.31 107.06,78.31 arc(106.8,78.38) 106.61,78.57 106.57,78.66 arc(106.45,78.77) 106.29,78.81 106.21,78.81 arc(106.06,78.77) 105.94,78.66 105.89,78.57 arc(105.7,78.38) 105.44,78.31 105.33,78.31 arc(105.07,78.38) 104.88,78.57 104.83,78.66 arc(104.72,78.77) 104.56,78.81 104.48,78.81 arc(104.32,78.77) 104.21,78.66 104.16,78.57 arc(103.97,78.38) 103.71,78.31 103.6,78.31 arc(103.34,78.38) 103.15,78.57 103.1,78.66 arc(102.99,78.77) 102.83,78.81 102.75,78.81 arc(102.59,78.77) 102.48,78.66 102.43,78.57 arc(102.24,78.38) 101.98,78.31 101.87,78.31 arc(101.61,78.38) 101.42,78.57 101.37,78.66 arc(101.25,78.77) 101.1,78.81 101.02,78.81 arc(100.86,78.77) 100.74,78.66 100.7,78.57 arc(100.51,78.38) 100.25,78.31 100.14,78.31 arc(99.88,78.38) 99.69,78.57 99.64,78.66 arc(99.52,78.77) 99.36,78.81 99.29,78.81 arc(99.13,78.77) 99.01,78.66 98.96,78.57 arc(98.77,78.38) 98.51,78.31 98.4,78.31 arc(98.14,78.38) 97.95,78.57 97.91,78.66 arc(97.79,78.77) 97.63,78.81 92.36,78.81 arc(92.2,78.77) 92.08,78.66 92.04,78.57 arc(91.85,78.38) 91.59,78.31 91.47,78.31 arc(91.22,78.38) 91.03,78.57 90.98,78.66 arc(90.86,78.77) 90.7,78.81 90.63,78.81 arc(90.47,78.77) 90.35,78.66 90.3,78.57 arc(90.11,78.38) 89.85,78.31 87.51,78.31 87.26,78.06 87.26,77.89 87.35,77.79 87.35,77.62 87.24,77.5 87.07,77.5 86.97,77.6 86.8,77.6 86.56,77.36 86.16,77.36 v1(85.8,77)
CLK_SYS_BAK_50M_P: length 174.3
  L16_SIG6 w0.079: v1(55.95,31.19) 55.95,30.9 56.05,30.8 57.04,30.8 58.35,29.49 58.35,19.1 55.46,16.2 46.96,16.2 45.51,17.65 45.51,18.87 44.63,19.75 44.63,29.29 45.88,30.53 45.88,35.39 43.72,37.55 43.72,39.5 42.95,40.28 42.95,56.05 41.16,57.84 41.16,61.33 40.15,62.33 40.15,65.01 38.92,66.23 38.92,68.36 39.63,69.07 39.63,75.49 42.04,77.9 42.04,80.75 42.93,81.64 42.93,81.91 44.4,83.37 56.4,83.37 57.02,82.76 66.19,82.76 69.9,79.05 77.11,79.05 78.56,77.6 84.31,77.6 84.44,77.47 85.42,77.47 v1(85.8,77.85)
  BOTTOM w0.102: v1(85.8,77.85) 86.06,77.59 86.47,77.59 87.42,78.54 89.85,78.54 arc(90,78.58) 90.11,78.69 90.15,78.77 arc(90.35,78.97) 90.63,79.04 90.7,79.04 arc(90.98,78.97) 91.18,78.77 91.22,78.69 arc(91.33,78.58) 91.47,78.54 91.59,78.54 arc(91.73,78.58) 91.84,78.69 91.89,78.77 arc(92.08,78.97) 92.36,79.04 97.63,79.04 arc(97.9,78.97) 98.1,78.77 98.15,78.69 arc(98.26,78.58) 98.4,78.54 98.51,78.54 arc(98.66,78.58) 98.77,78.69 98.81,78.77 arc(99.01,78.97) 99.29,79.04 99.36,79.04 arc(99.64,78.97) 99.84,78.77 99.88,78.69 arc(99.99,78.58) 100.14,78.54 100.25,78.54 arc(100.39,78.58) 100.5,78.69 100.55,78.77 arc(100.74,78.97) 101.02,79.04 101.1,79.04 arc(101.37,78.97) 101.57,78.77 101.62,78.69 arc(101.72,78.58) 101.87,78.54 101.98,78.54 arc(102.12,78.58) 102.23,78.69 102.28,78.77 arc(102.48,78.97) 102.75,79.04 102.83,79.04 arc(103.1,78.97) 103.3,78.77 103.35,78.69 arc(103.45,78.58) 103.6,78.54 103.71,78.54 arc(103.86,78.58) 103.96,78.69 104.01,78.77 arc(104.21,78.97) 104.48,79.04 104.56,79.04 arc(104.83,78.97) 105.03,78.77 105.08,78.69 arc(105.19,78.58) 105.33,78.54 105.44,78.54 arc(105.59,78.58) 105.69,78.69 105.74,78.77 arc(105.94,78.97) 106.21,79.04 106.29,79.04 arc(106.57,78.97) 106.76,78.77 106.81,78.69 arc(106.92,78.58) 107.06,78.54 107.17,78.54 arc(107.32,78.58) 107.43,78.69 107.47,78.77 arc(107.67,78.97) 107.95,79.04 108.02,79.04 arc(108.3,78.97) 108.5,78.77 108.54,78.69 arc(108.65,78.58) 108.8,78.54 108.91,78.54 arc(109.05,78.58) 109.16,78.69 109.21,78.77 arc(109.4,78.97) 109.68,79.04 109.76,79.04 arc(110.03,78.97) 110.23,78.77 110.28,78.69 arc(110.38,78.58) 110.53,78.54 110.64,78.54 arc(110.78,78.58) 110.89,78.69 110.99,78.86 arc(111.11,78.99) 111.27,79.05 arc(111.4,79.11) 111.45,79.24 v1(111.45,79.43)
CLK_UBII_M10: length 14.4
  L05_SIG2 w0.081: v1(30.83,26.02) 31.23,26.42 31.23,28.72 31.43,28.92 31.43,37.28 v1(33.47,39.32)
COMPA_1P8V: length 8.8
  TOP w0.203: v1(231.58,53.76) 231.58,54.54 231.22,54.89 226.85,54.89 226.5,54.54 226.5,53.89 v1(226.69,53.7)
  BOTTOM w0.305: v1(231.58,53.76) 231.69,53.65 C2004.2 ; v1(231.58,53.76) 231.55,53.74 C2003.2 ; v1(231.58,53.76) R6104.1
CORE_PMBUS_ALERTN: length 291.8
  L14_SIG5 w0.081: v1(257.35,23.46) 257.35,23.46 256.93,23.88 256.93,26.16 256.14,26.95 256.14,27.61 255.89,27.87 255.58,27.87 255.35,28.1 255.35,28.43 255.15,28.63 254.72,28.63 254.39,28.96 254.39,29.47 253.17,30.68 253.17,30.78 252.74,31.21 249.99,31.21 249.4,30.62 247.11,30.62 245.02,32.71 243.94,32.71 243.67,32.44 243.67,31.9 243.98,31.6 244.46,31.6 245.5,30.56 245.5,16.16 244.08,14.74 220.75,14.74 216.4,19.09 216.4,23.86 216.11,24.16 214.01,24.16 v1(213.37,23.51)
  BOTTOM w0.149: v1(213.37,23.51) 212.34,24.54 211.89,24.54 211.21,25.22 201.99,25.22 200.69,23.93 200.69,17.3 200.18,16.79 196.02,16.79 195,17.81 187.15,17.81 186.47,18.49 186.47,19.26 186.16,19.56 164.9,19.56 164.37,19.03 164.37,18.14 163.94,17.71 151.39,17.71 149.94,16.26 102.32,16.26 100.74,17.83 69.85,17.83 67.59,15.57 56.83,15.57 55.68,16.72 46.21,16.72 44.74,18.19 39.86,18.19 38.26,16.59 35.69,16.59 35.06,15.95 26.19,15.95 24.26,17.88 24.26,20.98 24.77,21.49 26.47,21.49 26.96,21.97 27.52,21.97 28.05,21.44 28.05,21.06 27.41,20.42 v1(26.83,20.42)
CORE_PMBUS_SCL: length 245.6
  L03_SIG1 w0.081: v1(14.68,47.7) 16.07,49.1 19.12,49.1 v1(19.63,48.59) 20.14,49.1 30.17,49.1 v1(30.68,48.59) 31.09,48.18 31.63,48.18 32.03,47.78 32.03,47.1 31.65,46.72 31.65,45.46 31.87,45.24 31.87,34.18 33.43,32.63 37.27,32.63 43.04,26.85 43.04,18.83 49.19,12.68 57.06,12.68 60.4,16.02 60.4,16.53 60.84,16.97 v1(61.48,16.97)
  L14_SIG5 w0.081: v1(61.48,16.97) 62.11,16.33 67.89,16.33 69.31,17.76 86.53,17.76 89.86,14.43 93.78,14.43 95.09,13.12 98.01,13.12 99.31,14.43 112.21,14.43 112.72,13.92 121.99,13.92 122.5,14.43 132.93,14.43 135.24,16.74 151.84,16.74 157.25,22.15 191.75,22.15 198.1,15.8 203.82,15.8 207.05,19.03 212.24,19.03 213.61,20.4 215.59,20.4 v1(216.03,20.84)
  BOTTOM w0.149: v1(30.68,48.59) 30.56,48.59 30.16,48.99 U20.2
CORE_PMBUS_SDA: length 245.2
  L03_SIG1 w0.081: v1(60.84,16.33) 60.84,15.83 57.28,12.27 48.92,12.27 42.58,18.62 42.58,21.2 42.16,21.62 42.16,27.09 37.09,32.17 33.18,32.17 30.91,34.44 30.91,47.47 v1(30.68,47.7) 30.17,48.21 20.14,48.21 v1(19.63,47.7) 19.25,48.08 16.83,48.08 v1(14.68,45.93)
  L14_SIG5 w0.081: v1(60.84,16.33) 60.84,16.97 61.32,17.45 67.61,17.45 68.28,18.12 87.08,18.12 90.14,15.06 93.88,15.06 95.27,13.67 97.29,13.67 98.69,15.06 112.03,15.06 112.86,14.24 121.85,14.24 122.43,14.82 132.15,14.82 134.4,17.07 151.7,17.07 157.02,22.39 188.25,22.39 189.19,23.32 190.92,23.32 197.27,16.97 201.3,16.97 202.32,17.99 205.37,17.99 206.65,19.27 210.65,19.27 v1(214.89,23.51)
  BOTTOM w0.149: U20.3 29.85,48.59 30.13,48.31 30.13,48.21 30.64,47.7 v1(30.68,47.7)
CPU_RESETN: length 443.9
  L05_SIG2 w0.081: v1(30.83,18.82) 31.21,19.21 37.42,19.21 38.28,18.34 41.69,18.34 43.14,16.89 60.92,16.89 61.22,16.59 65.54,16.59 68.33,13.79 89.9,13.79 93.53,10.16 107.83,10.16 111.43,13.77 117.91,13.77 121.26,17.12 121.26,18.59 122.45,19.78 124.61,19.78 126.15,21.32 140.76,21.32 140.98,21.54 147.7,21.54 148.05,21.19 149.34,21.19 149.66,21.52 152.92,21.52 153.25,21.19 162.92,21.19 163.51,20.6 163.51,18.06 167.77,13.79 170.95,13.79 171.66,14.51 189.69,14.51 190.46,13.74 193.3,13.74 193.94,14.38 210.8,14.38 211.75,13.43 248.61,13.43 249.99,14.81 249.99,20.04 249.77,20.27 249.77,20.63 251.37,22.23 251.92,22.23 252.94,23.24 252.94,28.4 254,29.46 259.15,29.46 259.53,29.83 263.06,29.83 267.22,33.99 267.22,43.79 268.56,45.14 268.56,53.6 267.98,54.18 267.98,58.88 266.33,60.53 265.5,60.53 v1(265.06,60.98)
  L12_SIG4 w0.089: v1(109.72,82.43) 109.61,82.32 108.59,82.32 108.31,82.05 107.69,82.05 107.38,82.36 106.89,82.36 106.58,82.05 106.05,82.05 105.55,81.55 105.18,81.55 104.68,81.05 104.67,81.05 104.67,81.05 104.28,81.05 104.18,81.15 99.38,81.15 98.79,80.55 98.25,80.55 97.74,80.04 95.16,80.04 94.22,80.98 93.86,80.98 93.52,81.33 93.04,81.33 92.57,81.8 92.09,81.8 91.84,81.55 91.18,81.55 90.91,81.83 90.73,81.83 90.18,82.37 84.94,82.37 83.45,80.88 80.27,80.88 78.01,83.14 66.81,83.14 63.13,79.45 59.95,79.45 53.85,73.36 53.85,71.07 52.59,69.8 52.59,68.02 50.43,65.86 50.43,63.83 49.28,62.69 48.01,62.69 45.8,60.48 43.9,60.48 42.42,59.01 42.42,58.1 38.25,53.93 35.69,53.93 32.9,51.13 32.9,49.74 32.2,49.04 29.41,49.04 27.44,47.07 26.55,47.07 22.36,42.88 22.36,28.78 22.11,28.53 22.11,23.83 23.68,22.26 23.68,19.97 25.53,18.11 30.12,18.11 v1(30.83,18.82)
  BOTTOM w0.149: v1(30.83,18.82) 30.27,18.26 29.75,18.26 R318.1
CT0: length 10.7
  L12_SIG4 w0.089: J8.12 17.51,95.82 16.77,95.07 16.77,94.25 v1(12.77,90.25)
CT1: length 7.8
  L12_SIG4 w0.089: v1(12.77,89.23) 13.6,90.06 13.6,90.26 J8.6
CT2: length 4.5
  BOTTOM w0.149: C213.1 19.12,83.65 J8.1
CT3: length 3.1
  BOTTOM w0.149: J8.7 20.67,82.15 20.9,81.93 C214.1
DAOUT0: length 1.3
  TOP w0.149: v1(195.43,60.32) 196.07,60.32 196.14,60.24 U47.11
DDR4_CH0_EVENT_N: length 18.9
  L14_SIG5 w0.081: v1(106.25,82.43) 106.25,82.77 104.94,84.08 104.94,84.81 103.67,86.08 103.67,86.81 103.22,87.26 103.22,90.07 102.34,90.95 102.34,95.33 102.84,95.84 104.78,95.84 v1(105.19,95.43)
  BOTTOM w0.149: R49.2 v1(106.25,82.43)
DDR4_CH0_SAVE_N: length 21.2
  L14_SIG5 w0.081: v1(104.54,94.92) 103.87,94.92 103.45,95.34 103.02,95.34 102.72,95.03 102.72,93.92 103.27,93.37 103.27,91.9 103.11,91.74 103.11,90.77 104.06,89.82 104.06,86.15 105.26,84.95 105.26,84.22 106.66,82.82 106.66,81.39 v1(107.12,80.93)
  BOTTOM w0.149: v1(107.12,80.93) 106.69,81.36 106.69,82.5 107.12,82.93 R50.2
DDR4_CH1_EVENT_N: length 20.1
  L14_SIG5 w0.081: v1(95.92,94.95) 96.64,94.23 97.14,94.23 99.79,91.58 99.79,90.95 100.55,90.19 100.55,89.11 100.88,88.78 101.33,88.78 102.13,87.99 102.13,86.26 102.58,85.81 102.97,85.81 103.83,84.94 103.83,83.47 104.21,83.1 104.91,83.1 105.39,82.62 v1(105.39,81.93)
  BOTTOM w0.149: v1(105.39,81.93) 105,82.31 105,82.63 104.52,83.11 R672.2
DDR4_CH1_SAVE_N: length 22
  L14_SIG5 w0.081: v1(106.25,81.43) 105.8,81.88 105.8,82.6 104.14,84.26 104.14,85.16 103.25,86.05 103.25,86.6 102.93,86.92 102.7,86.92 102.41,87.21 102.41,88.18 101.56,89.04 101.56,89.85 100.6,90.81 100.6,91.61 97.7,94.5 97.08,94.5 96.16,95.43 v1(95.27,95.43)
  BOTTOM w0.149: v1(106.25,81.43) 105.91,81.77 105.91,82.14 105.39,82.66 R673.2
DDR4_CH2_EVENT_N: length 52.1
  L05_SIG2 w0.081: v1(156.62,39.43) 155.95,40.1 155.95,40.73 153.04,43.64 147.96,43.64 146.1,41.78 142.45,41.78 141.92,42.3 141.44,42.3 141.19,42.05 140.69,42.05 140.45,42.3 139.63,42.3 139.39,42.05 138.86,42.05 138.6,42.31 138.08,42.31 137.59,42.8 137.12,42.8 136.87,42.56 136.29,42.56 135.86,42.98 135.41,42.98 135.01,43.39 134.72,43.39 134.23,43.87 133.78,43.87 133.27,44.38 132.93,44.38 132.42,44.89 132.06,44.89 131.54,45.41 131.15,45.41 130.71,45.85 130.3,45.85 129.72,46.43 v1(128.77,46.43)
  BOTTOM w0.149: U4.2 153.14,30.53 153.42,30.81 153.42,31.45 154.44,32.46 154.44,37.24 v1(156.62,39.43) ; v1(128.77,46.43) 129.2,46 129.2,41.13 129.64,40.69 R674.2
DDR4_CH2_SAVE_N: length 54.6
  L05_SIG2 w0.081: v1(128.77,47.43) 129.83,47.43 130.37,46.89 130.67,46.89 131.13,46.43 131.49,46.43 131.97,45.95 132.3,45.95 132.86,45.39 133.27,45.39 133.75,44.91 134.23,44.91 134.7,44.45 134.99,44.45 135.49,43.94 135.83,43.94 136.37,43.41 136.8,43.41 137.15,43.05 137.63,43.05 138.13,42.55 138.61,42.55 138.86,42.8 139.61,42.8 139.86,42.56 140.26,42.56 140.51,42.8 141.22,42.8 141.47,42.56 141.97,42.56 142.49,42.03 143.01,42.03 143.35,42.37 146.18,42.37 147.84,44.02 153.3,44.02 156.25,41.06 156.25,40.27 156.47,40.06 156.64,40.06 157.11,39.59 157.11,38.91 v1(156.62,38.43)
  BOTTOM w0.149: U4.3 153.79,31.31 154.95,32.46 154.95,36.75 v1(156.62,38.43) ; v1(128.77,47.43) 128.77,47.06 129.4,46.43 129.8,46.43 130.08,46.15 130.08,41.15 130.5,40.73 R675.2
DDR4_CH3_EVENT_N: length 53.2
  L05_SIG2 w0.081: v1(156.62,37.43) 155.63,38.42 155.63,40.42 152.66,43.39 148.22,43.39 146.19,41.36 141.7,41.36 141.26,41.8 140.65,41.8 140.35,41.5 139.74,41.5 139.44,41.8 138.78,41.8 138.48,41.5 138.05,41.5 137.66,41.88 137.27,41.88 136.85,42.3 136.14,42.3 135.89,42.05 135.48,42.05 135.1,42.43 134.6,42.43 134.15,42.88 133.73,42.88 133.16,43.45 132.81,43.45 132.33,43.92 131.96,43.92 131.49,44.39 131.19,44.39 130.68,44.9 130.3,44.9 129.83,45.37 129.44,45.37 128.97,45.84 128.59,45.84 128.23,46.2 128.23,46.6 v1(127.9,46.93)
  BOTTOM w0.149: U4.4 154.44,30.43 156.22,32.21 156.22,37.02 v1(156.62,37.43) ; R676.2 128.77,40.76 128.35,41.18 128.35,46.48 v1(127.9,46.93)
DDR4_CH3_SAVE_N: length 55.4
  L05_SIG2 w0.081: v1(127.9,47.93) 127.46,47.48 127.46,45.73 127.75,45.44 128.09,45.44 128.61,44.91 129.05,44.91 129.57,44.39 129.94,44.39 130.39,43.95 130.75,43.95 131.23,43.47 131.61,43.47 132.08,43 132.45,43 132.91,42.55 133.27,42.55 133.8,42.01 134.18,42.01 134.65,41.55 135.16,41.55 135.44,41.82 135.99,41.82 136.63,41.18 137.04,41.18 137.32,40.9 146.23,40.9 148.34,43 152.41,43 155.05,40.36 155.05,38 v1(156.62,36.43)
  BOTTOM w0.149: v1(156.62,36.43) 156.62,31.93 156.85,31.7 156.85,31.31 155.09,29.54 U4.5 ; R677.2 127.9,41.03 127.46,41.46 127.46,47.49 v1(127.9,47.93)
DDR4_DIMM0_EVENT_N: length 51.3
  L05_SIG2 w0.081: v1(105.19,101.2) 107.25,101.2 112.61,106.56 120.2,106.56 120.96,105.79 120.96,104.73 121.8,103.89 121.8,103.41 124.59,100.61 125.86,100.61 127.03,99.44 127.72,99.44 128.05,99.77 129.27,99.77 129.65,99.39 130.26,99.39 130.46,99.6 131.55,99.6 132.77,100.82 133.1,100.82 v1(133.51,100.41)
  BOTTOM w0.149: v1(136.74,91.44) 137.2,91.9 139.2,91.9 139.45,92.15 R4.1 139.06,92.6 138.92,92.74 138.92,96.52 138.51,96.93 135.31,96.93 133.51,98.73 v1(133.51,100.41)
DDR4_DIMM0_SAVE_N: length 47.6
  L12_SIG4 w0.089: v1(104.54,101.81) 104.54,101.11 105.02,100.64 116.07,100.64 117.13,99.57 124.9,99.57 125.63,100.3 127.98,100.3 128.32,100.64 130.07,100.64 130.64,101.22 132.21,101.22 133.62,102.64 133.62,103.39 134.54,104.3 136.45,104.3 137.29,103.46 140.66,103.46 141.14,102.98 v1(141.4,102.98)
  BOTTOM w0.149: v1(141.4,102.98) 141.87,102.51 141.87,100.03 142.76,99.14 142.76,98.23 v1(143.54,97.44)
DDR4_DIMM1_EVENT_N: length 54.3
  L12_SIG4 w0.089: v1(95.92,101.2) 96.95,100.17 114.35,100.17 115.02,99.5 116.69,99.5 116.97,99.22 125,99.22 125.55,99.77 126.89,99.77 127.18,99.48 127.6,99.48 128.53,100.4 130.17,100.4 130.74,100.98 132.56,100.98 133.87,102.28 133.87,103.17 134.66,103.96 135.77,103.96 137.17,102.57 138.73,102.57 v1(139.14,102.98)
  BOTTOM w0.149: v1(139.14,102.98) 138.95,102.78 138.95,100.32 139.05,100.22 R22.1 139.45,99.65 139.33,99.52 137.2,99.52 v1(136.74,99.06)
DDR4_DIMM1_SAVE_N: length 52.1
  L12_SIG4 w0.089: v1(95.27,101.81) 95.45,101.98 96.53,101.98 97.44,101.07 101.15,101.07 101.68,101.6 102.8,101.6 103.87,102.67 112.32,102.67 113.13,101.86 124.84,101.86 125.16,101.54 127.46,101.54 127.82,101.89 131.96,101.89 133.05,102.98 133.05,103.72 134.79,105.46 143.14,105.46 v1(143.54,105.06)
DDR4_DIMM2_EVENT_N: length 60.2
  BOTTOM w0.149: U4.13 153.14,23.28 153.57,23.72 156.77,23.72 157.11,23.38 157.11,20.51 154.99,18.39 147.99,18.39 146.95,17.35 127.64,17.35 125.98,19.01 125.98,30.82 124.39,32.42 v1(122.29,32.42) 121.91,32.03 120.31,32.03 R56.1
DDR4_DIMM2_SAVE_N: length 40.3
  L05_SIG2 w0.081: v1(115.49,26.42) 115.68,26.23 116.82,26.23 117.05,26 119.53,26 121.19,24.34 124.31,24.34 126.6,22.04 140.34,22.04 140.55,22.25 148.95,22.25 149.11,22.1 152.92,22.1 152.96,22.15 v1(153.81,22.15)
DDR4_DIMM3_EVENT_N: length 33.9
  L05_SIG2 w0.081: v1(122.37,24.8) 122.46,24.71 124.41,24.71 126.75,22.36 140.02,22.36 140.85,23.19 142.63,23.19 143.24,22.58 149.11,22.58 149.28,22.41 149.69,22.41 149.82,22.53 154.19,22.53 v1(154.44,22.78)
DDR4_DIMM3_SAVE_N: length 46.5
  L05_SIG2 w0.081: v1(155.09,22.15) 154.61,21.67 153.52,21.67 153.37,21.82 149.49,21.82 149.09,21.43 148.68,21.43 148.19,21.92 140.85,21.92 140.62,21.69 126.47,21.69 124.08,24.09 121.05,24.09 119.95,25.19 118.37,25.19 117.46,24.28 117.46,23.3 115.79,21.63 115.79,19.09 v1(115.49,18.8)
DDR4_DIMM_CH0_A0: length 86.6
  L16_SIG6 w0.081: v1(137.59,91.44) 137.59,89.92 137.83,89.68 137.83,84.5 137.97,84.35 138.2,84.35 138.36,84.51 138.36,88.76 139.82,90.23 140.63,90.23 141.43,91.03 141.43,95.99 141.33,96.08 140.54,96.08 140.44,95.98 140.44,95.8 140.54,95.69 140.97,95.69 141.09,95.58 141.09,94.05 140.99,93.95 140.85,93.95 140.76,94.05 140.76,95.07 140.66,95.17 140.52,95.17 140.42,95.07 140.42,92.96 140.32,92.86 140.18,92.86 140.09,92.96 140.09,94.93 139.99,95.03 139.85,95.03 139.75,94.93 139.75,92.97 139.65,92.87 139.51,92.87 139.41,92.97 139.41,96.24 139.32,96.33 139.18,96.33 139.08,96.24 139.08,94.05 138.98,93.95 138.84,93.95 138.74,94.05 138.74,94.75 138.64,94.85 138.45,94.85 138.1,94.5 136.94,94.5 136.84,94.4 136.84,94.26 136.94,94.16 137.94,94.16 138.04,94.06 138.04,93.93 137.94,93.83 136.94,93.83 136.84,93.73 136.84,93.59 136.94,93.49 137.94,93.49 138.04,93.39 138.04,93.26 137.94,93.16 137.22,93.16 137.12,93.06 137.12,92.92 137.22,92.82 137.52,92.82 137.62,92.72 137.62,92.58 137.52,92.49 136.31,92.49 135.7,91.87 135.7,91.01 136.89,89.82 136.89,82.93 136.29,82.33 136.29,81.49 135.7,80.9 135.63,80.9 135.21,80.48 135.21,79.78 134.95,79.52 134.75,79.52 134.4,79.17 134.4,78.97 133.57,78.15 133.57,77.85 133.24,77.52 132.73,77.52 132.42,77.83 131.95,77.83 131.56,77.44 131.17,77.44 130.65,76.91 130.23,76.91 129.74,76.42 129.36,76.42 128.84,75.9 128.57,75.9 128.23,75.56 127.53,75.56 127.19,75.9 126.83,75.9 126.37,75.44 126.01,75.44 125.56,75.9 125.07,75.9 124.62,75.44 124.19,75.44 123.73,75.9 123.35,75.9 122.89,75.44 122.43,75.44 121.95,75.92 121.62,75.92 121.14,75.44 120.89,75.44 120.38,74.93 119.84,74.93 119.34,75.44 119.05,75.44 118.54,74.93 v1(117.51,74.93)
DDR4_DIMM_CH0_A1: length 88.4
  L03_SIG1 w0.081: v4(117.51,73.93) 117.2,73.61 117.2,73.36 116.84,73.01 116.84,72.8 117.01,72.64 117.21,72.64 117.33,72.52 117.33,72.32 116.9,71.89 116.9,71.71 117.3,71.3 117.53,71.3 118.03,71.81 118.63,71.81 118.96,71.48 119.52,71.48 119.84,71.8 120.27,71.8 120.75,71.32 121.2,71.32 121.69,71.81 122.06,71.81 122.57,72.32 122.93,72.32 123.49,72.88 123.92,72.88 124.09,73.05 124.09,73.66 124.01,73.74 123.83,73.74 123.72,73.86 123.72,74.04 123.82,74.15 123.96,74.15 124.11,74.3 124.11,74.45 123.74,74.82 123.74,75.05 123.98,75.29 123.98,76.58 123.79,76.78 123.79,77.09 123.98,77.28 123.98,77.62 123.81,77.79 123.81,78.13 123.98,78.3 123.98,78.6 123.77,78.81 123.77,79.05 123.98,79.27 123.98,79.57 123.72,79.83 123.72,80.03 123.98,80.29 123.98,80.67 123.76,80.89 123.76,81.05 123.98,81.27 123.98,81.58 123.77,81.79 123.77,82.08 123.98,82.29 123.98,82.57 123.73,82.82 123.73,83.04 123.98,83.29 123.98,84.13 124.8,84.95 125.56,84.95 125.69,85.09 125.69,87.8 126.11,88.22 126.11,88.46 128.53,90.88 128.67,90.88 128.77,90.78 128.77,90.64 127.14,89.02 127.14,88.88 127.24,88.78 127.38,88.78 129.14,90.54 129.14,90.91 129.52,91.28 129.71,91.28 130.19,90.8 130.42,90.8 130.55,90.94 130.55,91.16 130.15,91.55 130.15,91.7 130.37,91.92 132.27,91.92 133.01,92.65 133.01,96.54 133.19,96.72 133.19,97.37 133.39,97.56 136.3,97.56 136.65,97.92 138.33,97.92 138.44,98.03 138.44,98.45 138.06,98.83 137.92,98.83 137.75,98.65 137.44,98.65 137.18,98.92 137.18,99.44 137.46,99.72 137.46,99.89 137.32,100.03 137.14,100.03 136.36,99.24 134.24,99.24 134.14,99.14 134.14,99 134.24,98.91 136.31,98.91 136.41,98.81 136.41,98.67 136.31,98.57 133.64,98.57 133.51,98.7 133.51,98.91 133.41,99.01 133.23,99.01 133.13,98.91 133.13,98.33 133.23,98.23 136.08,98.23 136.18,98.14 136.18,98 136.08,97.9 133.04,97.9 132.8,97.67 132.8,96.81 132.68,96.69 132.68,92.95 132.1,92.37 130.35,92.37 130.17,92.55 129.79,92.55 129.16,91.92 127.94,91.92 127.78,91.77 126.87,91.77 v4(126.54,91.44)
DDR4_DIMM_CH0_A2: length 86.2
  L03_SIG1 w0.081: v4(118.38,74.43) 118.38,74.8 118.8,75.22 119.01,75.22 119.15,75.36 119.15,75.5 119.05,75.6 118.73,75.6 118.48,75.85 118.48,76.01 118.72,76.24 119.03,76.24 119.15,76.36 119.15,76.51 119.05,76.61 118.73,76.61 118.52,76.81 118.52,77.04 118.77,77.29 118.98,77.29 119.08,77.39 119.08,77.54 118.98,77.64 118.7,77.64 118.52,77.81 118.52,78.05 118.72,78.25 119.03,78.25 119.14,78.36 119.14,78.5 119.04,78.6 118.74,78.6 118.52,78.82 118.52,79.04 118.75,79.26 119.05,79.26 119.14,79.35 119.14,79.51 119.03,79.62 118.72,79.62 118.53,79.81 118.53,80.04 118.75,80.26 119.05,80.26 119.14,80.35 119.14,80.51 119.04,80.61 118.72,80.61 118.52,80.81 118.52,81.04 118.7,81.21 118.98,81.21 119.11,81.34 119.11,81.5 118.98,81.62 118.72,81.62 118.52,81.82 118.52,82.03 118.76,82.28 118.76,82.74 118.87,82.84 119.1,82.84 119.18,82.76 119.18,82.39 119.27,82.3 119.41,82.3 119.52,82.41 119.52,82.74 119.62,82.84 120.07,82.84 120.17,82.94 120.17,83.08 120.07,83.18 118.44,83.18 118.35,83.28 118.35,83.42 118.44,83.52 120.06,83.52 120.17,83.62 120.17,83.75 120.07,83.85 118.66,83.85 118.57,83.95 118.57,84.09 118.66,84.19 119.64,84.19 119.73,84.28 119.73,84.42 119.64,84.52 118.8,84.52 118.7,84.62 118.7,84.76 118.8,84.86 119.8,84.86 119.9,84.95 119.9,85.09 119.8,85.19 118.86,85.19 118.76,85.29 118.76,85.43 118.86,85.53 119.69,85.53 119.78,85.62 119.78,85.76 119.69,85.86 118.71,85.86 118.61,85.96 118.61,86.1 118.71,86.2 119.51,86.2 119.61,86.3 119.61,86.43 119.51,86.53 118.8,86.53 118.7,86.63 118.7,86.77 118.8,86.87 119.65,86.87 119.75,86.97 119.75,87.11 119.65,87.2 118.87,87.2 118.77,87.3 118.77,87.44 118.87,87.54 119.56,87.54 119.66,87.64 119.66,87.78 119.56,87.87 118.69,87.87 118.59,87.97 118.59,88.11 118.69,88.21 119.6,88.21 119.7,88.31 119.7,88.45 119.6,88.54 118.79,88.54 118.7,88.64 118.7,88.78 118.79,88.88 120.06,88.88 120.16,88.98 120.16,89.12 120.06,89.21 118.55,89.21 118.45,89.31 118.45,89.45 118.55,89.55 120.08,89.55 120.18,89.65 120.18,89.79 120.08,89.89 118.56,89.89 118.46,89.98 118.46,90.12 118.56,90.22 120.07,90.22 120.17,90.32 120.17,90.46 120.07,90.56 118.95,90.56 118.85,90.65 118.85,90.82 118.96,90.93 120.09,90.93 120.18,91.02 120.18,91.17 120.09,91.26 119.39,91.26 119.29,91.36 119.29,91.75 119.07,91.98 119.07,92.12 119.19,92.25 119.34,92.25 119.92,91.67 120.11,91.67 120.21,91.77 120.21,91.93 120.09,92.05 120.09,92.19 120.19,92.29 120.19,92.58 120.56,92.95 120.97,92.95 121.91,93.89 122.16,93.89 122.28,94.01 122.28,94.26 122.4,94.39 123.63,94.39 124.13,94.89 124.13,95.32 124.24,95.42 124.52,95.42 124.72,95.21 124.87,95.21 125.56,95.9 125.78,95.9 126.2,95.48 126.2,95.34 125.75,94.88 125.62,94.88 125.42,95.08 125.27,95.08 125.1,94.91 125.1,94.69 126.12,93.66 126.26,93.66 126.36,93.76 126.36,93.9 125.89,94.37 125.89,94.51 125.98,94.61 126.12,94.61 126.5,94.23 126.64,94.23 126.74,94.33 126.74,94.47 126.34,94.86 126.34,95 126.44,95.1 126.58,95.1 127.14,94.54 130.17,94.54 130.26,94.63 130.26,94.85 130.17,94.94 129.2,94.94 129.04,95.1 128.26,95.1 128.09,94.94 127.22,94.94 126.05,96.1 126.05,96.24 126.15,96.34 126.29,96.34 127.29,95.34 127.43,95.34 127.53,95.44 127.53,95.58 126.83,96.27 126.83,96.61 126.66,96.79 126.32,96.79 126.19,96.91 126.19,97.09 v4(126.54,97.44)
DDR4_DIMM_CH0_A3: length 86.2
  L03_SIG1 w0.081: v4(125.69,91.44) 125.69,91.64 126.91,92.86 127.74,92.86 127.95,92.65 128.9,92.65 129.55,93.3 130.2,93.3 130.41,93.51 131.96,93.51 132.06,93.61 132.06,93.75 131.96,93.85 130.51,93.85 130.41,93.95 130.41,94.09 130.51,94.18 131.96,94.18 132.06,94.28 132.06,94.42 131.96,94.52 130.71,94.52 130.61,94.62 130.61,94.76 130.71,94.85 131.96,94.85 132.05,94.95 132.05,95.09 131.96,95.19 131.65,95.19 131.55,95.29 131.55,95.43 131.65,95.52 131.91,95.52 132.1,95.72 132.24,95.72 132.35,95.62 132.35,93.28 132.24,93.18 130.55,93.18 130.32,92.94 129.68,92.94 129,92.26 127.84,92.26 127.57,92.52 127.06,92.52 126.12,91.59 126.12,91.31 126.37,91.06 126.6,91.06 126.7,90.96 126.7,90.51 125.24,89.06 125.24,88.92 125.34,88.82 125.48,88.82 127.05,90.39 127.05,91.32 127.14,91.4 127.47,91.4 127.57,91.3 127.57,91.14 127.39,90.96 127.39,90.26 125.75,88.62 125.75,88.34 125.34,87.93 125.09,87.93 124.88,87.72 124.88,87.27 125.34,86.81 125.34,86.02 124.27,84.95 124.09,84.95 123.97,85.08 123.97,86.74 123.83,86.88 122.3,86.88 122.2,86.78 122.2,86.64 122.3,86.54 123.1,86.54 123.2,86.44 123.2,86.3 123.1,86.21 122.19,86.21 122.09,86.11 122.09,85.97 122.19,85.87 123.12,85.87 123.21,85.77 123.21,85.63 123.12,85.53 122.33,85.53 122.23,85.44 122.23,85.3 122.33,85.2 123.26,85.2 123.35,85.1 123.35,84.96 123.26,84.86 122.38,84.86 122.24,84.72 122.24,84.53 122.38,84.39 123.13,84.39 123.23,84.29 123.23,84.07 123.13,83.97 122.19,83.97 122.09,83.87 122.09,83.73 122.19,83.63 123.05,83.63 123.15,83.53 123.15,83.39 123.05,83.3 122.34,83.3 122.24,83.2 122.24,83.06 122.34,82.96 123.19,82.96 123.29,82.86 123.29,82.7 123.21,82.61 122.72,82.61 122.63,82.52 122.63,82.39 122.72,82.3 123.08,82.3 123.25,82.13 123.25,81.71 123.14,81.6 122.88,81.6 122.79,81.51 122.79,81.35 122.88,81.27 123.19,81.27 123.41,81.04 123.41,80.85 123.16,80.6 122.89,80.6 122.8,80.51 122.8,80.35 122.89,80.26 123.21,80.26 123.4,80.07 123.4,79.81 123.19,79.6 122.87,79.6 122.79,79.51 122.79,79.35 122.87,79.26 123.18,79.26 123.43,79.02 123.43,78.84 123.18,78.6 122.89,78.6 122.81,78.51 122.81,78.35 122.89,78.26 123.18,78.26 123.45,78 123.45,77.84 123.2,77.6 122.88,77.6 122.79,77.51 122.79,77.35 122.88,77.26 123.15,77.26 123.42,76.99 123.42,76.85 123.17,76.6 122.9,76.6 122.81,76.51 122.81,76.35 122.9,76.26 123.21,76.26 123.44,76.03 123.44,75.88 123.18,75.62 123.18,75.28 123.32,75.14 123.32,74.72 123.11,74.51 123.11,74.26 123.32,74.05 123.32,73.91 123.01,73.59 122.87,73.59 122.78,73.51 122.78,73.36 122.88,73.26 123.01,73.26 123.11,73.16 123.11,72.8 122.85,72.53 122.49,72.53 121.97,72.02 121.6,72.02 121.11,71.52 120.84,71.52 120.35,72.01 119.72,72.01 119.62,72.12 119.62,72.44 119.52,72.54 118.93,72.54 118.85,72.46 118.85,72.3 118.6,72.05 118.07,72.05 117.83,72.29 117.83,72.53 118.08,72.78 118.08,73.04 117.72,73.4 117.72,73.54 117.92,73.75 118.06,73.75 v4(118.38,73.43)
DDR4_DIMM_CH0_A4: length 84.6
  L14_SIG5 w0.081: v1(124.84,97.44) 124.45,97.05 123.8,97.05 123.61,97.23 123.61,98.8 123.38,99.03 121.28,99.03 120.56,98.31 120.56,96.85 119.09,95.38 118.95,95.38 118.85,95.48 118.85,95.62 119.67,96.44 119.67,96.58 119.57,96.67 119.43,96.67 118.41,95.66 118.41,94.67 118.26,94.52 118.26,92.55 118.17,92.45 118.03,92.45 117.93,92.55 117.93,94.91 117.83,95.01 117.69,95.01 117.59,94.91 117.59,93.06 117.49,92.96 116.87,92.96 116.41,93.41 116.27,93.41 116.11,93.25 116.11,93.1 116.67,92.54 116.67,92.37 116.54,92.25 116.4,92.25 116.12,92.53 115.98,92.53 115.88,92.43 115.88,92.29 116.17,92.01 116.17,91.87 116.07,91.77 115.93,91.77 115.64,92.06 115.5,92.06 115.41,91.96 115.41,91.82 115.69,91.53 115.69,91.4 115.01,90.71 113.94,90.71 113.38,91.26 113.38,91.77 113.28,91.87 112.84,91.87 112.74,91.97 112.74,92.11 112.84,92.21 113.71,92.21 113.81,92.31 113.81,92.44 113.71,92.54 111.29,92.54 111.2,92.64 111.2,92.78 111.29,92.88 112.65,92.88 112.75,92.98 112.75,93.11 112.65,93.21 110.93,93.21 110.79,93.07 110.79,92.06 110.32,91.6 110.32,89.03 110.23,88.93 110.09,88.93 109.99,89.03 109.99,90.45 109.89,90.55 109.75,90.55 109.65,90.45 109.65,86.98 109.75,86.88 109.89,86.88 109.99,86.98 109.99,88.35 110.09,88.45 110.23,88.45 110.32,88.35 110.32,86.87 110.58,86.61 110.58,85.18 110.68,85.08 110.88,85.08 110.98,85.18 110.98,86.05 111.11,86.18 112.87,86.18 112.97,86.08 112.97,85.95 112.87,85.85 111.88,85.85 111.78,85.75 111.78,85.61 111.88,85.51 112.68,85.51 112.78,85.41 112.78,85.27 112.68,85.18 111.76,85.18 111.66,85.08 111.66,84.94 111.76,84.84 112.74,84.84 112.84,84.74 112.84,84.6 112.74,84.51 111.96,84.51 111.86,84.41 111.86,84.27 111.96,84.17 112.91,84.17 113.13,83.95 114.89,83.95 114.99,83.85 114.99,83.71 114.89,83.61 114.17,83.61 114.07,83.52 114.07,83.38 114.17,83.28 115.74,83.28 116.26,82.76 116.4,82.76 116.5,82.86 116.5,83 116.04,83.45 116.04,83.59 116.14,83.69 116.28,83.69 117.11,82.86 117.11,77.65 117.33,77.43 117.71,77.43 117.94,77.2 117.94,76.2 118.17,75.97 118.57,75.97 119.24,75.31 v1(119.24,74.93)
DDR4_DIMM_CH0_A5: length 85.3
  L14_SIG5 w0.081: v1(119.24,73.93) 118.76,74.41 118.76,74.92 118.62,75.05 118.48,75.05 118.35,74.92 118.35,74.59 118.24,74.49 118.03,74.49 117.93,74.59 117.93,75.16 117.71,75.38 117.29,75.38 116.86,74.96 116.49,74.96 116.06,75.38 115.62,75.38 115.07,75.93 114.78,75.93 114.48,76.24 114.48,81.1 114.19,81.4 113.84,81.4 113.3,81.93 112.99,81.93 112.58,82.34 111.99,82.34 111.89,82.44 111.89,82.6 111.99,82.7 112.49,82.7 112.58,82.79 112.58,82.92 112.41,83.09 110.5,83.09 109.01,84.58 108.87,84.58 108.77,84.48 108.77,84.34 109.57,83.54 109.57,83.4 109.47,83.31 109.33,83.31 108.39,84.25 108.39,84.58 108.05,84.92 108.05,85.21 107.16,86.1 107.16,86.81 107.26,86.91 107.5,86.91 107.6,87.01 107.6,87.14 107.5,87.24 107.26,87.24 107.16,87.34 107.16,87.48 107.26,87.58 107.5,87.58 107.6,87.68 107.6,87.81 107.5,87.91 107.26,87.91 107.16,88.01 107.16,89 106.95,89.21 106.95,89.7 107.16,89.92 107.16,91.03 107.52,91.39 108.19,91.39 108.29,91.49 108.29,91.62 108.19,91.72 107.37,91.72 107.26,91.84 107.26,92.19 107.14,92.3 106.81,92.3 106.71,92.4 106.71,92.53 106.81,92.64 107.17,92.64 107.27,92.74 107.27,92.87 107.17,92.97 106.55,92.97 106.23,92.65 106.01,92.65 105.84,92.82 105.84,93.21 105.95,93.31 107.13,93.31 107.26,93.44 107.26,95.14 107.16,95.24 107.02,95.24 106.92,95.14 106.92,94.15 106.83,94.05 106.69,94.05 106.59,94.15 106.59,96.86 106.69,96.96 106.83,96.96 106.92,96.86 106.92,95.8 107.02,95.7 107.16,95.7 107.26,95.8 107.26,97.15 107.36,97.25 107.49,97.25 107.59,97.15 107.59,96.69 107.7,96.58 107.83,96.58 107.93,96.69 107.93,96.97 108.27,97.31 109.04,97.31 109.3,97.05 110.67,97.05 110.92,97.3 111.55,97.3 111.8,97.05 115.96,97.05 116.91,98 116.91,98.14 116.81,98.24 116.67,98.24 116.03,97.6 115.89,97.6 115.79,97.7 115.79,97.84 117.07,99.11 117.21,99.11 117.54,98.78 117.68,98.78 117.78,98.88 117.78,99.02 117.44,99.35 117.44,99.49 117.68,99.72 119.33,99.72 119.51,99.54 119.51,98.86 119.42,98.77 119.28,98.77 119.18,98.86 119.18,99.27 119.08,99.37 118.94,99.37 118.84,99.27 118.84,98.06 119.29,97.61 119.29,97.31 119.57,97.02 119.91,97.02 120.17,97.28 120.17,98.4 121.15,99.38 125.1,99.38 125.2,99.28 125.2,99.15 125.1,99.05 124.06,99.05 123.96,98.94 123.96,98.81 124.06,98.71 124.73,98.71 124.87,98.57 124.87,97.97 124.77,97.87 124.1,97.87 123.99,97.76 v1(123.99,97.44)
DDR4_DIMM_CH0_A6: length 82.6
  L14_SIG5 w0.081: v1(123.99,91.44) 124.58,92.02 124.73,92.02 125.71,91.04 125.85,91.04 125.96,91.15 125.96,91.3 125.14,92.11 125.14,92.25 125.24,92.35 125.38,92.35 126.76,90.97 127.25,90.97 127.62,91.33 127.62,91.53 127.52,91.63 127.32,91.63 127.07,91.37 126.83,91.37 125.09,93.11 125.09,93.25 125.19,93.35 125.33,93.35 126.77,91.91 126.91,91.91 127.01,92.01 127.01,92.14 125.22,93.93 125.22,94.07 125.32,94.17 125.46,94.17 127.13,92.5 127.27,92.5 127.37,92.59 127.37,92.73 126.13,93.97 126.13,94.11 126.23,94.21 126.37,94.21 127.89,92.69 127.89,92.08 128.02,91.95 128.77,91.95 128.86,92.05 128.86,92.18 127.07,93.98 127.07,94.12 127.17,94.22 127.3,94.22 128.92,92.6 129.06,92.6 129.16,92.7 129.16,92.84 128.02,93.97 128.02,94.11 128.12,94.21 128.26,94.21 129.54,92.93 129.54,92 130.5,91.04 130.5,90.81 130.4,90.71 130.21,90.71 130.12,90.61 130.12,90.47 130.21,90.38 130.4,90.38 130.5,90.28 130.5,90.14 130.4,90.04 130.21,90.04 130.12,89.94 130.12,89.8 130.21,89.71 130.4,89.71 130.5,89.61 130.5,89.03 130.12,88.65 130.12,84.16 129.78,83.83 128.6,83.83 128.36,83.59 128.36,83.06 127.26,81.96 126.88,81.96 126.36,81.43 125.96,81.43 125.46,81.93 125.05,81.93 124.87,81.75 124.87,76.55 124.74,76.42 124.19,76.42 124.02,76.59 124.02,81.74 123.82,81.95 123.3,81.95 123.11,81.77 123.11,74.54 122.93,74.35 122.5,74.35 122.29,74.57 122.29,75.72 122.07,75.94 121.66,75.94 121.44,75.72 121.44,73.36 121.34,73.26 121.2,73.26 121.1,73.36 121.1,75.37 121,75.47 120.86,75.47 120.77,75.37 120.77,74.11 120.66,74.01 120.52,74.01 v1(120.11,74.43)
DDR4_DIMM_CH0_A7: length 83.7
  L14_SIG5 w0.081: v1(120.11,73.43) 119.66,73.88 119.66,75.71 119.84,75.89 120.34,75.89 120.55,76.11 120.55,81.67 120.27,81.96 119.92,81.96 119.19,82.68 119.19,83.83 119.59,84.22 119.59,88.97 119.75,89.13 120.04,89.13 120.13,89.23 120.13,89.37 120.04,89.46 119.75,89.46 119.65,89.56 119.65,89.7 119.75,89.8 123.48,89.8 123.58,89.9 123.58,90.14 123.48,90.24 119.71,90.24 119.61,90.34 119.61,90.55 119.71,90.65 123.1,90.65 123.2,90.75 123.2,90.95 123.1,91.05 120.41,91.05 120.21,91.25 120.21,91.63 120.42,91.84 122.62,91.84 122.74,91.96 122.74,94.48 122.84,94.58 122.98,94.58 123.08,94.48 123.08,91.96 123.17,91.86 123.31,91.86 123.41,91.96 123.41,94.47 123.51,94.57 123.65,94.57 123.75,94.47 123.75,92.65 123.84,92.55 123.98,92.55 124.08,92.65 124.08,94.73 124.27,94.92 127.46,94.92 127.56,95.02 127.56,95.15 127.46,95.25 126.2,95.25 126.1,95.35 126.1,95.49 126.2,95.59 127.18,95.59 127.28,95.69 127.28,95.82 127.18,95.92 125.62,95.92 124.98,95.29 123.73,95.29 123.39,94.95 122.01,94.95 121.91,94.85 121.91,94.67 122,94.58 122.27,94.58 122.37,94.48 122.37,94.34 122.27,94.24 122.01,94.24 121.91,94.14 121.91,92.37 121.8,92.27 121.67,92.27 121.57,92.37 121.57,93.69 121.47,93.79 121.33,93.79 121.24,93.69 121.24,92.47 121.14,92.37 121,92.37 120.9,92.47 120.9,93.69 120.8,93.79 120.66,93.79 120.56,93.69 120.56,92.47 120.47,92.37 120.33,92.37 120.23,92.47 120.23,94.39 120.33,94.49 121.47,94.49 121.57,94.59 121.57,96.97 121.72,97.12 121.86,97.12 121.96,97.02 121.96,95.41 122.05,95.31 122.19,95.31 122.29,95.41 v1(122.29,97.44)
DDR4_DIMM_CH0_A8: length 84.2
  L03_SIG1 w0.081: v4(123.14,91.44) 123.45,91.44 123.85,91.03 124.13,91.03 126.64,93.54 128.82,93.54 128.91,93.64 128.91,93.78 128.82,93.87 127.12,93.87 127.02,93.97 127.02,94.11 127.12,94.21 129.86,94.21 130.05,94.02 130.05,93.8 129.89,93.64 129.42,93.64 128.76,92.99 128.09,92.99 127.88,93.2 126.77,93.2 125.31,91.74 125.31,91.5 123.76,89.95 123.76,89.81 123.86,89.72 124,89.72 125.39,91.1 125.53,91.1 125.62,91 125.62,90.86 123.64,88.88 123.64,88.74 123.74,88.64 123.88,88.64 125.72,90.48 125.86,90.48 125.96,90.39 125.96,90.25 123.94,88.23 123.94,88.09 124.04,87.99 124.18,87.99 124.7,88.51 124.83,88.51 124.93,88.41 124.93,88.28 124.27,87.61 124.27,87.41 125.01,86.67 125.01,86.16 124.56,85.71 124.4,85.71 124.3,85.82 124.3,86.88 123.97,87.21 122.75,87.21 122.66,87.31 122.66,87.45 122.75,87.55 123.67,87.55 123.77,87.64 123.77,87.78 123.67,87.88 121.11,87.88 121.02,87.78 121.02,87.64 121.11,87.55 122.22,87.55 122.32,87.45 122.32,87.31 122.22,87.21 120.95,87.21 120.84,87.1 120.84,86.95 120.95,86.84 121.33,86.84 121.45,86.72 121.45,86.23 121.35,86.13 120.99,86.13 120.9,86.03 120.9,85.89 120.99,85.79 121.35,85.79 121.45,85.69 121.45,85.55 121.35,85.45 120.99,85.45 120.9,85.36 120.9,85.22 120.99,85.12 121.62,85.12 121.72,85.02 121.72,84.88 121.62,84.78 120.99,84.78 120.9,84.69 120.9,84.55 120.99,84.45 121.35,84.45 121.45,84.35 121.45,84.21 121.35,84.11 120.99,84.11 120.9,84.02 120.9,83.88 120.99,83.78 121.35,83.78 121.45,83.68 121.45,83.54 121.35,83.44 120.99,83.44 120.9,83.34 120.9,83.21 120.99,83.11 121.64,83.11 121.73,83.01 121.73,82.87 121.64,82.77 120.99,82.77 120.9,82.67 120.9,82.54 120.99,82.44 121.35,82.44 121.45,82.34 121.45,82.14 121.63,81.96 121.89,81.96 122.28,81.56 122.28,74.18 122.02,73.92 121.6,73.92 121.42,74.11 121.42,81.15 121.17,81.4 120.77,81.4 120.51,81.14 120.51,75.39 v4(120.98,74.93)
DDR4_DIMM_CH0_A9: length 84.5
  L03_SIG1 w0.081: v4(120.98,73.93) 121.39,73.51 121.39,73.3 121.62,73.07 121.62,72.88 121.41,72.67 121.41,72.43 121.31,72.33 120.63,72.33 120.53,72.43 120.53,72.61 120.29,72.86 120.29,73.06 120.43,73.2 120.64,73.2 120.78,73.34 120.78,73.54 120.53,73.79 120.53,73.91 120.41,74.04 119.82,74.04 119.67,73.89 119.67,73.47 119.52,73.32 119.05,73.32 118.58,73.79 118.58,74.08 118.99,74.49 119.17,74.49 119.37,74.29 119.53,74.29 119.63,74.39 119.63,74.68 119.72,74.78 119.91,74.78 120,74.87 120,75.02 119.91,75.11 119.63,75.11 119.52,75.21 119.52,75.66 119.63,75.76 119.92,75.76 120,75.85 120,76 119.92,76.09 119.63,76.09 119.51,76.22 119.51,76.64 119.63,76.76 119.93,76.76 120.02,76.85 120.02,76.99 119.92,77.09 119.62,77.09 119.47,77.24 119.47,77.6 119.63,77.76 119.93,77.76 120.02,77.85 120.02,78 119.92,78.1 119.65,78.1 119.48,78.27 119.48,78.61 119.64,78.77 119.88,78.77 119.97,78.86 119.97,79.01 119.88,79.1 119.62,79.1 119.46,79.27 119.46,79.59 119.65,79.78 119.91,79.78 120,79.87 120,80.02 119.91,80.11 119.62,80.11 119.5,80.23 119.5,80.66 119.61,80.76 119.9,80.76 120,80.86 120,81.01 119.92,81.1 119.69,81.1 119.5,81.29 119.5,81.62 119.89,82.02 120.04,82.02 120.3,81.75 120.49,81.75 120.59,81.85 120.59,82.04 120.51,82.12 120.51,84.59 120.24,84.86 120.24,85.01 120.51,85.28 120.51,85.69 120.41,85.79 120.21,85.79 120.11,85.89 120.11,86.02 120.21,86.12 120.5,86.12 120.74,86.37 120.74,86.52 120.63,86.63 120.34,86.63 120.23,86.74 120.23,87.06 120.58,87.41 120.58,87.63 120.49,87.71 120.29,87.71 120.18,87.82 120.18,87.97 120.51,88.3 120.51,90.94 120.6,91.03 120.76,91.03 120.85,90.94 120.85,88.31 120.94,88.22 121.1,88.22 121.44,88.56 121.44,88.89 121.19,89.14 121.19,90.98 121.27,91.07 121.43,91.07 121.52,90.98 121.52,89.9 121.61,89.81 121.77,89.81 121.86,89.9 121.86,91.74 121.94,91.83 122.1,91.83 122.19,91.74 122.19,89.56 122.28,89.47 122.44,89.47 122.53,89.56 122.53,90.63 122.62,90.72 122.77,90.72 122.86,90.63 122.86,89.21 122.75,89.09 122.02,89.09 121.92,88.99 121.92,88.86 122.02,88.76 122.13,88.76 122.22,88.67 122.22,88.33 122.33,88.23 122.45,88.23 122.54,88.32 122.54,88.65 122.64,88.75 122.77,88.75 122.87,88.65 122.87,88.31 122.96,88.23 123.1,88.23 123.2,88.33 123.2,90.92 123.03,91.08 122.64,91.08 122.54,91.18 122.54,91.71 122.65,91.82 124.43,91.82 124.52,91.91 124.52,92.06 124.43,92.15 122.76,92.15 122.66,92.25 122.66,92.39 122.76,92.49 124.37,92.49 124.46,92.58 124.46,92.72 124.37,92.82 123.12,92.82 123.02,92.92 123.02,93.62 123.11,93.71 123.4,93.71 123.49,93.62 123.49,93.25 123.58,93.16 124.76,93.16 125.2,92.72 125.34,92.72 125.89,93.27 125.89,93.41 125.76,93.55 125.63,93.55 125.47,93.39 125.34,93.39 125.22,93.51 125.22,93.65 125.35,93.79 125.35,93.96 125.09,94.22 124.89,94.22 124.16,93.5 124.02,93.5 123.92,93.6 123.92,93.73 124.76,94.57 124.76,94.71 124.66,94.81 124.52,94.81 123.77,94.05 122.8,94.05 122.68,93.93 122.68,93.04 122.57,92.93 122.33,92.93 121.95,93.31 121.8,93.31 121.7,93.2 121.7,92.96 121.56,92.83 121.34,92.83 121.24,92.73 121.24,92.58 121.33,92.49 121.81,92.49 121.91,92.39 121.91,92.25 121.81,92.15 121.19,92.15 120.81,92.53 120.67,92.53 120.54,92.41 120.54,91.92 120.64,91.82 121.34,91.82 121.44,91.71 v4(121.44,91.44)
DDR4_DIMM_CH0_A10: length 82.6
  L16_SIG6 w0.081: v1(121.84,74.43) 122.9,74.43 123.4,74.93 123.74,74.93 124.25,74.42 124.54,74.42 125.05,74.93 125.56,74.93 125.99,74.5 126.4,74.5 126.8,74.91 128.81,74.91 129.34,75.43 129.79,75.43 130.3,75.94 130.7,75.94 131.2,76.44 131.48,76.44 132.02,76.99 132.36,76.99 132.69,77.31 133.32,77.31 134.43,78.41 134.88,78.41 135.26,78.79 135.26,79.53 135.67,79.94 135.88,79.94 136.16,80.22 136.16,80.86 136.99,81.69 136.99,82.42 137.89,83.32 137.89,83.51 138.69,84.32 138.69,88.63 139.96,89.9 141.49,89.9 142.22,90.63 142.22,92.72 142.47,92.97 143.04,92.97 144.09,94.02 144.09,94.16 143.99,94.25 143.85,94.25 143.27,93.67 143.13,93.67 143.04,93.77 143.04,93.91 143.78,94.65 146.24,94.65 146.34,94.75 146.34,94.89 146.24,94.99 144.85,94.99 144.75,95.09 144.75,95.23 144.85,95.32 146.74,95.32 147.16,94.9 157.84,94.9 157.94,95.01 157.94,95.25 157.84,95.35 151.01,95.35 150.44,95.92 145.32,95.92 145.22,96.02 145.22,96.16 145.32,96.26 145.61,96.26 145.7,96.36 145.7,96.5 145.61,96.59 144.99,96.59 144.89,96.5 144.89,96.02 144.79,95.92 143.53,95.92 143.43,96.02 143.43,96.16 143.53,96.26 143.88,96.26 143.98,96.36 143.98,96.5 143.88,96.59 143.19,96.59 143.09,96.5 143.09,96.02 143,95.92 142.49,95.92 142.2,96.21 142.2,96.52 142.69,97.02 142.69,97.21 142.55,97.35 142.36,97.35 141.86,96.85 141.56,96.85 140.85,97.56 139.42,97.56 v1(139.29,97.44)
DDR4_DIMM_CH0_A11: length 82
  L14_SIG5 w0.081: v1(121.44,97.44) 121.87,97.87 122.17,97.87 122.57,98.27 122.8,98.27 122.93,98.14 122.93,96.72 122.72,96.52 122.72,96.11 122.9,95.93 123.17,95.93 123.45,95.65 124.83,95.65 124.93,95.75 124.93,95.89 124.83,95.99 123.73,95.99 123.64,96.09 123.64,96.23 123.73,96.32 124.77,96.32 125.58,97.14 125.58,97.71 126.37,98.51 127.28,98.51 127.38,98.41 127.38,98.27 127.28,98.17 126.6,98.17 126.5,98.08 126.5,97.94 126.6,97.84 128.78,97.84 128.87,97.74 128.87,97.6 128.78,97.5 126.07,97.5 125.97,97.41 125.97,97.27 126.07,97.17 126.54,97.17 126.64,97.07 126.64,96.93 126.54,96.83 126.09,96.83 125.99,96.73 125.99,96.6 126.09,96.5 126.99,96.5 127.09,96.6 127.09,97.07 127.19,97.17 129.43,97.17 129.53,97.07 129.53,96.93 129.43,96.83 127.81,96.83 127.71,96.73 127.71,96.6 127.81,96.5 129.47,96.5 129.56,96.4 129.56,96.26 129.47,96.16 127.73,96.16 127.63,96.06 127.63,95.93 127.73,95.83 129.94,95.83 130.07,95.7 130.07,95.28 133.29,92.06 133.29,90.27 133.39,90.18 133.53,90.18 133.62,90.27 133.62,91.37 133.72,91.47 133.86,91.47 133.96,91.37 133.96,90.03 133.54,89.61 133.54,89.19 133.45,89.09 132.49,89.09 132.39,88.99 132.39,88.85 132.49,88.76 133.45,88.76 133.54,88.66 133.54,88.52 133.45,88.42 132.71,88.42 132.61,88.32 132.61,88.18 132.71,88.08 133.72,88.08 133.82,87.99 133.82,87.85 133.72,87.75 132.49,87.75 132.39,87.65 132.39,87.51 132.49,87.41 133.45,87.41 133.54,87.32 133.54,87.18 133.45,87.08 132.48,87.08 132.38,86.98 132.38,86.84 132.48,86.74 133.45,86.74 133.54,86.65 133.54,86.51 133.45,86.41 132.71,86.41 132.61,86.31 132.61,86.17 132.71,86.07 133.45,86.07 133.54,85.97 133.54,85.84 133.45,85.74 132.71,85.74 132.61,85.64 132.61,85.5 132.71,85.4 133.45,85.4 133.54,85.3 133.54,85.13 133.44,85.02 132.77,85.02 132.62,84.87 132.62,84.2 132.35,83.93 132.08,83.93 131.04,82.9 130.03,82.9 129.21,82.07 129.21,81.2 128.92,80.92 128.66,80.92 128.16,80.43 127.77,80.43 127.25,79.91 126.93,79.91 126.64,79.62 126.64,74.78 126.3,74.45 125.92,74.45 125.38,73.9 123.35,73.9 122.88,73.43 v1(121.84,73.43)
DDR4_DIMM_CH0_A12: length 79.4
  L14_SIG5 w0.081: v1(120.59,91.44) 123.37,91.44 124.42,92.48 124.42,93.84 125.13,94.56 128.39,94.56 130.17,92.77 130.31,92.77 130.41,92.87 130.41,93.01 128.3,95.12 128.3,95.26 128.4,95.35 128.54,95.35 130.72,93.17 130.86,93.17 130.96,93.27 130.96,93.41 129.59,94.78 129.59,94.92 129.69,95.02 129.83,95.02 131.5,93.34 131.5,93.2 131.31,93 131.31,92.5 131.18,92.37 130.42,92.37 130.32,92.27 130.32,92.01 130.42,91.91 131.39,91.91 131.88,92.4 132.12,92.4 132.28,92.24 132.28,91.09 132.38,90.99 132.51,90.99 132.61,91.09 132.61,91.85 132.71,91.95 132.85,91.95 132.95,91.85 132.95,90.78 132.77,90.6 132.01,90.6 131.9,90.71 131.9,91.03 131.8,91.14 131.67,91.14 131.57,91.03 131.57,90.7 131.47,90.6 131.32,90.6 131.22,90.7 131.22,91.09 131.12,91.19 130.98,91.19 130.88,91.09 130.88,90.36 130.98,90.27 132.87,90.27 132.97,90.17 132.97,89.54 132.87,89.43 132.73,89.43 132.63,89.54 132.63,89.81 132.51,89.93 130.98,89.93 130.88,89.83 130.88,89.69 130.98,89.6 131.76,89.6 131.86,89.5 131.86,89.36 131.76,89.26 130.98,89.26 130.88,89.16 130.88,89.02 130.98,88.93 131.83,88.93 131.93,88.83 131.93,88.69 131.83,88.59 130.98,88.59 130.88,88.49 130.88,88.35 130.98,88.26 131.86,88.26 131.96,88.16 131.96,88.02 131.86,87.92 130.73,87.92 130.64,87.82 130.64,87.68 130.73,87.58 131.94,87.58 132.04,87.49 132.04,87.35 131.94,87.25 130.98,87.25 130.88,87.15 130.88,87.01 130.98,86.91 131.85,86.91 131.94,86.82 131.94,86.68 131.85,86.58 131.03,86.58 130.93,86.48 130.93,86.34 131.03,86.24 131.87,86.24 131.97,86.15 131.97,86.01 131.87,85.91 130.95,85.91 130.85,85.81 130.85,85.67 130.95,85.57 131.76,85.57 131.85,85.47 131.85,85.34 131.76,85.24 130.92,85.24 130.82,85.14 130.82,85 130.92,84.9 131.84,84.9 131.94,84.8 131.94,84.67 131.84,84.57 131.03,84.57 130.94,84.47 130.94,84.33 131.03,84.23 131.52,84.23 131.61,84.13 131.61,83.99 131.52,83.9 130.32,83.9 129.37,82.94 128.7,82.94 128.37,82.61 128.37,81.69 128.07,81.4 127.69,81.4 127.21,80.92 126.87,80.92 126.38,80.43 126.04,80.43 125.76,80.15 125.76,75.19 125.44,74.87 125.13,74.87 124.74,75.26 124.74,75.62 v1(124.44,75.93)
DDR4_DIMM_CH0_A13: length 79.3
  L16_SIG6 w0.081: v1(125.31,77.43) 124.25,77.43 123.75,77.93 123.4,77.93 123.15,78.18 123.15,78.57 123.4,78.82 123.84,78.82 124.3,78.37 124.73,78.37 125.18,77.92 125.5,77.92 125.88,77.54 126.44,77.54 126.8,77.9 127.24,77.9 127.69,77.45 128.07,77.45 128.53,77.9 128.94,77.9 129.18,78.14 129.18,79.74 129.28,79.84 129.46,79.84 129.56,79.74 129.56,78.45 129.66,78.35 129.8,78.35 129.9,78.45 129.9,78.76 130,78.86 130.19,78.86 130.39,78.67 133.09,78.67 134.14,79.72 134.14,80.19 134.35,80.4 134.35,81.16 134.65,81.46 134.91,81.46 135.28,81.83 135.28,82.46 136.13,83.31 136.13,83.94 136.03,84.03 135.93,84.03 135.84,84.13 135.84,84.27 135.93,84.37 136.03,84.37 136.13,84.47 136.13,84.61 136.03,84.71 135.93,84.71 135.84,84.8 135.84,84.94 135.93,85.04 136.03,85.04 136.13,85.14 136.13,89.53 131.84,93.82 129.51,93.82 129,94.33 129,95.25 128.9,95.35 128.75,95.35 128.65,95.25 128.65,95.04 128.55,94.94 128.42,94.94 128.32,95.04 128.32,95.78 128.22,95.88 127.82,95.88 127.72,95.98 127.72,96.18 127.82,96.28 128.71,96.28 128.81,96.18 128.81,95.85 128.91,95.75 129.04,95.75 129.14,95.85 129.14,96.19 129.24,96.29 129.38,96.29 129.48,96.19 129.48,96.1 129.6,95.99 130.18,95.99 130.36,96.17 130.36,96.54 130.77,96.95 131.06,96.95 131.15,96.85 131.15,96.57 131.25,96.47 131.49,96.47 132.09,97.07 135.72,97.07 135.82,96.97 135.82,96.83 135.72,96.73 132.31,96.73 132.21,96.63 132.21,96.49 132.31,96.4 136.82,96.4 137.45,95.76 137.81,95.76 137.99,95.94 137.99,96.89 138.17,97.07 138.66,97.07 138.87,97.28 138.87,97.6 139.27,98 141.4,98 141.5,98.1 141.5,98.24 141.4,98.33 140.18,98.33 140.08,98.43 140.08,98.57 140.18,98.67 142.83,98.67 142.93,98.57 142.93,98.43 142.83,98.33 142.38,98.33 142.29,98.24 142.29,98.1 142.38,98 143.03,98 143.13,97.9 143.13,97.06 143.25,96.94 143.61,96.94 143.8,97.13 143.94,97.13 144.13,96.94 144.28,96.94 144.47,97.13 144.61,97.13 144.8,96.94 145.14,96.94 145.24,97.04 v1(145.24,97.44)
