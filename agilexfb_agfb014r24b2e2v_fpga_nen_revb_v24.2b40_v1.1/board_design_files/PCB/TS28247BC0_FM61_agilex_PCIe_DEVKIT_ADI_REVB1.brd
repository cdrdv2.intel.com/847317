# Allegro board TS28247BC0_FM61_agilex_PCIe_DEVKIT_ADI_REVB1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_DIMM_CH1_DBI_N5: length 83.5
  L05_SIG2 w0.079: v1(163.94,99.06) 164.3,98.7 164.3,98.25 164.13,98.08 163.7,98.08 163.58,98.2 163.3,98.2 163.18,98.08 158.93,98.08 158.42,98.58 158.42,99.23 158.93,99.73 158.93,100.64 158.59,100.98 157.13,100.98 156.73,100.59 156.73,99.95 156.58,99.8 156.13,99.8 155.98,99.95 155.98,100.61 155.63,100.96 155.21,100.96 154.87,100.61 154.87,99.88 154.7,99.71 154.22,99.71 154.05,99.88 154.05,100.68 153.75,100.98 152.08,100.98 150.42,99.32 147.73,99.32 147.33,99.71 140.91,99.71 140.3,99.1 140.3,98.57 140.98,97.89 140.98,97.29 140.68,97 134.48,97 131.75,94.27 118.46,94.27 117.35,93.15 116.85,93.15 115.28,91.59 115.28,91.04 113.3,89.06 111.48,89.06 109.11,86.69 109.11,83.97 108.68,83.54 108.37,82.79 108.37,82.37 108.31,82.23 108.17,82.09 108.04,82.04 107.86,82.04 107.64,81.94 107.48,81.79 107.39,81.56 107.39,81.29 107.5,81.01 107.5,80.86 107.38,80.57 107.38,80.28 107.5,80 107.5,79.85 107.38,79.57 107.38,79.31 107.5,79.02 107.5,78.88 107.38,78.59 107.38,78.31 107.52,77.99 107.52,77.87 107.39,77.55 107.39,77.29 107.49,77.02 107.49,76.82 107.42,76.64 107.32,76.54 107.22,76.54 107.12,76.64 v1(107.12,76.93)
DDR4_DIMM_CH1_DBI_N6: length 81.3
  L07_SIG3 w0.085: v1(113.18,77.43) 113.18,77.16 113.28,77.06 113.38,77.06 113.47,77.15 113.56,77.35 113.56,77.47 arc(113.55,77.52) 113.54,77.56 113.48,77.7 arc(113.45,77.79) 113.44,77.88 113.44,78.01 arc(113.48,78.18) 113.57,78.32 113.63,78.37 arc(113.81,78.5) 114.03,78.54 114.09,78.54 arc(114.21,78.57) 114.31,78.65 114.46,78.85 arc(114.64,78.99) 114.87,79.04 114.95,79.04 arc(115.08,79.07) 115.18,79.15 115.33,79.35 arc(115.51,79.49) 115.73,79.54 115.82,79.54 arc(115.95,79.57) 116.05,79.65 116.2,79.85 arc(116.38,79.99) 116.6,80.04 116.68,80.04 arc(116.81,80.07) 116.91,80.15 117.06,80.35 arc(117.24,80.49) 117.47,80.54 117.55,80.54 arc(117.67,80.57) 117.77,80.65 117.92,80.84 arc(118.1,80.99) 118.33,81.04 118.42,81.04 arc(118.55,81.07) 118.65,81.15 118.8,81.34 arc(118.98,81.49) 119.21,81.54 119.28,81.54 arc(119.41,81.57) 119.51,81.65 119.66,81.84 arc(119.84,81.99) 120.07,82.04 120.15,82.04 arc(120.28,82.07) 120.38,82.15 120.5,82.31 120.8,82.6 121.13,82.6 121.57,83.04 122,83.04 123.01,84.05 141.13,84.05 142.11,85.04 143.87,85.04 147.75,88.92 149.52,89.65 153.15,89.65 154.54,91.04 158.41,91.04 161.4,94.03 ; 171.76,93.72 175.45,97.42 175.45,97.87 175.17,98.15 173.92,98.15 173.62,98.45 173.62,98.96 173.52,99.06 v1(173.29,99.06)
  L07_SIG3 w0.089: 171.76,93.72 170.94,93.72 170.71,93.96 170.71,94.16 172.56,96.02 172.56,96.36 172.19,96.73 171.77,96.73 169.07,94.03 161.4,94.03
DDR4_DIMM_CH1_DBI_N7: length 90.7
  L05_SIG2 w0.079: v1(113.18,74.43) 113.18,74.14 113.28,74.05 113.39,74.05 113.47,74.12 113.57,74.36 113.57,74.49 113.44,74.8 113.44,75.04 113.56,75.32 113.56,75.52 113.44,75.81 113.44,76.05 113.57,76.36 113.57,76.5 113.44,76.79 113.44,76.95 arc(113.49,77.17) 113.62,77.36 113.62,77.37 arc(113.81,77.5) 114.04,77.54 114.08,77.54 arc(114.2,77.57) 114.3,77.65 114.46,77.84 arc(114.64,77.99) 114.86,78.04 114.91,78.04 arc(115.05,78.07) 115.17,78.15 115.2,78.18 arc(115.27,78.29) 115.3,78.41 115.3,78.41 arc(115.29,78.5) 115.26,78.59 115.24,78.64 arc(115.19,78.79) 115.18,78.96 arc(115.22,79.17) 115.33,79.34 115.38,79.39 arc(115.55,79.5) 115.74,79.54 115.77,79.54 arc(115.9,79.56) 116.01,79.64 116.06,79.69 arc(116.13,79.79) 116.15,79.9 116.15,79.91 arc(116.14,80.02) 116.11,80.12 116.09,80.16 arc(116.05,80.3) 116.04,80.43 116.04,80.45 arc(116.08,80.65) 116.19,80.82 116.23,80.86 arc(116.42,80.99) 116.64,81.03 116.68,81.03 arc(116.8,81.06) 116.9,81.14 117.06,81.35 arc(117.23,81.48) 117.45,81.53 117.51,81.53 arc(117.67,81.57) 117.8,81.67 117.93,81.84 arc(118.1,81.98) 118.32,82.03 118.35,82.03 arc(118.54,82.08) 118.69,82.2 119,82.59 119.84,83.44 120.54,83.44 121.15,84.05 122.08,84.05 123.06,85.03 137.36,85.03 138.15,85.19 140.41,86.13 141.89,87.6 143.06,88.09 144.51,88.09 146.6,89.49 149.74,90.78 150.78,90.99 151.58,91.07 169.14,91.07 169.43,91.19 171.22,92.98 175.63,92.98 175.82,93.16 175.82,93.38 175.63,93.56 172.73,93.56 172.48,93.81 172.48,94.36 172.73,94.61 178.59,94.61 180.28,96.29 181.67,96.29 181.93,96.56 181.93,97.04 182.93,98.04 182.93,98.78 v1(182.64,99.06)
DDR4_DIMM_CH1_DBI_N8: length 55.7
  L07_SIG3 w0.085: v1(108.69,99.09) 108.69,98.89 108.51,98.71 108.37,98.71 108.25,98.83 108.11,98.83 108.01,98.73 108.01,98.59 108.13,98.47 108.13,98.33 107.87,98.06 99.67,98.06 98.39,96.78 98.39,96.15 97.94,95.71 97.42,95.71 96.42,96.71 95.95,96.71 95.61,96.38 95.61,95.9 96.63,94.88 96.63,94.59 94.09,92.04 93.74,92.04 93.63,92.15 93.63,92.43 94.98,93.78 94.98,94.29 94.73,94.54 94.25,94.54 92.11,92.4 92.11,91.87 91.85,91.61 91.85,88.07 92.12,87.8 92.64,87.8 92.9,88.06 92.9,90.66 93.07,90.83 93.32,90.83 93.5,90.65 93.5,85.01 93.25,84.76 93.25,84.06 94.51,82.79 94.51,82.35 94.39,82.06 94.39,81.78 94.5,81.52 94.5,81.32 94.39,81.05 94.39,80.8 94.51,80.52 94.51,79.94 94.38,79.81 94.38,77.81 94.51,77.48 94.51,76.46 95.09,75.88 95.09,75.69 95.38,75 95.38,74.84 95.28,74.62 95.21,74.54 95.1,74.54 95,74.64 v1(95,74.93)
DDR4_DIMM_CH1_DQ0: length 52.5
  L05_SIG2 w0.081: v1(97.59,82.43) 97.59,81.96 97.19,81.55 97.19,80.86 96.77,80.45 96.5,80.45 96.06,80.89 95.66,80.89 95.31,80.55 94.65,80.55 94.14,81.06 93.98,81.06 93.66,81.38 93.66,82.08 93.34,82.4 93.34,82.52 87.96,87.9 87.47,87.9 85.14,90.24 82.88,90.24 82.21,90.91 82.21,91.35 80.94,92.62 78.62,92.62 78.52,92.72 78.52,92.85 78.62,92.95 79.86,92.95 79.96,93.05 79.96,93.19 79.86,93.29 76.53,93.29 76.43,93.19 76.43,93.05 76.53,92.95 77.88,92.95 77.98,92.85 77.98,92.72 77.88,92.62 75.48,92.62 71.75,96.35 70.97,96.35 70.31,97.01 67.7,97.01 67.46,97.25 67.46,97.86 66.66,98.66 66.66,99.12 67.38,99.85 69.22,99.85 69.59,99.48 v1(69.59,99.06)
DDR4_DIMM_CH1_DQ1: length 53
  L05_SIG2 w0.081: v1(97.59,81.43) 97.59,80.97 96.59,79.97 93.96,79.97 93.7,80.23 93.7,81.04 93.37,81.36 93.18,81.36 93.03,81.51 93.03,81.63 92.62,82.04 92.24,82.04 91.97,82.32 91.97,82.62 89.8,84.79 88.88,84.79 84.24,89.43 80.74,89.43 79.21,90.96 73.38,90.96 69.45,94.89 67.92,94.89 67.07,95.74 67.07,96.39 66.31,97.14 65.8,98.39 65.8,100.57 67.63,102.41 67.63,103.93 68.31,104.6 68.31,105.01 68.51,105.21 68.92,105.21 69.17,104.96 69.17,104.28 69.36,104.09 70.24,104.09 70.44,104.29 v1(70.44,104.8)
DDR4_DIMM_CH1_DQ2: length 52.9
  L05_SIG2 w0.081: v1(75.59,99.06) 75.96,98.69 76.57,98.69 76.88,99 76.88,100.79 76.78,100.89 76.65,100.89 76.55,100.79 76.55,99.65 76.45,99.55 76.31,99.55 76.21,99.65 76.21,102.56 76.31,102.66 76.45,102.66 76.55,102.56 76.55,101.64 76.65,101.55 76.78,101.55 76.88,101.64 76.88,103.14 77.25,103.5 82.39,103.5 82.75,103.14 82.75,102.11 82.85,102.01 83.18,102.01 83.28,101.92 83.28,101.78 83.18,101.68 82.85,101.68 82.75,101.58 82.75,101.44 82.85,101.34 83.18,101.34 83.28,101.25 83.28,101.11 83.18,101.01 82.85,101.01 82.75,100.91 82.75,100.77 82.85,100.67 83.18,100.67 83.28,100.57 83.28,100.44 83.18,100.34 82.85,100.34 82.75,100.24 82.75,100.1 82.85,100 83.18,100 83.28,99.9 83.28,99.77 83.18,99.67 82.85,99.67 82.75,99.57 82.75,99.43 82.85,99.33 83.18,99.33 83.28,99.23 83.28,99.09 83.18,99 82.85,99 82.75,98.9 82.75,98.76 82.85,98.66 83.18,98.66 83.28,98.56 83.28,98.42 83.18,98.33 82.85,98.33 82.75,98.23 82.75,98.09 82.85,97.99 83.18,97.99 83.28,97.89 83.28,97.75 83.18,97.66 82.85,97.66 82.75,97.56 82.75,96.5 82.93,96.32 83.92,96.32 86.11,94.12 88.67,94.12 88.93,93.86 88.93,93.12 90.41,91.65 90.41,91.26 90.66,91.01 90.92,91.01 93.96,87.96 94.52,87.96 95.43,87.05 95.43,86.02 96.31,85.13 96.31,82.34 v1(96.73,81.93)
DDR4_DIMM_CH1_DQ3: length 53
  L05_SIG2 w0.081: v1(76.39,105.06) 76.88,104.57 79.2,104.57 79.3,104.47 79.3,104.34 79.2,104.24 77.85,104.24 77.75,104.14 77.75,104 77.85,103.9 80.86,103.9 80.96,104 80.96,104.14 80.86,104.24 79.85,104.24 79.75,104.34 79.75,104.47 79.85,104.57 82.29,104.57 82.39,104.47 82.39,104.34 82.29,104.24 81.58,104.24 81.48,104.14 81.48,104 81.58,103.9 82.91,103.9 83.21,103.6 83.21,102.77 83.62,102.36 83.62,97.16 86.32,94.46 89.62,94.46 89.84,94.24 89.84,93.82 90.4,93.26 90.68,93.26 91.43,92.51 91.43,92.37 91.33,92.27 91.19,92.27 90.67,92.8 90.53,92.8 90.43,92.7 90.43,92.56 91.76,91.24 91.76,91.1 91.61,90.95 91.61,90.82 91.71,90.72 91.85,90.72 92.2,91.07 92.34,91.07 92.44,90.97 92.44,90.83 92.09,90.48 92.09,90.34 92.19,90.24 92.33,90.24 92.65,90.57 92.79,90.57 92.89,90.47 92.89,90.33 92.56,90.01 92.56,89.87 92.66,89.77 92.8,89.77 93.14,90.11 93.27,90.11 93.37,90.01 93.37,89.87 93.04,89.53 93.04,89.39 93.14,89.3 93.27,89.3 93.42,89.44 93.55,89.44 94,88.99 94.41,88.99 95.42,87.98 96,87.98 96.35,87.63 96.35,85.86 96.73,85.49 96.73,82.64 97.1,82.26 97.1,81.77 96.73,81.39 v1(96.73,80.93)
DDR4_DIMM_CH1_DQ4: length 49.5
  L05_SIG2 w0.081: v1(94.13,82.43) 93.98,82.58 93.98,82.91 90.93,85.96 90.93,86.1 91.03,86.19 91.16,86.19 91.59,85.76 91.73,85.76 91.83,85.86 91.83,86 90.9,86.93 89.98,86.93 88.98,87.93 88.98,88.07 89.08,88.17 89.22,88.17 90.02,87.37 90.16,87.37 90.25,87.47 90.25,87.61 88.93,88.93 88.63,88.93 88.35,89.21 88.35,89.54 87.94,89.95 87.65,89.95 86.55,91.04 86.41,91.04 86.31,90.95 86.31,90.81 87.42,89.7 87.42,89.56 87.32,89.46 87.18,89.46 85.6,91.05 84.69,91.05 84.11,91.63 83.79,91.63 83.32,92.1 83.32,92.38 81.15,94.55 74.83,94.55 74.73,94.65 74.73,94.79 74.83,94.88 76.03,94.88 76.12,94.98 76.12,95.12 76.03,95.22 75.05,95.22 73.92,96.34 73.79,96.34 73.69,96.25 73.69,96.11 74.5,95.29 74.5,95.16 74.4,95.06 74.26,95.06 72.56,96.76 72.56,97.91 72.3,98.17 69.34,98.17 68.9,98.61 68.34,98.61 v1(67.89,99.06)
DDR4_DIMM_CH1_DQ5: length 50
  L05_SIG2 w0.081: v1(93.26,81.93) 93.05,82.14 93.05,82.33 90.16,85.22 89.75,85.22 88.15,86.82 87.66,86.82 84.63,89.85 81.32,89.85 79.14,92.03 74.77,92.03 71.1,95.7 70.96,95.7 70.87,95.6 70.87,95.46 71.96,94.36 71.96,94.23 71.86,94.13 71.72,94.13 69.91,95.94 67.95,95.94 67.85,96.04 67.85,96.18 67.95,96.28 70.02,96.28 70.12,96.38 70.12,96.52 70.02,96.61 67.34,96.61 66.67,97.28 66.32,98.13 66.32,99.26 68.01,100.96 68.01,103.64 68.74,104.37 v1(68.74,104.81)
DDR4_DIMM_CH1_DQ6: length 49.6
  L05_SIG2 w0.081: v1(94.13,81.43) 93.96,81.6 93.96,82.07 93.64,82.39 93.64,82.69 88.3,88.04 88.3,88.62 87.93,88.99 87.15,88.99 85.51,90.63 84.14,90.63 84.03,90.74 84.03,91.06 83.9,91.2 83.71,91.2 83.58,91.06 83.58,90.76 83.45,90.63 83.15,90.63 82.79,91 82.79,92.42 81.73,93.48 81.59,93.48 81.49,93.39 81.49,93.25 82.04,92.69 82.04,92.55 81.94,92.46 81.8,92.46 80.63,93.63 80.63,93.83 80.32,94.13 74.65,94.13 71.63,97.15 70.94,97.15 70.84,97.25 70.84,97.39 70.94,97.49 71.66,97.49 71.76,97.59 71.76,97.72 71.66,97.82 69.06,97.82 68.79,98.09 67.94,98.09 67.42,98.61 67.42,99.14 67.75,99.47 69.02,99.47 69.17,99.32 69.17,98.92 69.5,98.59 72.76,98.59 72.93,98.41 72.93,97.96 73.04,97.85 73.24,97.85 73.34,97.96 73.34,98.61 v1(73.79,99.06)
DDR4_DIMM_CH1_DQ7: length 50.2
  L05_SIG2 w0.081: v1(93.26,80.93) 92.82,81.37 92.82,81.53 92.52,81.83 92.16,81.83 90.37,83.62 88.78,84.28 85.27,87.79 82.41,88.98 80.51,88.98 71.8,90.71 71.16,90.98 70.87,91.26 70.87,91.63 70.66,91.84 69.06,92.51 68.21,93.07 67.77,93.52 65.83,95.88 65.72,96.14 65.63,96.6 65.4,98.93 65.4,100.91 67.09,103.73 67.18,103.93 67.44,104.79 67.58,105.11 67.81,105.34 68.4,105.59 69.04,105.59 69.41,105.22 71.63,105.22 71.86,105.32 73.76,105.32 v1(74.69,104.93)
DDR4_DIMM_CH1_DQ8: length 42.4
  L03_SIG1 w0.081: v4(97.59,79.43) 97.59,79.22 96.92,78.55 96.51,78.55 96.02,78.06 95.7,78.06 95.21,78.55 94.84,78.55 94.34,79.05 93.97,79.05 93.7,79.33 93.7,81.02 93.41,81.31 93.05,81.31 92.46,81.89 92.26,81.89 92.01,82.15 92.01,83.21 89.03,86.19 89.03,86.81 87.91,87.94 87.49,87.94 82.75,92.68 81.35,92.68 80.5,93.53 80.5,93.83 80.14,94.19 79.64,94.19 78.22,95.61 78.22,95.75 78.32,95.84 78.46,95.84 79.61,94.69 79.75,94.69 79.85,94.79 79.85,94.93 78.28,96.5 78.28,96.64 78.38,96.74 78.52,96.74 80.31,94.94 80.45,94.94 80.55,95.04 80.55,95.18 78.52,97.21 78.52,98.64 v4(78.94,99.06)
DDR4_DIMM_CH1_DQ9: length 42.8
  L03_SIG1 w0.081: v4(97.59,78.43) 97.18,78.43 97.06,78.31 96.57,78.31 96.06,77.8 95.66,77.8 95.12,78.34 94.75,78.34 94.28,78.81 93.92,78.81 93.63,78.51 93.09,78.51 92.67,78.93 92.25,78.93 91.7,79.48 91.45,79.48 91.1,79.83 91.1,80.53 90.7,80.93 90.51,80.93 89.99,81.45 89.75,81.45 89.24,81.96 89.24,83.86 83,90.1 80.7,90.1 79.69,91.11 79.69,91.7 76.81,94.57 75.95,96.65 75.95,97.84 75.1,98.69 75.1,98.96 76.1,101.37 v4(79.79,105.06)
DDR4_DIMM_CH1_DQ10: length 41.5
  L03_SIG1 w0.081: v4(96.73,79.93) 96.95,80.15 96.95,80.62 97.11,80.78 97.11,81.08 96.95,81.24 96.95,81.62 97.11,81.79 97.11,82.08 96.37,82.82 96.37,84.44 95.97,84.85 95.13,84.85 93.62,86.36 93.62,88.29 91.25,90.66 91.25,93.78 91.72,94.25 91.72,96.08 91.62,96.18 91.48,96.18 91.38,96.08 91.38,94.72 91.28,94.63 91.14,94.63 91.05,94.72 91.05,96.54 90.95,96.63 90.81,96.63 90.71,96.54 90.71,95.7 90.61,95.6 90.47,95.6 90.38,95.7 90.38,98.38 90.13,98.62 88.29,98.62 88.2,98.52 88.2,98.38 88.29,98.28 89.63,98.28 89.73,98.18 89.73,98.05 89.63,97.95 85.74,97.95 85.64,98.05 85.64,98.18 85.74,98.28 87.5,98.28 87.6,98.38 87.6,98.52 87.5,98.62 85.34,98.62 v4(84.89,99.06)
DDR4_DIMM_CH1_DQ11: length 41.4
  L03_SIG1 w0.081: v4(85.74,105.06) 86.14,105.46 86.86,105.46 87.03,105.29 87.03,104.87 87.46,104.44 90.16,104.44 90.26,104.34 90.26,104.21 90.16,104.11 88.4,104.11 88.3,104.01 88.3,103.87 88.4,103.77 89.67,103.77 89.95,103.49 89.95,102.84 90.59,102.2 90.59,100.76 90.69,100.66 90.83,100.66 90.92,100.76 90.92,102.1 91.02,102.2 91.16,102.2 91.26,102.1 91.26,97.22 92.12,96.35 92.12,90.74 93.96,88.9 94.29,88.9 94.51,88.68 94.51,86.06 95.39,85.18 96.18,85.18 96.79,84.58 96.79,83.24 97.22,82.81 97.22,82.27 97.34,82.15 97.34,81.7 97.22,81.57 97.22,81.28 97.37,81.13 97.37,80.74 97.22,80.59 97.22,79.71 97.06,79.55 97.06,79.26 v4(96.73,78.93)
DDR4_DIMM_CH1_DQ12: length 40.9
  L03_SIG1 w0.081: v4(94.13,79.43) 94.13,79.85 94.6,80.32 94.6,80.62 94.27,80.95 94.07,80.95 93.49,81.54 93.12,81.54 92.82,81.84 92.82,83.08 89.61,86.28 89.61,86.88 88.28,88.22 88.28,88.63 87.94,88.97 87.01,88.97 85.67,90.31 85.67,90.45 85.77,90.55 85.91,90.55 87.01,89.45 87.15,89.45 87.24,89.55 87.24,89.69 85.93,91 85.51,91 85.31,91.19 85.31,91.63 83.92,93.03 82.6,93.03 81,94.63 81,94.77 81.1,94.86 81.24,94.86 81.97,94.13 82.11,94.13 82.21,94.23 82.21,94.37 79.38,97.2 79.38,99.51 79.1,99.8 78.24,99.8 78.14,99.9 78.14,100.03 78.24,100.13 79.23,100.13 79.32,100.23 79.32,100.37 79.23,100.47 77.75,100.47 77.24,99.96 v4(77.24,99.06)
DDR4_DIMM_CH1_DQ13: length 40.9
  L03_SIG1 w0.081: v4(78.09,105.06) 78.09,103.97 74.28,100.15 74.28,98.94 75.14,98.07 75.14,95.59 78.54,92.19 78.54,91.1 80.12,89.52 82.93,89.52 88.82,83.63 88.82,82.88 88.3,82.36 88.3,81.84 88.72,81.42 88.98,81.42 89.28,81.13 89.28,80.77 89.61,80.44 89.82,80.44 90.43,79.83 90.79,79.83 91.14,79.48 91.14,78.64 91.42,78.36 91.85,78.36 92.16,78.06 92.72,78.06 92.96,78.3 94,78.3 v4(94.13,78.43)
DDR4_DIMM_CH1_DQ14: length 39.5
  L03_SIG1 w0.081: v4(93.26,79.93) 93.26,80.3 92.68,80.89 92.3,80.89 91.78,81.41 91.52,81.41 91.15,81.79 91.15,83.16 88.41,85.89 88.41,86.38 87.85,86.95 87.33,86.95 83.32,90.96 82.78,90.96 81.8,91.94 81.23,91.94 77.68,95.49 77.68,97.67 76.79,98.56 76.79,100.62 78.84,102.67 82.88,102.67 83.19,102.36 v4(83.19,99.06)
DDR4_DIMM_CH1_DQ15: length 40.1
  L03_SIG1 w0.081: v4(93.26,78.93) 93.26,79.21 92.59,79.89 92.18,79.89 91.6,80.47 91.46,80.47 91.06,80.87 91.06,81.57 90.78,81.86 90.44,81.86 89.72,82.58 89.72,83.92 83.11,90.53 80.98,90.53 80.22,91.29 80.22,92.28 76.84,95.66 76.84,97.72 76,98.55 76,99.74 76.52,100.97 79.28,103.74 81.54,103.74 83.56,104.58 v4(84.04,105.06)
DDR4_DIMM_CH1_DQ16: length 43.6
  L05_SIG2 w0.081: v1(88.29,99.06) 89.57,97.79 89.57,97.27 89.77,97.06 91.49,97.06 94.08,94.48 97.08,94.48 98.36,93.2 98.5,93.2 98.6,93.29 98.6,93.43 97.8,94.23 97.8,94.37 97.9,94.47 98.03,94.47 99.77,92.73 99.77,90.73 100.73,89.77 100.86,89.77 100.96,89.87 100.96,90.01 100.18,90.8 100.18,90.93 100.28,91.03 100.41,91.03 101.56,89.89 101.56,88.42 101.46,88.32 101.32,88.32 101.23,88.42 101.23,88.88 101.13,88.98 100.99,88.98 100.89,88.88 100.89,88.01 100.99,87.91 101.46,87.91 101.56,87.81 101.56,87.1 101.36,86.89 100.84,86.89 100.69,86.74 100.69,79.71 100.61,79.63 100.61,78.35 100.92,78.04 101.38,78.04 101.68,78.34 102.19,78.34 102.49,78.04 102.94,78.04 103.27,78.37 103.27,79.08 103.66,79.46 v1(103.66,79.93)
DDR4_DIMM_CH1_DQ17: length 43.4
  L05_SIG2 w0.081: v1(89.14,105.06) 84.89,100.81 84.89,98.27 85.31,97.85 85.31,97.26 87.01,95.56 90.06,95.56 93.81,91.81 93.81,91.26 94.34,90.73 94.54,90.73 94.78,90.97 94.92,90.97 95.09,90.8 95.09,90.66 94.86,90.43 94.86,90.22 95.19,89.88 96.06,89.88 98.38,87.56 98.38,87.23 98.22,87.07 98.22,86.72 98.38,86.56 98.38,86.23 97.92,85.77 97.92,85.49 98.38,85.04 98.38,82.66 98.89,82.15 98.89,79.12 99.12,78.89 99.46,78.89 99.89,78.46 100.2,78.46 100.83,77.83 101.33,77.83 101.61,77.55 102.14,77.55 102.41,77.82 103.02,77.82 103.66,78.45 v1(103.66,78.93)
DDR4_DIMM_CH1_DQ18: length 43.7
  L05_SIG2 w0.081: v1(94.24,99.06) 94.65,98.66 101.56,98.66 101.66,98.56 101.66,98.42 101.56,98.32 100.03,98.32 99.93,98.23 99.93,98.09 100.03,97.99 101.53,97.99 103.48,96.03 103.48,95.89 103.39,95.79 103.25,95.79 102.45,96.59 102.31,96.59 102.22,96.49 102.22,96.35 103.22,95.34 103.39,95.34 103.65,95.08 103.65,94.74 103.35,94.44 103.35,92.49 103.45,92.39 103.59,92.39 103.68,92.49 103.68,94.12 103.78,94.21 103.92,94.21 104.02,94.12 104.02,92.49 104.12,92.39 104.26,92.39 104.35,92.49 104.35,94.4 104.45,94.5 104.59,94.5 104.69,94.4 104.69,92.13 104.5,91.94 104.2,91.94 104.04,91.78 104.04,85.1 103.42,84.48 103.42,83.39 103,82.97 103,80.74 103.16,80.59 103.16,80.27 103.03,80.14 103.03,79.67 v1(102.79,79.43)
DDR4_DIMM_CH1_DQ19: length 43.6
  L05_SIG2 w0.081: v1(102.79,78.43) 102.79,78.9 103.27,79.39 103.27,80.08 103.4,80.21 103.4,82.82 103.78,83.2 103.78,84.28 104.93,85.43 104.93,87.68 104.55,88.06 104.55,90.01 105.71,91.17 105.71,93.23 105.61,93.33 105.47,93.33 105.37,93.23 105.37,91.98 105.27,91.88 105.13,91.88 105.04,91.98 105.04,94.92 105.13,95.02 105.27,95.02 105.37,94.92 105.37,94.12 105.47,94.02 105.61,94.02 105.71,94.12 105.71,95.84 104.75,96.8 104.61,96.8 104.51,96.71 104.51,96.57 105.06,96.02 105.06,95.88 104.96,95.78 104.82,95.78 104.04,96.56 104.04,97.73 103.24,98.53 103.1,98.53 103,98.43 103,98.29 103.26,98.03 103.26,97.89 103.17,97.79 103.03,97.79 101.08,99.74 99.81,99.74 95.09,104.46 v1(95.09,105.06)
DDR4_DIMM_CH1_DQ20: length 39.8
  L05_SIG2 w0.081: v1(86.59,99.06) 87.38,98.28 88.05,98.28 88.76,97.56 88.76,97.16 89.23,96.7 91.32,96.7 93.95,94.08 96.14,94.08 96.23,93.98 96.23,93.84 96.14,93.74 94.25,93.74 94.16,93.64 94.16,93.5 94.25,93.4 96.29,93.4 96.38,93.31 96.38,93.17 96.29,93.07 95.7,93.07 95.6,92.97 95.6,92.83 95.7,92.73 97.15,92.73 98.08,91.81 98.08,90.83 98.99,89.92 99.13,89.92 99.23,90.02 99.23,90.16 98.55,90.83 98.55,90.97 98.65,91.07 98.79,91.07 99.73,90.13 99.73,88.32 99.83,88.22 99.97,88.22 100.06,88.32 100.06,89.54 100.16,89.64 100.3,89.64 100.4,89.54 100.4,87.11 100.2,86.92 100.2,82.96 100.36,82.8 100.36,80.1 v1(100.19,79.93)
DDR4_DIMM_CH1_DQ21: length 40
  L05_SIG2 w0.081: v1(99.32,78.43) 98.26,78.43 98.04,78.64 98.04,84.74 97.4,85.38 97.4,87.75 96.12,89.03 95.21,89.03 92.96,91.28 92.96,92.06 89.81,95.21 86.51,95.21 84.52,97.21 84.52,100.98 87.26,103.72 87.26,103.86 87.16,103.96 87.02,103.96 86.19,103.12 86.05,103.12 85.95,103.22 85.95,103.36 87.04,104.45 87.04,104.66 87.41,105.03 v1(87.46,105.03)
DDR4_DIMM_CH1_DQ22: length 39.9
  L05_SIG2 w0.081: v1(92.54,99.06) 92.54,100.53 92.27,100.79 92.27,101.87 91.46,102.68 89.24,102.68 86.16,99.61 86.16,98.68 86.98,97.87 86.98,97.34 88,96.32 90.57,96.32 94.5,92.39 95.75,92.39 99.1,89.05 99.1,88.29 99.76,87.63 99.76,86.16 99.35,85.75 99.35,85.15 99.76,84.74 99.76,82.4 100.04,82.12 100.04,80.3 99.75,80.01 99.75,79.37 v1(100.19,78.93)
DDR4_DIMM_CH1_DQ23: length 40
  L05_SIG2 w0.081: v1(99.32,79.43) 99.54,79.65 99.54,80.1 99.73,80.29 99.73,80.49 99.5,81.64 98.83,83.26 98.83,87.67 94.61,91.9 94.37,91.9 90.33,95.94 87.5,95.94 86.25,97.19 85.93,97.97 85.53,98.37 85.33,98.86 85.33,99.12 85.46,99.46 86.31,100.72 87.87,102.29 88.65,103.45 89.44,104.63 89.62,105.06 89.62,105.37 90.73,106.48 92.39,106.48 93.39,105.47 v1(93.39,105.06)
DDR4_DIMM_CH1_DQ24: length 32.9
  L03_SIG1 w0.081: v4(103.66,81.93) 103.66,81.76 102.95,81.05 102.58,81.05 102.08,80.55 101.75,80.55 101.28,81.03 100.92,81.03 100.59,81.36 100.59,84.71 99.76,85.53 99.76,86.63 99.45,86.95 99.19,86.95 98.95,87.19 98.95,88.02 98.05,88.92 98.05,91.64 97.58,92.12 97.58,94.94 97.23,95.28 97.23,96.36 98.07,97.2 98.07,97.93 97.91,98.09 96.9,98.09 96.79,98.19 96.79,98.41 96.9,98.51 97.94,98.51 98.07,98.65 98.07,99.35 98.41,99.68 100.22,99.68 100.32,99.78 100.32,100.32 100.17,100.47 98.84,100.47 98.44,100.07 97.96,100.07 97.64,99.75 v4(97.64,99.06)
DDR4_DIMM_CH1_DQ25: length 33.7
  L03_SIG1 w0.081: v4(98.49,105.06) 95.27,101.13 93.8,99.67 93.8,96.78 93.58,96.55 93.58,95.1 94.67,94.02 94.67,91.29 96.37,89.59 96.37,86.31 96.97,85.71 97.43,85.71 98.41,84.72 98.41,82.51 98.93,81.99 98.93,81.27 99.18,81.02 99.7,81.02 99.99,81.31 100.34,81.31 100.82,80.82 101.19,80.82 101.7,80.32 102.15,80.32 102.64,80.8 103.04,80.8 103.17,80.93 v4(103.66,80.93)
DDR4_DIMM_CH1_DQ26: length 32.3
  L03_SIG1 w0.081: v4(102.79,82.43) 103.25,82.89 103.25,83.31 103.45,83.51 103.45,84.95 103.19,85.2 103.19,89.86 102.98,90.08 102.84,90.08 102.65,89.89 102.51,89.89 102.41,89.98 102.41,90.12 102.6,90.32 102.6,90.45 102.51,90.55 102.37,90.55 102.17,90.36 102.03,90.36 101.48,90.92 101.48,92.01 101.59,92.12 101.78,92.12 101.88,92.22 101.88,92.36 101.78,92.46 101.4,92.46 101.32,92.54 101.32,92.72 101.42,92.82 101.91,92.82 102.01,92.92 102.01,93.06 101.91,93.16 101.4,93.16 101.3,93.26 101.3,93.4 101.4,93.49 101.98,93.49 102.08,93.59 102.08,93.73 101.98,93.83 101.37,93.83 101.27,93.93 101.27,94.07 101.37,94.16 101.79,94.16 101.88,94.26 101.88,94.4 101.79,94.5 101.37,94.5 101.27,94.6 101.27,94.74 101.37,94.83 101.79,94.83 101.88,94.93 101.88,95.07 101.79,95.17 101.39,95.17 101.29,95.27 101.29,95.67 102.36,96.74 102.36,97.6 103.18,98.43 103.18,100.67 102.85,101 102.85,102.12 103.04,102.31 103.47,102.31 103.66,102.12 103.66,101.68 103.48,101.51 103.48,101.02 103.59,100.91 v4(103.59,99.06)
DDR4_DIMM_CH1_DQ27: length 32.7
  L03_SIG1 w0.081: v4(102.79,81.43) 103.12,81.76 103.12,81.93 103.59,82.4 103.59,83.11 104.04,83.56 104.04,84.83 103.54,85.33 103.54,89.99 102.54,90.99 102.54,91.76 102.34,91.96 102.34,92.29 102.58,92.54 102.58,94.13 102.22,94.49 102.22,95.79 103.14,96.71 103.14,97.9 104.02,98.78 104.02,100.5 104.12,100.6 104.54,100.6 104.64,100.69 104.64,100.83 104.54,100.93 104.12,100.93 104.02,101.03 104.02,102.45 103.69,102.78 102.74,102.78 102.64,102.88 102.64,103.01 102.74,103.11 104.83,103.11 104.93,103.21 104.93,103.34 104.83,103.45 103.35,103.45 103.25,103.55 103.25,103.68 103.35,103.78 104.22,103.78 104.44,104 v4(104.44,105.06)
DDR4_DIMM_CH1_DQ28: length 30.5
  L03_SIG1 w0.081: v4(100.19,81.93) 100.19,84.63 98.61,86.21 98.61,87.86 97.66,88.81 97.66,90.21 97.19,90.68 97.19,92.31 97.05,92.44 97.05,93.78 96.68,94.14 96.68,95.58 96.37,95.89 96.37,99.19 97.67,100.48 98.19,100.48 98.53,100.82 99.82,100.82 99.92,100.92 99.92,101.05 99.82,101.15 99.27,101.15 99.16,101.25 99.16,101.39 99.27,101.49 99.76,101.49 99.86,101.59 99.86,101.72 99.76,101.82 98.94,101.82 98.03,100.91 97.38,100.91 95.94,99.47 v4(95.94,99.06)
DDR4_DIMM_CH1_DQ29: length 30.6
  L03_SIG1 w0.081: v4(100.19,80.93) 100.07,80.81 99,80.81 98.71,80.51 98.24,80.51 98.01,80.75 98.01,84.59 97.59,85.01 97.19,85.01 96.42,85.78 95.82,85.78 95.1,86.51 95.1,89.44 94.3,90.25 93.82,91.39 93.82,92.96 92.97,95 92.97,100.21 94.39,101.63 95.12,103.39 v4(96.79,105.06)
DDR4_DIMM_CH1_DQ30: length 29
  L03_SIG1 w0.081: v4(99.32,82.43) 99.82,82.92 99.82,84.48 98.27,86.03 98.27,87.65 97.28,88.64 97.28,89.97 96.99,90.27 96.4,91.68 96.1,92.41 96.1,94.32 96.32,94.54 96.32,95.25 95.49,96.09 95.49,99.49 97.36,101.37 98.02,101.37 98.81,102.16 100.38,102.16 100.7,101.84 100.7,99.93 101.57,99.06 v4(101.89,99.06)
DDR4_DIMM_CH1_DQ31: length 29.3
  L03_SIG1 w0.081: v4(102.74,105.06) 102.47,105.06 102.06,104.65 100.71,104.09 96.67,101.39 94.86,99.58 94.65,99.07 94.65,97.31 94.85,96.82 94.85,95.45 95,95.09 95.49,92.63 95.49,91.54 95.84,90.67 96.64,89.88 96.81,89.45 96.81,88.62 97.26,87.54 97.26,86.81 97.55,86.13 98.67,85.01 98.94,84.35 98.94,82.28 99.32,81.9 v4(99.32,81.43)
DDR4_DIMM_CH1_DQ32: length 76.7
  L07_SIG3 w0.089: v1(109.72,74.43) 109.72,74.15 109.11,73.55 108.63,73.55 108.14,73.05 107.83,73.05 107.33,73.55 106.97,73.55 106.74,73.78 106.74,75.08 106.86,75.21 106.86,75.65 106.74,75.78 106.74,76.08 106.86,76.21 106.86,76.65 106.74,76.78 106.74,77.08 106.89,77.23 106.89,77.63 106.74,77.78 106.74,78.08 106.86,78.2 106.86,78.65 106.74,78.78 106.74,79.08 106.86,79.21 106.86,79.65 106.74,79.78 106.74,80.08 106.86,80.21 106.86,80.65 106.74,80.77 106.74,81.08 107.07,81.41 107.32,81.41 107.8,81.89 108.24,81.89 109.26,82.92 109.37,82.92 111.34,84.89 111.61,84.89 111.89,85.17 111.89,85.85 112.66,86.62 113.4,86.93 114.53,87.68 115.35,87.68 116.7,89.04 118.14,89.63 120.64,92.14 122.69,92.14 123.01,92.45 123.01,93.09 123.51,93.59 124.34,93.59 124.44,93.49 124.44,93.35 124.34,93.25 123.76,93.25 123.67,93.16 123.67,93.02 123.76,92.92 124.94,92.92 125.57,93.54 128.85,93.54 130.26,94.95 132.77,94.95 134.06,96.24 135.69,96.24 136.97,94.96 137.88,94.96 137.98,95.06 137.98,95.48 138.08,95.58 138.22,95.58 138.32,95.48 138.32,95.06 138.42,94.96 138.56,94.96 138.65,95.06 138.65,95.48 138.75,95.58 138.89,95.58 138.99,95.48 138.99,95.06 139.09,94.96 139.23,94.96 139.32,95.06 139.32,95.48 139.42,95.58 139.56,95.58 139.66,95.48 139.66,95.06 139.76,94.96 140.44,94.96 140.54,95.06 140.54,95.45 140.64,95.55 140.78,95.55 140.87,95.45 140.87,95.06 140.97,94.96 141.11,94.96 141.21,95.06 141.21,95.45 141.31,95.55 141.45,95.55 141.54,95.45 141.54,95.06 141.64,94.96 141.78,94.96 141.88,95.06 141.88,95.45 141.98,95.55 142.12,95.55 142.22,95.45 142.22,95.06 142.31,94.96 143.33,94.96 143.43,95.06 143.43,95.43 143.53,95.53 143.67,95.53 143.76,95.43 143.76,95.06 143.86,94.96 144.58,94.96 145.58,95.96 146.86,95.96 148.28,97.37 148.28,98.41 148.52,98.66 152.49,98.66 v1(152.89,99.06)
DDR4_DIMM_CH1_DQ33: length 77.2
  L07_SIG3 w0.089: v1(109.72,73.43) 109.59,73.3 108.69,73.3 108.19,72.8 107.78,72.8 107.28,73.31 106.91,73.31 106.43,73.78 106.43,73.9 106.32,74 106.14,74 105.88,74.27 105.88,74.61 106.02,74.76 106.02,75.1 105.87,75.26 105.87,75.5 105.99,75.78 105.99,76.16 105.87,76.27 105.87,76.58 105.99,76.69 105.99,77.16 105.87,77.27 105.87,77.58 106.01,77.72 106.01,78.14 105.87,78.27 105.87,78.58 105.98,78.68 105.98,79.17 105.88,79.27 105.88,79.58 106.05,79.76 106.05,80.1 105.88,80.27 105.88,80.58 105.99,80.7 105.99,81.16 105.88,81.27 105.88,81.59 106.06,81.77 106.06,81.89 106.16,82 106.35,82 106.66,82.31 106.66,82.51 109.17,85.02 109.87,85.02 111.1,86.25 111.32,86.25 112.28,87.2 112.99,87.5 113.53,87.86 114.22,88.55 114.83,88.81 115.42,88.81 116.24,89.63 117.54,90.17 118.5,91.12 118.5,91.81 119.44,92.75 120.16,92.75 120.91,93.5 121.4,93.5 122.34,94.45 126.89,94.45 126.99,94.55 126.99,94.8 127.09,94.89 127.23,94.89 127.33,94.8 127.33,94.5 127.43,94.4 127.56,94.4 127.66,94.5 127.66,94.8 127.76,94.89 127.9,94.89 128,94.8 128,94.5 128.1,94.4 128.36,94.4 128.82,94.85 128.82,95.45 129.27,95.9 130.26,95.9 130.49,95.67 132.12,95.67 133.4,96.95 136.04,96.95 136.39,96.6 137.24,96.6 137.42,96.78 137.82,96.78 137.97,96.63 139.7,96.63 139.96,96.9 140.49,96.9 140.78,96.6 142.15,96.6 142.41,96.86 142.92,96.86 143.15,96.63 143.92,96.63 144.24,96.95 145.35,96.95 145.89,97.18 146.88,98.16 146.88,98.74 147.75,99.61 148.66,99.61 149.75,100.7 150.97,100.7 151.4,101.13 151.4,101.27 151.18,101.49 151.18,101.63 151.28,101.73 151.42,101.73 151.64,101.51 151.78,101.51 151.88,101.6 151.88,101.74 151.65,101.97 151.65,102.1 151.75,102.2 151.89,102.2 152.11,101.98 152.25,101.98 152.35,102.08 152.35,102.22 152.13,102.44 152.13,102.58 152.23,102.68 152.36,102.68 152.59,102.45 152.73,102.45 153.74,103.47 v1(153.74,105.06)
DDR4_DIMM_CH1_DQ34: length 77.4
  L07_SIG3 w0.089: v1(108.85,74.93) 109.05,75.12 109.05,75.59 109.23,75.77 109.23,76.09 109.07,76.24 109.07,76.62 109.23,76.77 109.23,77.08 109.07,77.24 109.07,77.62 109.23,77.77 109.23,78.08 109.07,78.23 109.07,78.62 109.23,78.77 109.23,79.08 109.1,79.21 109.1,79.65 109.49,80.04 109.86,80.04 110.37,80.55 110.74,80.55 111.24,81.05 111.6,81.05 112.09,81.54 112.46,81.54 112.97,82.04 113.33,82.04 113.6,82.31 113.6,82.55 115.37,84.33 116.15,84.33 116.25,84.43 116.25,84.57 116.15,84.67 115.26,84.67 115.16,84.76 115.16,84.9 115.26,85 116.92,85 117.98,86.06 117.98,86.65 118.28,86.94 118.93,86.94 119.93,87.94 120.28,87.94 121.37,89.03 123.88,89.03 124.17,89.32 131.69,89.32 131.79,89.42 131.79,89.56 131.69,89.66 130.81,89.66 130.71,89.76 130.71,89.89 130.81,89.99 132.26,89.99 132.9,90.64 136.49,90.64 136.9,91.04 137.51,91.04 137.61,90.95 137.61,90.68 137.71,90.58 137.85,90.58 137.94,90.68 137.94,91.12 138.04,91.22 138.18,91.22 138.28,91.12 138.28,90.68 138.38,90.58 138.52,90.58 138.61,90.68 138.61,91.12 138.71,91.22 138.85,91.22 138.95,91.12 138.95,90.68 139.05,90.58 139.19,90.58 139.28,90.68 139.28,90.95 139.42,91.08 140,91.08 140.13,90.95 140.13,90.67 140.23,90.58 140.37,90.58 140.47,90.67 140.47,91.13 140.57,91.23 140.71,91.23 140.81,91.13 140.81,90.67 140.9,90.58 141.04,90.58 141.14,90.67 141.14,90.95 141.24,91.04 141.91,91.04 142.01,90.95 142.01,90.7 142.11,90.6 142.25,90.6 142.35,90.7 142.35,91.23 142.52,91.4 143.04,91.4 143.14,91.5 143.14,91.64 143.04,91.74 142.48,91.74 142.38,91.83 142.38,91.97 142.48,92.07 143.33,92.07 143.57,91.83 143.87,91.83 144.02,91.99 144.02,92.18 144.14,92.29 144.59,92.29 144.73,92.15 144.73,91.71 144.86,91.59 145.05,91.59 145.75,92.28 146.19,92.28 146.47,92.56 146.47,92.99 146.72,93.24 147.29,93.24 147.33,93.19 147.78,93.19 148,93.42 148.59,93.42 150.17,95 150.63,95 150.91,95.28 156.13,95.28 157.61,96.76 157.61,97.35 158.84,98.58 v1(158.84,99.06)
DDR4_DIMM_CH1_DQ35: length 77.7
  L07_SIG3 w0.089: v1(108.85,73.93) 109.28,74.35 109.28,75.52 109.46,75.7 109.46,76.16 109.33,76.29 109.33,76.57 109.46,76.7 109.46,77.16 109.33,77.28 109.33,77.57 109.46,77.7 109.46,78.16 109.33,78.29 109.33,78.56 109.46,78.69 109.46,79.16 109.33,79.28 109.33,79.58 109.56,79.81 109.93,79.81 110.44,80.32 110.81,80.32 111.3,80.81 111.66,80.81 112.16,81.31 112.53,81.31 113.04,81.82 113.4,81.82 114.5,82.92 114.77,82.92 115.69,83.84 116.61,83.84 117.34,84.58 117.34,84.94 118.26,85.85 118.56,85.85 119.51,86.81 120.11,86.81 121.34,88.05 122.03,88.05 122.67,88.68 124.05,88.68 124.33,88.97 132.32,88.97 133.31,89.96 138.25,89.96 138.5,90.2 142.55,90.2 142.81,90.47 142.81,90.9 142.95,91.04 145.02,91.04 145.89,91.91 146.47,91.91 147.41,92.84 147.98,92.84 148.21,93.08 148.73,93.08 149.64,93.99 150.45,93.99 151.36,94.9 156.26,94.9 158.13,96.77 158.13,97.36 159.27,98.49 159.27,101.46 159.36,101.56 159.5,101.56 159.6,101.46 159.6,100.71 159.7,100.62 159.84,100.62 159.94,100.71 159.94,102.77 159.84,102.87 159.7,102.87 159.6,102.77 159.6,102.17 159.5,102.07 159.36,102.07 159.27,102.17 159.27,103.99 159.36,104.09 159.5,104.09 159.6,103.99 159.6,103.49 159.7,103.39 159.84,103.39 159.94,103.49 159.94,104.36 159.69,104.61 v1(159.69,105.06)
DDR4_DIMM_CH1_DQ36: length 73.6
  L07_SIG3 w0.089: v1(151.19,99.06) 152.73,100.6 153.13,100.6 153.5,100.23 154.43,100.23 154.79,100.6 154.79,102.71 154.33,103.17 154.01,103.17 150.04,99.2 148,99.2 147.37,98.58 147.37,97.21 146.94,96.78 145.98,96.78 145.65,96.45 145.09,96.45 144.58,95.94 136.48,95.94 135.83,96.59 133.72,96.59 132.43,95.3 130.08,95.3 128.8,94.03 123.43,94.03 122.54,93.14 121.16,93.14 117.96,89.94 116.49,89.33 115.2,88.05 114.43,88.05 113.17,87.2 112.47,86.91 111.41,85.85 111.26,85.85 110.12,84.72 110.12,84.26 109.9,84.04 109.64,84.04 108.47,82.87 107.52,82.87 106.66,82.01 106.66,81.3 106.48,81.13 106.48,80.73 106.64,80.58 106.64,80.28 106.48,80.13 106.48,79.73 106.64,79.58 106.64,79.28 106.48,79.12 106.48,78.73 106.64,78.58 106.64,78.28 106.48,78.13 106.48,77.73 106.64,77.58 106.64,77.28 106.48,77.13 106.48,76.73 106.64,76.58 106.64,76.28 106.48,76.13 106.48,75.73 106.64,75.58 106.64,75.28 106.48,75.13 106.48,74.66 v1(106.25,74.43)
DDR4_DIMM_CH1_DQ37: length 73.9
  L07_SIG3 w0.089: v1(152.04,105.06) 152.04,104.31 151.86,104.14 150.85,104.14 150.75,104.04 150.75,103.9 150.85,103.8 151.38,103.8 151.48,103.7 151.48,103.56 151.38,103.46 150.37,103.46 149.32,102.41 149.18,102.41 149.08,102.51 149.08,102.65 149.79,103.36 149.79,103.49 149.69,103.59 149.55,103.59 147.73,101.77 147.73,101.63 147.82,101.53 147.96,101.53 148.55,102.12 148.69,102.12 148.79,102.02 148.79,101.88 147.64,100.73 146.97,100.73 146.27,100.04 146.27,99.49 144.6,97.82 139.09,97.82 138.99,97.72 138.76,97.72 138.51,97.82 130.87,97.82 129.87,97.52 127.5,95.94 123.36,95.94 122.52,95.59 120.94,94.54 119.59,93.98 115.46,89.85 112.81,88.75 112.65,88.59 112.65,88.32 112.36,88.03 112.03,87.9 111.49,87.9 109.99,87.28 108.2,85.49 107.93,85.49 106.98,84.53 106.98,84.12 105.47,82.61 105.43,82.5 105.01,82.08 105.01,81.77 105.15,81.64 105.15,81.22 104.98,81.06 104.98,80.8 105.12,80.66 105.12,80.2 105,80.07 105,79.79 105.13,79.65 105.13,79.21 104.99,79.07 104.99,78.79 105.11,78.67 105.11,78.18 104.99,78.06 104.99,77.79 105.14,77.64 105.14,77.22 105,77.07 105,76.79 105.16,76.62 105.16,76.23 105,76.07 105,75.79 105.11,75.67 105.11,75.19 104.99,75.06 104.99,74.79 105.27,74.51 105.52,74.51 105.65,74.39 105.65,74.19 105.78,74.07 105.78,73.9 v1(106.25,73.43)
DDR4_DIMM_CH1_DQ38: length 73.6
  L07_SIG3 w0.089: v1(157.14,99.06) 156.49,100.63 154.26,104.81 154.17,105.03 154.17,105.24 153.96,105.44 153.52,105.44 153.29,105.21 153.29,104.93 153.18,104.66 152.93,104.29 151.25,102.24 150.94,101.93 150.27,101.65 149.83,101.65 149.4,101.47 147.99,100.54 145.31,97.85 145.12,97.85 144.68,97.41 144.09,97.41 143.73,97.06 143.36,97.06 143.05,97.36 142.3,97.36 141.99,97.06 141.55,97.06 140.92,97.32 140.04,97.32 139.4,97.06 138.36,97.06 137.78,97.29 137.21,97.29 136.97,97.06 136.48,97.06 136.23,97.31 133.26,97.31 132.08,96.82 129.45,96.82 127.44,95.48 125.73,94.96 122.23,94.96 121.49,94.22 120.7,93.89 119.95,93.14 119.26,93.14 117.63,91.52 117.63,90.76 117.38,90.51 116.08,89.97 115.61,89.51 114.04,88.85 113.32,88.14 112.81,87.8 112.08,87.49 111.64,87.05 111.23,86.88 109.98,86.05 109.26,85.75 107.75,84.74 107.62,84.6 107.33,83.91 106.22,82.8 106.01,82.8 105.77,82.57 105.77,81.78 105.59,81.6 105.59,81.26 105.77,81.08 105.77,80.78 105.65,80.66 105.65,80.2 105.79,80.06 105.79,79.8 105.65,79.66 105.65,79.2 105.76,79.08 105.76,78.77 105.66,78.67 105.66,78.19 105.77,78.08 105.77,77.78 105.63,77.64 105.63,77.21 105.77,77.08 105.77,76.77 105.64,76.65 105.64,76.21 105.76,76.08 105.76,75.84 v1(105.39,74.93)
DDR4_DIMM_CH1_DQ39: length 73.8
  L07_SIG3 w0.089: v1(157.99,105.06) 157.99,105.77 157.23,106.53 154.49,106.53 150,104.67 145.74,100.41 145.74,99.78 144.63,98.67 140.99,98.67 140.48,98.88 139.33,98.88 138.67,98.61 137.5,98.61 137.34,98.76 136.96,98.76 136.41,98.2 130.51,98.2 127.31,96.88 123.36,96.88 122.38,96.47 120.86,94.95 120.07,94.95 117.29,92.17 116.69,91.91 116.27,91.91 115.97,91.61 115.97,90.89 115.22,90.14 110.31,88.11 108.16,85.96 107.92,85.96 106.64,84.67 106.64,84.3 105.35,83.02 105.14,82.52 104.77,82.14 104.77,81.72 104.91,81.58 104.91,81.28 104.75,81.13 104.75,80.73 104.91,80.58 104.91,80.28 104.75,80.12 104.75,79.73 104.9,79.58 104.9,79.28 104.75,79.13 104.75,78.73 104.9,78.58 104.9,78.27 104.75,78.12 104.75,77.73 104.9,77.58 104.9,77.27 104.76,77.14 104.76,76.72 104.9,76.58 104.9,76.28 104.75,76.13 104.75,75.73 104.9,75.59 104.9,75.27 104.75,75.13 104.75,74.73 104.96,74.53 104.96,74.36 v1(105.39,73.93)
DDR4_DIMM_CH1_DQ40: length 85.7
  L05_SIG2 w0.081: v1(109.72,77.43) 109.23,76.94 109.23,76.77 108.87,76.41 108.67,76.41 108.17,75.92 107.81,75.92 107.43,75.54 106.93,75.54 106.74,75.73 106.74,77.09 106.94,77.29 106.94,77.56 106.74,77.75 106.74,78.08 106.86,78.2 106.86,78.65 106.74,78.77 106.74,79.09 106.84,79.19 106.84,79.66 106.74,79.76 106.74,80.1 106.87,80.23 106.87,80.65 106.74,80.78 106.74,81.08 106.89,81.23 106.89,81.63 106.74,81.78 106.74,82.09 107.93,83.27 108.47,84.58 108.47,86.93 111.2,89.66 112.63,89.66 114.26,91.29 114.26,91.85 117.3,94.9 131.53,94.9 134.55,97.92 137.9,97.92 140.66,100.67 150.72,100.67 151.73,101.68 163.3,101.68 163.58,101.4 163.58,100.53 163.22,100.17 160.8,100.17 160.1,99.47 160.1,98.91 160.33,98.68 161.86,98.68 v1(162.24,99.06)
DDR4_DIMM_CH1_DQ41: length 85.7
  L05_SIG2 w0.081: v1(163.09,105.06) 162.71,105.44 140.77,105.44 138.34,103 138.34,102.67 135.59,99.93 133.59,99.93 132.42,98.76 126.4,98.76 126.28,98.87 125.39,98.87 125.28,98.99 117.12,98.99 116.49,98.36 115,98.36 114.21,97.56 114.21,97.11 113.04,95.94 112.73,95.94 109.11,92.31 108.75,92.31 106.13,89.69 106.13,84.9 105.69,84.47 105.69,84.07 104.95,83.33 104.95,82.33 104.78,82.16 104.78,81.71 104.93,81.56 104.93,81.31 104.8,81.17 104.8,80.68 104.92,80.56 104.92,80.3 104.77,80.15 104.77,79.71 104.93,79.55 104.93,79.31 104.8,79.17 104.8,78.68 104.92,78.55 104.92,78.3 104.81,78.18 104.81,77.68 104.91,77.58 104.91,77.28 104.75,77.12 104.75,76.72 105,76.47 105,75.72 105.29,75.43 105.58,75.43 106.08,74.93 106.45,74.93 106.86,74.52 107.4,74.52 107.76,74.88 108.17,74.88 108.7,75.42 109,75.42 109.72,76.13 v1(109.72,76.43)
DDR4_DIMM_CH1_DQ42: length 85.6
  L05_SIG2 w0.081: v1(108.85,76.93) 109.25,77.33 109.25,80.76 109.5,81.01 109.82,81.01 110.09,81.27 110.09,81.58 109.93,81.74 109.93,82.12 110.09,82.27 110.09,82.61 111.25,83.77 111.81,83.77 112.2,84.16 112.2,86.16 112.95,86.91 113.94,86.91 117.2,90.17 120.13,90.17 120.23,90.27 120.23,90.41 120.13,90.51 117.91,90.51 117.81,90.61 117.81,90.75 117.91,90.84 120.21,90.84 120.31,90.94 120.31,91.08 120.21,91.18 119.44,91.18 119.35,91.28 119.35,91.42 119.44,91.51 120.06,91.51 120.39,91.84 121.64,91.84 121.87,92.08 122.57,92.08 122.78,92.28 124.24,92.28 124.83,91.7 125.11,91.7 125.21,91.79 125.21,92.18 125.31,92.28 125.45,92.28 125.55,92.18 125.55,91.79 125.64,91.7 125.78,91.7 125.88,91.79 125.88,92.18 125.98,92.28 126.12,92.28 126.22,92.18 126.22,91.79 126.31,91.7 126.45,91.7 126.55,91.79 126.55,92.18 126.65,92.28 126.79,92.28 126.89,92.18 126.89,91.79 126.99,91.7 127.59,91.7 127.95,92.05 129.27,92.05 129.6,91.72 130.21,91.72 130.54,92.05 132.47,92.05 132.93,91.6 136.25,91.6 136.71,92.05 137.4,92.05 138.28,92.94 139.17,92.94 140.17,93.94 141.19,93.94 142.1,94.85 143.09,94.85 143.44,95.2 143.44,95.53 143.8,95.89 144.78,95.89 145.2,95.47 145.93,95.47 146.35,95.89 147.66,95.89 148.06,95.49 148.94,95.49 149.34,95.89 151.79,95.89 152,95.68 165.64,95.68 166.23,96.27 166.96,96.27 167.82,97.13 167.82,97.59 168.19,97.96 v1(168.19,99.06)
DDR4_DIMM_CH1_DQ43: length 85.6
  L05_SIG2 w0.081: v1(108.85,75.93) 109.23,76.31 109.23,76.47 109.7,76.94 109.86,76.94 110.12,77.21 110.12,81 110.37,81.24 110.37,81.62 110.21,81.78 110.21,82.08 110.37,82.24 110.37,82.4 111.4,83.43 111.94,83.43 112.72,84.21 112.72,85.79 112.91,85.98 113.62,85.98 117.29,89.65 120.1,89.65 121.86,91.41 122.72,91.41 123.25,91.95 124.1,91.95 124.84,91.21 127.92,91.21 128.08,91.06 129.26,91.06 129.35,91.15 136.49,91.15 136.59,91.06 137.88,91.06 139.77,92.95 141.04,92.95 142.36,94.26 143.48,94.26 144.19,94.97 165.42,94.97 166.34,95.9 167.35,95.9 168.61,97.16 168.61,103.84 168.71,103.93 168.85,103.93 168.95,103.84 168.95,102.15 169.05,102.05 169.18,102.05 169.28,102.15 169.28,104.37 169.04,104.61 v1(169.04,105.06)
DDR4_DIMM_CH1_DQ44: length 82.4
  L05_SIG2 w0.081: v1(106.25,77.43) 106.53,77.71 106.53,78.17 106.63,78.27 106.63,78.58 106.53,78.68 106.53,79.17 106.64,79.28 106.64,79.57 106.53,79.68 106.53,80.18 106.66,80.31 106.66,80.56 106.52,80.7 106.52,81.16 106.63,81.27 106.63,81.58 106.51,81.7 106.51,82.16 106.78,82.43 106.78,82.76 107.61,83.59 107.61,85.43 107.47,85.57 107.47,87.63 107.9,88.06 108.08,88.06 110.09,90.07 112.22,90.07 113.37,91.21 113.37,91.77 117.48,95.89 129.57,95.89 129.83,95.63 131.07,95.63 131.35,95.91 131.35,96.29 131.55,96.5 132.37,96.5 134.32,98.45 136.68,98.45 136.99,98.76 137.34,98.76 137.5,98.61 138.06,98.61 140.16,100.71 140.16,100.87 140.9,101.6 150.6,101.6 151.13,102.14 163.28,102.14 163.52,102.38 164.32,102.38 164.85,101.85 164.85,100.07 164.46,99.68 161.16,99.68 v1(160.54,99.06)
DDR4_DIMM_CH1_DQ45: length 82.6
  L05_SIG2 w0.081: v1(161.39,105.06) 160.92,104.59 159.13,104.59 158.5,103.96 155.3,103.96 155.2,104.06 155.2,104.46 155.1,104.56 154.96,104.56 154.86,104.46 154.86,104.06 154.76,103.96 154.63,103.96 154.53,104.06 154.53,104.46 154.43,104.56 154.29,104.56 154.19,104.46 154.19,104.06 154.09,103.96 153.95,103.96 153.86,104.06 153.86,104.46 153.76,104.56 153.62,104.56 153.52,104.46 153.52,104.06 153.42,103.96 153.28,103.96 153.19,104.06 153.19,104.46 153.09,104.56 152.95,104.56 152.85,104.46 152.85,104.06 152.75,103.96 152.61,103.96 152.52,104.06 152.52,104.46 152.42,104.56 152.28,104.56 152.18,104.46 152.18,104.06 152.08,103.96 150.12,103.96 149.56,104.52 142.25,104.52 139.3,101.58 137.75,101.58 135.74,99.57 133.74,99.57 132.44,98.28 130.08,98.28 129.67,97.87 125.58,97.87 124.82,98.63 118.32,98.63 117.23,97.54 116.22,97.54 112.03,93.36 110.78,93.36 109.1,91.69 109.1,91.26 108.26,90.42 107.36,90.42 106.46,89.52 106.46,85.06 106.6,84.93 106.6,84.26 105.33,83 105.33,82.41 105.01,82.09 105.01,81.78 105.14,81.64 105.14,81.22 105.01,81.08 105.01,80.77 105.13,80.64 105.13,80.21 104.98,80.06 104.98,79.79 105.14,79.64 105.14,79.22 105.01,79.09 105.01,78.77 105.13,78.64 105.13,78.21 105.02,78.1 105.02,77.77 105.11,77.67 105.11,77.19 104.96,77.04 104.96,76.81 105.39,76.38 v1(105.39,75.93)
DDR4_DIMM_CH1_DQ46: length 83
  L05_SIG2 w0.081: v1(166.49,99.06) 166.22,99.06 165.74,99.55 165.74,102.47 164.92,103.29 162.28,103.29 161.62,102.64 148.14,102.64 147.51,102.01 140.82,102.01 139.53,100.71 139.53,100.56 138.51,99.55 136.68,99.55 135.97,98.83 134.12,98.83 132.24,96.95 117.61,96.95 112.53,91.87 112.53,91.26 111.69,90.43 109.92,90.43 108.46,88.97 107.44,88.97 107.13,88.66 107.13,85.41 107.27,85.27 107.27,83.97 105.87,82.57 105.87,82.28 106,82.15 106,81.71 105.87,81.59 105.87,81.28 106.02,81.13 106.02,80.74 105.87,80.58 105.87,80.27 106.04,80.1 106.04,79.75 105.88,79.59 105.88,79.27 105.99,79.15 105.99,78.7 105.88,78.59 105.88,78.26 105.98,78.16 105.98,77.69 105.83,77.53 105.83,77.13 106.25,76.71 v1(106.25,76.43)
DDR4_DIMM_CH1_DQ47: length 82.3
  L05_SIG2 w0.081: v1(167.34,105.06) 167.34,105.4 166.26,106.48 165.15,106.48 164.43,106.18 163.48,105.23 163.48,104.86 163.28,104.67 161.63,103.98 159,103.46 145.68,103.46 144.63,102.42 140.72,102.42 138.92,100.61 137.27,100.61 135.87,99.22 133.94,99.22 132.57,97.84 130.54,97.84 130.18,97.49 125.36,97.49 125,97.84 118.02,97.84 112.85,92.67 111.47,92.67 108.73,89.93 107.35,89.93 106.8,89.38 106.8,85.27 106.94,85.13 106.94,84.11 105.62,82.8 105.62,82.23 105.76,82.09 105.76,81.77 105.66,81.67 105.66,81.2 105.82,81.04 105.82,80.82 105.66,80.67 105.66,80.19 105.84,80.01 105.84,79.84 105.67,79.67 105.67,79.18 105.78,79.07 105.78,78.79 105.67,78.68 105.67,78.18 105.78,78.07 105.78,77.77 105.62,77.62 105.62,77.16 v1(105.39,76.93)
DDR4_DIMM_CH1_DQ48: length 84.7
  L07_SIG3 w0.089: v1(115.78,76.93) 115.78,76.56 115.15,75.93 114.62,75.93 114.23,75.54 113.85,75.54 113.51,75.89 113.19,75.89 112.8,76.28 112.8,77.58 112.99,77.77 112.99,78.09 112.8,78.27 112.8,78.58 113.04,78.82 113.41,78.82 113.88,79.29 114.24,79.29 114.76,79.81 115.13,79.81 115.64,80.32 116,80.32 116.5,80.81 116.86,80.81 117.36,81.31 117.73,81.31 118.23,81.82 118.6,81.82 119.62,82.83 120.53,82.83 121.62,83.92 122.03,83.92 122.92,84.81 134.28,84.81 134.42,84.67 140.56,84.67 141.71,85.83 143.64,85.83 144.15,86.34 144.15,86.57 144.53,86.95 144.94,86.95 147.43,89.43 149.41,90.25 152.44,90.25 153.91,91.72 156.73,91.72 157.06,92.05 158.58,92.05 161.45,94.92 168.5,94.92 168.6,95.02 168.6,95.16 168.5,95.26 166.75,95.26 166.65,95.36 166.65,95.49 166.75,95.59 168.98,95.59 169.07,95.69 169.07,95.83 168.98,95.93 167.56,95.93 167.46,96.03 167.46,96.17 167.56,96.26 169.51,96.26 169.6,96.36 169.6,96.5 169.51,96.6 168.22,96.6 168.12,96.7 168.12,96.84 168.22,96.93 169.94,96.93 170.47,97.46 170.47,97.94 v1(171.59,99.06)
DDR4_DIMM_CH1_DQ49: length 85.3
  L07_SIG3 w0.089: v1(172.44,105.06) 172.44,103.34 171.62,102.52 171.48,102.52 171.38,102.62 171.38,102.76 171.85,103.22 171.85,103.36 171.75,103.46 171.61,103.46 166.63,98.48 165.98,98.48 165.22,97.73 165.22,97.05 164.58,96.41 159.89,96.41 156.81,93.33 152.34,93.33 150.85,91.84 149.35,91.84 149.06,91.55 148.5,91.55 147.59,90.63 146.87,90.34 145.18,88.64 143.4,88.64 142.77,88.01 141.64,88.01 140.55,86.92 132.87,86.92 132.6,87.19 128.4,87.19 127.91,86.69 124.47,86.69 123.97,87.19 123.23,87.19 122.08,86.05 121.56,86.05 121.37,85.86 121.37,85.62 120.52,84.77 120.52,84.31 120.23,84.02 119.13,84.02 118.49,83.37 117.98,83.37 117.14,82.53 117.14,82.39 116.79,82.04 116.43,82.04 115.93,81.55 115.56,81.55 115.06,81.05 114.7,81.05 114.2,80.55 113.83,80.55 113.33,80.04 112.96,80.04 112.47,79.55 112.1,79.55 111.56,79.01 111.34,79.01 111.24,78.91 111.24,78.75 111.06,78.57 111.06,78.29 111.18,78.16 111.18,77.69 111.06,77.57 111.06,77.29 111.3,77.04 111.46,77.04 112.12,76.38 112.39,76.38 112.76,76.02 112.76,75.16 113.01,74.91 113.27,74.91 113.62,74.55 114.33,74.55 114.76,74.98 115.15,74.98 115.78,75.62 v1(115.78,75.93)
DDR4_DIMM_CH1_DQ50: length 83.7
  L07_SIG3 w0.089: v1(177.54,99.06) 178.02,98.59 178.02,96.81 172.61,91.39 171.22,91.39 171.12,91.29 171.12,91.16 171.22,91.06 171.87,91.06 171.97,90.96 171.97,90.82 171.87,90.72 170.62,90.72 170.16,91.19 169.58,91.19 169.11,90.72 167.75,90.72 167.5,90.98 166.54,90.98 166.29,90.72 164.65,90.72 162.67,88.74 155.76,88.74 154.9,87.87 154.9,83.59 152.2,80.9 148.45,80.9 146.34,83 142.86,83 142.21,82.35 141.49,82.35 141.1,81.97 140.84,81.97 140.31,81.44 139.28,81.44 138.67,82.05 135.94,82.05 135.32,81.44 134.61,81.44 134.11,80.94 133.65,80.94 133.2,81.39 132.94,81.39 132.48,80.93 132.02,80.93 131.53,81.42 131.12,81.42 130.59,80.89 130.25,80.89 129.72,81.42 129.44,81.42 128.94,80.92 128.64,80.92 128.17,81.38 127.68,81.38 127.21,80.91 126.86,80.91 126.31,81.47 126.03,81.47 125.47,80.91 125.08,80.91 124.55,81.44 124.25,81.44 123.71,80.89 123.38,80.89 122.93,80.44 122.58,80.44 122.11,80.9 121.7,80.9 121.19,80.39 120.73,80.39 120.28,79.94 119.95,79.94 119.39,79.38 119.01,79.38 118.55,78.92 118.19,78.92 117.63,78.36 117.28,78.36 116.87,77.96 116.54,77.96 116.14,77.55 115.47,77.55 115.34,77.43 v1(114.91,77.43)
DDR4_DIMM_CH1_DQ51: length 84.2
  L07_SIG3 w0.089: v1(178.39,105.06) 178.82,104.63 178.82,96.74 172.31,90.23 166.32,90.23 164.34,88.25 158.79,88.25 156.54,86 156.54,84.36 152.72,80.54 147.81,80.54 147.49,80.87 142.36,80.87 142.02,80.53 141.56,80.53 141.19,80.9 135.46,80.9 135,80.44 134.68,80.44 134.2,79.96 128.56,79.96 128.1,80.41 127.69,80.41 127.24,79.96 126.9,79.96 126.45,80.41 125.96,80.41 125.53,79.98 125.08,79.98 124.68,80.38 124.24,80.38 123.81,79.96 123.45,79.96 122.98,79.48 122.4,79.48 121.98,79.91 121.65,79.91 121.19,79.45 120.78,79.45 120.25,78.92 119.9,78.92 119.39,78.41 118.98,78.41 118.5,77.93 118.14,77.93 117.74,77.52 117.36,77.52 116.8,76.96 116.39,76.96 116.03,77.32 115.58,77.32 115.24,76.99 115.24,76.76 v1(114.91,76.43)
DDR4_DIMM_CH1_DQ52: length 81.4
  L07_SIG3 w0.089: v1(112.32,76.93) 112.32,77.4 112.7,77.78 112.7,78.07 112.58,78.19 112.58,78.66 112.97,79.05 113.34,79.05 113.83,79.54 114.19,79.54 114.69,80.04 115.06,80.04 115.56,80.55 115.93,80.55 116.44,81.05 116.8,81.05 117.3,81.55 117.67,81.55 117.91,81.8 117.91,82.5 118.22,82.81 119.07,82.81 119.48,83.22 120.43,83.22 121.4,84.2 121.4,84.58 121.63,84.81 122.26,84.81 123.28,85.83 134.34,85.83 135.12,85.05 140.29,85.05 141.47,86.23 142.67,86.23 143.36,86.92 143.77,86.92 144.13,87.28 144.13,87.58 144.48,87.94 145.45,87.94 147.23,89.72 149.37,90.61 151.6,90.61 153.59,92.6 158.42,92.6 159.26,93.44 159.26,93.58 159.16,93.68 159.02,93.68 158.48,93.14 158.34,93.14 158.24,93.24 158.24,93.38 160.34,95.47 160.48,95.47 160.58,95.37 160.58,95.24 159.62,94.27 159.62,94.14 159.71,94.04 159.85,94.04 161.16,95.35 164.85,95.35 165.86,96.36 166,96.36 166.09,96.26 166.09,96.12 165.56,95.59 165.56,95.45 165.66,95.36 165.8,95.36 167.76,97.31 167.76,97.83 168.05,98.12 169.66,98.12 170.33,98.79 170.33,99.25 170.79,99.71 171.05,99.71 171.15,99.81 171.15,100.06 171.05,100.16 170.41,100.16 169.89,99.65 v1(169.89,99.06)
DDR4_DIMM_CH1_DQ53: length 81.9
  L07_SIG3 w0.089: v1(170.74,105.06) 169.16,103.48 167.67,103.48 163.5,99.31 163.5,98.68 162.75,97.93 160.22,97.93 156.39,94.1 151.41,94.1 150.7,93.39 150.11,93.39 149.86,93.15 149.67,93.15 148.76,92.24 147.65,92.24 146.46,91.05 145.9,91.05 144.93,90.08 143.27,90.08 142.8,89.6 138.74,89.6 138.64,89.51 138.64,89.37 138.74,89.27 140.91,89.27 141.01,89.17 141.01,89.03 140.91,88.93 133.52,88.93 132.51,87.92 122.87,87.92 122.22,87.27 121.45,87.27 120.11,85.94 119.81,85.94 118.89,85.02 118.3,85.02 117.96,84.68 117.96,84.36 116.83,83.22 115.93,83.22 115.35,82.64 115.35,82.33 115.06,82.04 114.69,82.04 114.2,81.55 113.84,81.55 113.34,81.05 112.97,81.05 112.47,80.55 112.1,80.55 111.6,80.05 111.24,80.05 110.64,79.45 110.45,79.45 110.19,79.2 110.19,76.66 110.47,76.38 110.82,76.38 111.27,75.93 v1(112.32,75.93)
DDR4_DIMM_CH1_DQ54: length 79.8
  L07_SIG3 w0.089: v1(175.84,99.06) 175.84,101.36 175.42,101.79 171.21,101.79 168.61,99.19 168.61,98.86 168.31,98.56 167.47,98.56 164.77,95.86 160.02,95.86 157.12,92.97 153.43,92.97 151.51,91.05 149.32,91.05 149.2,91.18 148.62,91.18 147.77,90.33 147.06,90.03 145.31,88.29 143.59,88.29 142.1,86.8 141.24,86.8 140.43,86 138.98,86 138.62,86.35 138.04,86.35 137.68,86 135.19,86 134.82,86.36 132.87,86.36 132.39,86.84 128.62,86.84 128.11,86.34 124.31,86.34 123.83,86.82 123.34,86.82 123.16,86.64 123.16,86.25 122.07,85.15 121.43,85.15 120.96,84.68 120.96,84.25 120.36,83.65 119.36,83.65 118.76,83.05 118.1,83.05 116.87,81.82 116.5,81.82 115.99,81.31 115.63,81.31 115.13,80.81 114.76,80.81 114.27,80.32 113.9,80.32 113.4,79.81 113.03,79.81 112.55,79.33 112.18,79.33 111.87,79.02 111.87,77.85 v1(111.45,77.43)
