# Allegro board TS28247BC0_FM61_agilex_PCIe_DEVKIT_ADI_REVB1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_DIMM_CH3_DQS_P1: length 92.4
  L07_SIG3 w0.085: v1(112.32,48.93) 112.27,49.18 112.37,49.28 112.56,49.28 112.61,49.23 112.67,49.08 112.85,48.9 113.06,48.81 113.22,48.81 arc(113.34,48.78) 113.44,48.7 113.59,48.51 arc(113.77,48.37) 114,48.31 114.08,48.31 arc(114.21,48.29) 114.31,48.2 114.46,48.01 arc(114.64,47.87) 114.87,47.81 114.95,47.81 arc(115.17,47.87) 115.35,48.01 115.51,48.2 arc(115.61,48.28) 115.73,48.31 115.82,48.31 arc(115.94,48.29) 116.04,48.2 116.19,48.01 arc(116.37,47.87) 116.6,47.81 118.41,47.81 arc(118.64,47.87) 118.82,48.01 118.97,48.2 arc(119.07,48.28) 119.2,48.31 119.28,48.31 arc(119.4,48.29) 119.5,48.2 119.66,48.01 arc(119.84,47.87) 120.06,47.81 120.15,47.81 arc(120.37,47.87) 120.55,48.01 120.7,48.2 arc(120.8,48.28) 120.93,48.31 121.01,48.31 arc(121.14,48.29) 121.24,48.2 121.39,48.01 arc(121.57,47.87) 121.79,47.81 121.88,47.81 arc(122.1,47.87) 122.28,48.01 122.43,48.2 arc(122.53,48.28) 122.66,48.31 122.74,48.31 arc(122.87,48.29) 122.97,48.2 123.12,48.01 arc(123.3,47.87) 123.53,47.81 125.15,47.81 125.66,47.31 126.21,47.31 arc(126.33,47.28) 126.43,47.2 126.58,47.01 arc(126.76,46.87) 126.99,46.81 127.07,46.81 arc(127.2,46.78) 127.3,46.7 127.45,46.51 arc(127.63,46.37) 127.86,46.31 127.94,46.31 arc(128.06,46.28) 128.16,46.2 128.32,46.01 arc(128.5,45.87) 128.72,45.81 128.81,45.81 arc(128.93,45.79) 129.03,45.7 129.18,45.51 arc(129.36,45.37) 129.59,45.31 129.67,45.31 arc(129.8,45.29) 129.9,45.2 130.05,45.01 arc(130.23,44.87) 130.45,44.81 130.54,44.81 arc(130.66,44.79) 130.76,44.7 130.91,44.51 arc(131.09,44.37) 131.32,44.31 131.4,44.31 arc(131.53,44.29) 131.63,44.2 131.78,44.01 arc(131.96,43.87) 132.19,43.81 132.27,43.81 arc(132.39,43.79) 132.49,43.71 132.65,43.51 arc(132.83,43.37) 133.05,43.31 133.14,43.31 arc(133.26,43.29) 133.36,43.21 133.51,43.01 arc(133.69,42.87) 133.92,42.81 134,42.81 arc(134.13,42.79) 134.23,42.71 134.38,42.51 arc(134.56,42.37) 134.78,42.31 134.87,42.31 arc(135.09,42.37) 135.27,42.51 135.42,42.7 arc(135.52,42.79) 135.65,42.81 135.73,42.81 arc(135.86,42.79) 135.96,42.71 136.11,42.51 arc(136.29,42.37) 136.52,42.31 136.6,42.31 arc(136.72,42.29) 136.82,42.21 136.98,42.01 arc(137.16,41.87) 137.38,41.81 137.47,41.81 arc(137.59,41.79) 137.69,41.71 137.84,41.51 arc(138.02,41.37) 138.25,41.31 138.39,41.31 139.51,40.2 142.35,40.2 143.75,38.8 144.55,38.8 148.69,42.94 152.22,42.94 154.47,40.68 154.47,37.26 154.91,36.81 163.11,36.81 164.58,35.35 164.95,35.35 167.15,33.14 167.15,32.51 168.86,30.8 174.49,30.8 176.45,28.84 176.45,28.58 176.57,28.46 176.83,28.46 177.2,28.08 177.2,27.41 178.77,25.84 178.77,24.62 177,22.86 177,19.11 v1(176.69,18.8)
DDR4_DIMM_CH3_DQS_P2: length 90.9
  L05_SIG2 w0.079: v1(106.25,49.43) 106.25,49.71 106.35,49.81 106.46,49.81 106.54,49.73 106.63,49.52 106.63,49.34 106.57,49.22 106.41,49.05 106.17,49.05 105.92,48.95 105.74,48.77 105.65,48.56 105.65,48.3 105.76,48.03 105.76,47.86 105.65,47.58 105.65,47.31 105.77,47.02 105.77,46.86 105.65,46.58 105.65,46.3 105.76,46.03 105.76,45.84 105.65,45.58 105.65,45.29 105.76,45.02 105.76,44.83 105.65,44.57 105.65,44.3 105.77,44.01 105.77,43.86 105.64,43.54 105.64,43.31 105.76,43.01 105.76,42.83 105.65,42.56 105.65,42.29 105.76,42.02 105.76,41.85 105.65,41.56 105.65,41.25 105.72,41.09 105.91,40.89 106.12,40.81 106.46,40.81 106.66,40.6 106.66,39.9 107.74,38.82 108.4,38.82 109.42,37.8 109.87,37.8 112.86,34.81 113.45,34.81 114.08,34.18 114.71,34.18 117.07,31.81 122.56,31.81 122.88,32.13 125.67,32.13 127.04,30.76 130.23,30.76 131.19,29.79 137.79,29.79 138.66,28.93 141.91,28.93 143.05,27.79 146.64,27.79 146.95,27.48 163.69,27.48 164.24,26.93 165.7,26.93 166,26.64 166.9,26.64 167.06,26.8 168.35,26.8 169.66,25.49 169.66,24.86 170.42,24.11 170.42,22.31 170.06,21.95 167.97,21.95 167.65,21.64 167.65,19.1 v1(167.34,18.8)
DDR4_DIMM_CH3_DQS_P3: length 73
  L07_SIG3 w0.085: v1(157.99,18.8) 158.38,19.18 158.38,20.32 158.61,20.56 160.43,20.56 160.53,20.66 160.53,21.09 160.43,21.19 158.57,21.19 158.31,21.45 158.31,22.02 158.57,22.28 160.54,22.28 160.66,22.41 160.66,22.84 160.54,22.97 159.56,22.97 159.32,23.2 159.32,23.82 160.33,24.83 160.33,25.34 160.95,25.95 160.95,26.62 157.92,29.65 144.57,29.65 142.43,31.79 137.4,31.79 135.58,33.62 132.91,33.62 131.93,34.6 130.14,34.6 128.92,35.82 128.24,35.82 127.25,36.81 126.47,36.81 125.48,37.8 114.49,37.8 113.66,38.64 113.66,39.49 113.33,39.82 112.94,39.82 112.58,40.18 112.58,41.57 112.69,41.84 112.69,42.04 112.65,42.14 112.52,42.26 112.42,42.26 112.32,42.16 v1(112.32,41.93)
DDR4_DIMM_CH3_DQS_P4: length 39.6
  L05_SIG2 w0.079: v1(100.19,46.93) 100.12,47.1 100.1,47.16 100.11,47.23 100.14,47.27 100.28,47.31 100.38,47.27 100.52,47.13 100.56,47.01 100.56,46.83 100.46,46.57 100.46,46.3 100.57,46.03 100.57,45.83 100.46,45.56 100.46,45.28 100.57,45.01 100.57,44.84 100.44,44.52 100.44,44.32 100.57,44.01 100.57,43.83 100.45,43.55 100.45,43.29 100.56,43.02 100.56,42.83 100.45,42.57 100.45,42.29 100.57,42.02 100.57,41.84 100.5,41.69 99.74,40.93 99.74,36.88 102.95,33.68 102.95,32.17 103.35,31.77 104.43,31.77 105.48,30.73 105.48,26.8 105.69,26.59 105.69,26.27 104.86,25.44 104.86,24.33 104.68,24.16 104.68,19.75 104.56,19.62 104.22,19.62 104.1,19.75 104.1,21.87 103.84,22.13 103.31,22.13 103.05,21.87 103.05,19.11 v1(102.74,18.8)
DDR4_DIMM_CH3_DQS_P5: length 40.4
  L14_SIG5 w0.079: v1(100.19,48.93) 100.19,49.22 100.28,49.31 100.39,49.31 100.48,49.23 100.57,48.99 100.57,48.85 100.51,48.71 100.35,48.54 99.96,48.54 99.67,48.25 99.59,48.05 99.59,47.8 99.7,47.53 99.7,47.33 99.66,47.23 99.54,47.11 99.38,47.04 99.29,47.04 arc(99.09,47) 98.93,46.89 98.67,46.61 arc(98.6,46.56) 98.51,46.54 98.42,46.54 arc(98.23,46.5) 98.06,46.39 97.81,46.11 arc(97.73,46.06) 97.64,46.04 97.59,46.04 97.39,46 97.26,45.95 97.08,45.77 96.99,45.56 96.99,45.28 97.11,45.01 97.11,44.85 97.05,44.72 96.93,44.6 96.78,44.54 96.61,44.54 96.39,44.45 96.21,44.27 96.12,44.06 96.12,43.8 96.24,43.52 96.24,43.35 96.12,43.07 96.12,42.78 96.23,42.51 96.23,42.35 96.12,42.07 96.12,41.82 96.28,41.43 97.11,40.6 97.11,39.1 96.88,38.87 96.88,33.55 97.18,33.25 97.18,31.71 96.98,31.51 96.98,28.15 96.09,27.26 96.09,26.82 96.34,26.57 96.34,26.13 95.78,25.58 95.78,24.89 93.89,22.99 93.89,21.15 94.14,20.89 95.93,20.89 96.12,20.7 96.12,20.39 95.93,20.2 94.12,20.2 93.71,19.79 93.71,19.07 v1(93.44,18.8)
DDR4_DIMM_CH3_DQS_P6: length 58.6
  L05_SIG2 w0.079: v1(94.13,46.43) 94.13,46.71 94.21,46.79 94.35,46.79 94.42,46.73 94.5,46.53 94.5,46.34 94.45,46.22 94.34,46.11 94.18,46.04 94.1,46.04 arc(93.89,46) 93.72,45.88 93.5,45.64 arc(93.4,45.57) 93.28,45.54 93.23,45.54 arc(93.03,45.5) 92.86,45.38 92.63,45.13 arc(92.54,45.07) 92.43,45.04 92.37,45.04 arc(92.16,45) 91.99,44.87 91.77,44.64 arc(91.67,44.57) 91.55,44.54 91.53,44.54 arc(91.39,44.57) 91.28,44.65 91.06,44.89 arc(90.9,45) 90.71,45.04 90.65,45.04 arc(90.52,45.07) 90.41,45.15 90.16,45.42 arc(90.03,45.51) 89.87,45.54 89.07,45.54 88.2,44.67 88.06,44.67 87.91,44.52 87.91,44.38 86.84,43.31 86.84,32.91 85.88,31.95 85.88,27.73 87.05,26.56 87.05,25.48 85.01,23.43 85.01,23.1 85.33,22.78 87.5,22.78 87.6,22.68 87.6,21.96 87.5,21.86 84.68,21.86 84.43,22.1 84.43,22.81 84.2,23.04 83.62,23.04 83.39,22.81 83.39,21.91 83.21,21.74 81.42,21.74 81.14,21.46 81.14,20.97 81.42,20.69 82.65,20.69 82.79,20.56 82.79,19.75 83.12,19.42 83.52,19.42 83.86,19.75 83.86,20.49 84.14,20.77 87.51,20.77 87.61,20.67 87.61,20.29 87.51,20.18 85.1,20.18 84.35,19.43 84.35,19.11 v1(84.04,18.8)
DDR4_DIMM_CH3_DQS_P7: length 52.6
  L07_SIG3 w0.085: v1(94.13,49.43) 94.15,49.65 94.26,49.72 94.4,49.7 94.44,49.65 94.5,49.51 94.5,49.37 arc(94.43,49.16) 94.23,49.06 93.99,49.02 arc(93.78,48.94) 93.62,48.78 93.58,48.7 arc(93.46,48.58) 93.31,48.54 93.23,48.54 arc(93,48.49) 92.82,48.34 92.67,48.15 arc(92.57,48.07) 92.44,48.04 92.36,48.04 arc(92.14,47.99) 91.96,47.85 91.8,47.65 arc(91.7,47.57) 91.58,47.54 91.49,47.54 arc(91.37,47.57) 91.27,47.65 91.12,47.84 arc(90.94,47.99) 90.71,48.04 90.63,48.04 arc(90.4,47.99) 90.22,47.85 90.07,47.65 arc(89.97,47.57) 89.85,47.54 89.45,47.54 88.99,47.09 88.63,47.09 88.42,46.88 88.18,46.88 87.97,46.67 87.97,46.43 87.04,45.5 87.04,40.09 85.92,38.97 85.92,36.83 84.04,34.95 79.32,34.95 79.02,34.65 79.02,33.66 79.32,33.36 80.04,33.36 80.29,33.11 80.29,32.13 79.9,31.74 79.9,29.98 76.58,26.67 76.58,25.98 76.81,25.74 76.81,24.67 76.62,24.47 76.62,23.96 76.45,23.8 75.32,23.8 75.08,23.56 75.08,22.87 75.32,22.63 76.42,22.63 76.52,22.53 76.52,22.08 76.42,21.98 75.13,21.98 74.9,21.75 74.9,21.15 75.13,20.92 76.45,20.92 76.56,20.82 76.56,20.26 76.45,20.15 75.57,20.15 75.02,19.6 75.02,19.12 v1(74.69,18.8)
DDR4_DIMM_CH3_DQS_P8: length 84.1
  L14_SIG5 w0.081: v1(106.25,46.43) 106.25,46.72 106.33,46.8 106.45,46.8 106.54,46.71 106.63,46.51 106.63,46.33 106.51,46.06 106.51,45.82 106.63,45.54 106.63,45.33 106.52,45.06 106.52,44.8 106.63,44.53 106.63,44.35 106.51,44.07 106.51,43.8 106.64,43.5 106.64,43.36 106.51,43.04 106.51,42.82 106.63,42.52 106.63,42.33 106.52,42.06 106.52,41.78 106.6,41.57 107.24,40.94 107.24,32.14 107.39,31.99 107.39,28.47 107.24,28.31 107.24,26.9 108.49,25.65 108.49,24.54 109.07,23.97 109.07,23.55 108.68,23.16 108.68,22.49 108.98,22.19 110.28,22.19 111.29,21.18 113.02,21.18 114.01,20.19 122.64,20.19 123.12,19.71 124.58,19.71 127.41,22.53 129.65,22.53 130.29,23.17 143.86,23.17 144.54,23.85 144.54,24.09 145.75,25.3 146.08,25.52 147.86,26.26 148.4,26.79 149.73,26.79 151.03,25.5 151.03,24.85 152.09,23.79 152.09,22.37 151.94,22.22 151.66,22.22 151.5,22.37 151.5,22.75 151.27,22.99 150.7,22.99 150.46,22.75 150.46,21.02 150.3,20.86 150.04,20.86 149.9,20.72 149.9,20.46 148.95,19.51 148.95,19.05 v1(148.69,18.8)
DDR4_DIMM_CH3_ODT0: length 85
  L07_SIG3 w0.089: v1(100.19,41.93) 100.47,41.93 100.62,41.77 100.62,41.24 100.83,41.04 100.83,40.8 100.62,40.59 100.62,40.32 100.83,40.11 100.83,39.75 100.62,39.55 100.62,39.29 100.83,39.08 100.83,38.76 100.62,38.55 100.62,38.27 100.83,38.06 100.83,37.75 100.62,37.54 100.62,36.01 100.52,35.91 100.38,35.91 100.28,36.01 100.28,38.31 100.18,38.41 100.01,38.41 99.67,38.07 99.67,37.84 99.94,37.58 99.94,37.38 99.57,37.02 99.57,36.87 99.94,36.51 99.94,36.01 99.84,35.91 99.7,35.91 99.6,36.01 99.6,36.31 99.49,36.41 99.35,36.41 99.25,36.31 99.25,36 99.08,35.83 98.76,35.83 98.66,35.73 98.66,35.46 98.51,35.31 98.14,35.31 98.05,35.22 98.05,35.06 98.14,34.97 98.82,34.97 98.91,34.88 98.91,34.72 98.82,34.63 98.06,34.63 97.97,34.54 97.97,34.37 98.06,34.28 98.67,34.28 98.76,34.19 98.76,34.03 98.67,33.94 97.31,33.94 97.22,33.85 97.22,33.69 97.31,33.6 98.49,33.6 98.58,33.51 98.58,33.34 98.49,33.25 96.62,33.25 96.53,33.17 96.53,33 96.62,32.91 97.89,32.91 98.01,32.79 98.37,32.79 98.49,32.91 98.73,32.91 98.9,32.74 98.9,32.25 98.99,32.16 99.7,32.16 99.79,32.07 99.79,31.89 99.7,31.81 98.84,31.81 98.74,31.71 98.74,31.02 98.64,30.92 98.5,30.92 98.4,31.02 98.4,31.99 98.3,32.09 98.15,32.09 98.05,31.99 98.05,31.45 97.95,31.35 97.81,31.35 97.71,31.45 97.71,32.45 97.61,32.55 97.33,32.55 97.24,32.46 97.24,31.66 97.14,31.56 96.94,31.56 96.83,31.67 96.83,31.89 96.73,31.99 96.51,31.99 96.41,31.89 96.41,31.31 96.5,31.22 97.16,31.22 97.25,31.13 97.25,30.96 97.16,30.87 96.31,30.87 96.22,30.79 96.22,30.62 96.31,30.53 98.92,30.53 99.23,30.85 99.41,30.85 99.51,30.75 99.51,30.28 99.42,30.19 96.5,30.19 96.41,30.1 96.41,29.94 96.5,29.85 99.41,29.85 99.5,29.76 99.5,29.59 99.41,29.5 96.31,29.5 96.22,29.41 96.22,29.25 96.31,29.16 99.38,29.16 99.47,29.07 99.47,28.91 99.38,28.82 96.34,28.82 96.25,28.73 96.25,28.56 96.34,28.47 97.89,28.47 98.08,28.29 98.42,28.29 98.61,28.47 99.44,28.47 99.63,28.29 99.93,28.29 100.12,28.47 101.17,28.47 101.37,28.28 101.68,28.28 101.88,28.47 102.75,28.47 103,28.22 103.28,28.22 103.53,28.47 104.94,28.47 105.56,27.85 111.49,27.85 112.41,26.94 113.56,26.94 113.85,26.65 114.64,26.65 114.72,26.57 114.72,26.43 114.46,26.17 114.46,26.02 114.56,25.92 114.7,25.92 114.96,26.18 115.1,26.18 115.45,25.84 115.45,25.4 115.27,25.22 115.06,25.22 v1(114.64,24.79)
DDR4_DIMM_CH3_ODT1: length 85.2
  L07_SIG3 w0.089: v1(111.24,24.8) 110.7,24.8 109.88,23.97 109.88,23.78 110.2,23.45 110.2,23.31 110.07,23.18 109.93,23.18 109.38,23.72 109.15,23.72 108.67,23.24 108.35,23.24 108.21,23.38 108.21,23.8 108.11,23.9 107.96,23.9 107.86,23.8 107.86,23.1 107.76,22.99 107.62,22.99 107.52,23.1 107.52,24.44 107.42,24.54 107.28,24.54 107.18,24.44 107.18,22.87 107.08,22.77 106.94,22.77 106.84,22.87 106.84,24.41 106.73,24.51 106.59,24.51 106.49,24.41 106.49,22.89 106.39,22.79 106.25,22.79 106.15,22.89 106.15,24.05 106.05,24.15 105.91,24.15 105.81,24.05 105.81,22.99 105.71,22.89 105.07,22.89 104.9,23.06 104.9,23.88 104.8,23.98 104.55,23.98 104.45,23.88 104.45,22.96 104.35,22.86 104.21,22.86 104.11,22.96 104.11,23.83 104.01,23.93 103.86,23.93 103.76,23.83 103.76,23.14 103.66,23.04 103.52,23.04 103.42,23.14 103.42,23.83 103.32,23.93 103.18,23.93 103.08,23.83 103.08,23.14 102.98,23.04 102.83,23.04 102.73,23.14 102.73,23.83 102.63,23.93 102.47,23.93 102.37,23.83 102.37,23.13 102.27,23.03 102.13,23.03 102.02,23.13 102.02,24.1 101.92,24.2 101.78,24.2 101.68,24.1 101.68,23.13 101.58,23.03 101.44,23.03 101.34,23.13 101.34,23.83 101.24,23.93 101.1,23.93 101,23.83 101,23.13 100.9,23.03 100.75,23.03 100.65,23.13 100.65,23.83 100.55,23.93 100.41,23.93 100.31,23.83 100.31,23.13 100.21,23.03 100.07,23.03 99.97,23.13 99.97,23.83 99.87,23.93 99.72,23.93 99.62,23.83 99.62,23.13 99.52,23.03 99.38,23.03 99.28,23.13 99.28,23.83 99.18,23.93 99.04,23.93 98.94,23.83 98.94,23.13 98.84,23.03 98.7,23.03 98.6,23.13 98.6,24.07 98.5,24.17 98.35,24.17 98.25,24.07 98.25,23.13 98.15,23.03 98.01,23.03 97.91,23.13 97.91,23.95 97.81,24.05 97.67,24.05 97.57,23.95 97.57,23.29 97.47,23.19 97.32,23.19 97.22,23.29 97.22,24.05 97.12,24.15 96.98,24.15 96.88,24.05 96.88,23.72 96.78,23.62 96.64,23.62 96.54,23.72 96.54,24.2 96.13,24.61 96.13,24.85 96.03,24.96 95.64,24.96 95.54,24.85 95.54,23.68 95.44,23.58 95.3,23.58 95.19,23.68 95.19,24.31 95.09,24.41 94.95,24.41 94.85,24.31 94.85,23.69 94.75,23.59 93.88,23.59 93.78,23.69 93.78,24.12 93.88,24.22 94.22,24.22 94.68,24.69 94.68,25.05 94.96,25.33 94.96,25.5 94.84,25.62 94.53,25.62 94.41,25.5 94.41,25.28 94.31,25.18 94.15,25.18 94.05,25.28 94.05,25.62 93.95,25.72 93.79,25.72 93.68,25.62 93.68,24.58 93.58,24.48 93.42,24.48 93.32,24.58 93.32,25.8 93.78,26.26 93.78,31.59 93.52,31.84 93.52,32.71 94.31,33.49 94.31,33.95 95,34.64 95,35.9 96.13,37.04 96.13,38.43 96.23,38.53 96.37,38.53 96.48,38.43 96.48,37.55 96.58,37.44 96.72,37.44 96.82,37.55 96.82,38.88 97.45,39.52 97.45,40.87 97.21,41.12 97.21,41.5 97.26,41.63 97.45,41.81 97.84,41.81 98.11,42.08 98.2,42.31 98.2,42.56 98.08,42.84 98.08,43.08 98.3,43.3 98.61,43.3 99.11,42.81 100.07,42.81 v1(100.19,42.93)
DDR4_DIMM_CH3_PAR: length 82.4
  L07_SIG3 w0.089: v1(122.29,18.8) J4.222 121.6,20.19 120.46,20.19 120.36,20.29 120.36,20.51 120.46,20.61 120.95,20.61 121.05,20.72 121.05,20.93 120.95,21.03 120.33,21.03 119.74,21.62 112.83,21.62 112.14,22.31 109.19,22.31 108.99,22.51 108.39,22.51 107.95,22.07 103.43,22.07 103.24,22.25 97.17,22.25 96.54,22.88 93.48,22.88 92.16,24.21 92.16,25.12 92.26,25.22 92.49,25.22 92.59,25.32 92.59,25.46 92.49,25.56 91.71,25.56 91.61,25.66 91.61,25.8 91.71,25.9 92.49,25.9 92.59,26 92.59,26.15 92.49,26.25 92.26,26.25 92.16,26.35 92.16,27.88 92.26,27.98 92.51,27.98 92.61,27.88 92.61,27.55 92.71,27.45 92.88,27.45 92.98,27.55 92.98,28.25 92.88,28.36 92.27,28.36 92.17,28.46 92.17,28.6 92.27,28.7 92.9,28.7 93,28.8 93,28.94 92.9,29.04 92.25,29.04 92.15,29.14 92.15,29.28 92.25,29.38 92.9,29.38 93,29.48 93,29.63 92.9,29.73 92.27,29.73 92.17,29.83 92.17,29.97 92.27,30.07 92.9,30.07 93,30.17 93,30.31 92.9,30.41 92.27,30.41 92.17,30.51 92.17,30.66 92.27,30.76 92.55,30.76 92.65,30.86 92.65,31 92.55,31.1 92.18,31.1 92.09,31.19 92.09,31.34 92.2,31.44 92.55,31.44 92.65,31.54 92.65,31.72 92.17,32.21 92.17,32.57 92.36,32.77 92.36,35.7 92.46,35.8 92.61,35.8 92.71,35.7 92.71,33.32 92.81,33.22 92.95,33.22 93.05,33.32 93.05,33.55 93.15,33.65 93.42,33.65 93.52,33.75 93.52,33.9 93.42,34 93.15,34 93.05,34.1 93.05,36.24 93.15,36.34 93.29,36.34 93.39,36.24 93.39,34.47 93.49,34.37 93.63,34.37 93.74,34.47 93.74,35.59 93.94,35.8 93.94,36.07 93.74,36.28 93.74,36.56 93.97,36.8 94.57,36.8 94.7,36.93 94.7,37.61 94.57,37.73 94.37,37.73 94.26,37.85 94.26,37.99 94.37,38.1 94.56,38.1 94.7,38.24 94.7,38.96 94.8,39.06 94.96,39.06 95.06,38.96 95.06,37.38 95.17,37.28 95.35,37.28 95.45,37.38 95.45,39 95.57,39.13 95.83,39.13 95.89,39.19 95.89,39.39 95.82,39.46 95.57,39.46 95.45,39.59 95.45,39.79 95.79,40.13 95.95,40.13 96.07,40.01 96.21,40.01 96.31,40.11 96.31,40.64 96.53,40.86 96.53,41.43 96.35,41.85 96.35,42.02 96.4,42.15 96.68,42.43 v1(97.59,42.43)
DDR4_DIMM_CH3_RESET_N: length 88.4
  L07_SIG3 w0.089: v1(101.92,42.93) 102.32,42.53 102.32,41.23 102.7,40.86 102.7,40.09 103.2,39.58 103.2,36.25 102.64,35.7 102.64,33.98 103.99,32.64 103.99,32.34 104.86,31.47 105.48,31.47 106.04,32.02 106.26,32.02 106.68,32.44 107.31,32.44 107.73,32.02 108.63,32.02 109.07,31.58 109.07,31.26 109.17,31.15 109.76,31.15 109.98,30.94 111.47,30.94 111.86,30.55 112.17,30.55 113.05,29.67 116.62,29.67 117.41,28.88 117.41,27.21 118.27,26.35 119.09,26.35 119.57,26.83 122.43,26.83 122.89,26.37 126.67,26.37 127.17,26.88 128.31,26.88 128.81,26.37 129.37,26.37 129.79,26.79 130.1,26.79 130.32,26.57 130.32,26.32 131.54,25.09 131.54,24.44 132.35,23.63 133.86,23.63 134.08,23.41 137.09,23.41 137.71,24.04 138.48,24.04 139.11,23.41 139.57,23.41 139.93,23.78 139.93,24.02 140.53,24.61 140.53,24.92 140.81,25.2 143.03,25.2 144.53,23.7 146.2,23.7 147.23,22.67 147.23,21.41 147.03,21.22 144.9,21.22 144.8,21.11 144.8,20.36 144.9,20.26 147.52,20.26 147.62,20.36 147.62,23.39 147.73,23.49 147.93,23.49 148.03,23.39 148.03,20.39 148.14,20.29 148.34,20.29 148.44,20.39 148.44,23.63 147.72,24.35 145.88,24.35 145.67,24.56 144.63,24.56 v1(144.39,24.8)
  BOTTOM w0.149: v1(144.39,24.8) 144.4,24.79 R75.1
DDR4_DIMM_CH3_RZQ: length 1.6
  BOTTOM w0.149: v1(95,41.93) 95,40.51 R84.1
DDR4_DIMM_CH3_SA0:
  vias: v1(70.44,23.71)
DDR4_DIMM_CH3_SA1:
  vias: v1(69.59,24.79)
DDR4_DIMM_CH3_SA2: length 0.8
  BOTTOM w0.149: R74.2 v1(108.69,18.8)
DDR4_DIMM_CH3_TDQS_N9: length 93.1
  L05_SIG2 w0.079: v1(111.45,47.43) 111.45,47.18 111.59,47.04 111.75,47.04 111.94,46.85 112.05,46.58 112.05,46.31 111.94,46.05 111.94,45.83 112.05,45.56 112.05,45.3 111.94,45.04 111.94,44.87 arc(111.96,44.77) 112.02,44.69 112.07,44.63 arc(112.17,44.57) 112.29,44.54 112.34,44.54 arc(112.55,44.5) 112.72,44.38 112.94,44.14 arc(113.04,44.07) 113.16,44.04 113.21,44.04 arc(113.41,44) 113.58,43.88 113.8,43.64 arc(113.91,43.57) 114.03,43.54 114.08,43.54 arc(114.28,43.5) 114.45,43.38 114.67,43.14 arc(114.77,43.07) 114.9,43.04 114.94,43.04 arc(115.15,43) 115.32,42.88 115.54,42.64 arc(115.64,42.57) 115.76,42.54 115.81,42.54 arc(116.01,42.5) 116.18,42.38 116.4,42.14 arc(116.51,42.07) 116.63,42.04 116.67,42.04 arc(116.88,42) 117.05,41.88 117.27,41.64 arc(117.37,41.57) 117.49,41.54 117.54,41.54 arc(117.74,41.5) 117.91,41.38 118.13,41.14 arc(118.24,41.07) 118.36,41.04 118.41,41.04 arc(118.61,41) 118.78,40.88 118.94,40.7 119.95,40.03 120.36,40.03 120.51,40.18 120.72,40.18 120.87,40.03 127.66,40.03 131.04,38.91 131.75,38.21 132.18,38.03 134.21,38.03 135.23,37.19 135.49,37.08 135.82,37.03 137.76,36.44 138.87,35.98 141.36,35.98 145.04,34.46 147.09,33.73 147.73,33.53 150.08,33.06 166.9,33.06 167.92,32.04 172.79,32.04 173.06,31.78 173.06,30.86 173.18,30.74 173.52,30.74 173.64,30.86 173.64,31.78 173.9,32.04 174.43,32.04 174.69,31.78 174.69,30.44 174.81,30.31 175.15,30.31 175.27,30.44 175.27,31.75 175.53,32.01 176.06,32.01 176.32,31.75 176.32,30.14 176.49,29.96 179.15,29.96 180.21,28.9 181.68,28.9 183.04,27.54 184.11,27.54 184.91,26.74 185.12,26.23 185.25,26.17 185.33,26.21 185.46,26.16 185.51,26.03 185.46,25.9 185.38,25.87 185.32,25.74 185.44,25.47 185.9,25 186.04,25 186.13,25.1 186.27,25.1 186.37,25 186.37,24.86 186.28,24.77 186.28,24.63 186.79,24.11 187.1,24.11 187.2,24.21 187.2,24.36 v1(186.89,24.67)
DDR4_DIMM_CH3_TDQS_N10: length 90.5
  L07_SIG3 w0.085: v1(177.59,24.8) 177.85,25.06 177.85,25.4 177.56,25.69 176.55,25.69 176.08,26.16 176.08,26.79 176.25,26.96 176.25,27.48 175.7,28.03 171.07,28.03 170.81,28.29 170.81,28.94 171.07,29.2 174,29.2 174.13,29.33 174.13,29.79 174,29.91 167.98,29.91 163.69,34.21 163.69,34.95 162.81,35.82 153.74,35.82 152.89,34.97 148.72,34.97 146.34,37.35 146.34,37.56 146.09,37.82 143.49,37.82 142.5,38.81 138.83,38.81 137.54,40.1 137.54,40.45 136.67,41.31 136.52,41.31 arc(136.29,41.37) 136.11,41.51 135.96,41.71 arc(135.86,41.79) 135.73,41.81 135.65,41.81 arc(135.52,41.79) 135.42,41.7 135.27,41.51 arc(135.09,41.37) 134.87,41.31 134.78,41.31 arc(134.56,41.37) 134.38,41.51 134.23,41.71 arc(134.13,41.79) 134,41.81 133.92,41.81 arc(133.69,41.87) 133.51,42.01 133.36,42.21 arc(133.26,42.29) 133.14,42.31 133.05,42.31 arc(132.83,42.37) 132.65,42.51 132.49,42.71 arc(132.39,42.79) 132.27,42.81 132.19,42.81 arc(131.96,42.87) 131.78,43.01 131.63,43.21 arc(131.53,43.29) 131.4,43.31 131.32,43.31 arc(131.09,43.37) 130.91,43.51 130.76,43.71 arc(130.66,43.79) 130.54,43.81 130.45,43.81 arc(130.23,43.87) 130.05,44.01 129.9,44.2 arc(129.8,44.29) 129.67,44.31 129.59,44.31 arc(129.36,44.37) 129.18,44.51 129.03,44.7 arc(128.93,44.79) 128.81,44.81 128.72,44.81 arc(128.5,44.87) 128.32,45.01 128.16,45.2 arc(128.06,45.29) 127.94,45.31 127.86,45.31 arc(127.63,45.37) 127.45,45.51 127.3,45.7 arc(127.2,45.79) 127.07,45.81 126.99,45.81 arc(126.76,45.87) 126.58,46.01 126.43,46.2 arc(126.33,46.28) 126.21,46.31 125.66,46.31 125.15,46.81 123.53,46.81 arc(123.3,46.87) 123.12,47.01 122.97,47.2 arc(122.87,47.29) 122.74,47.31 122.66,47.31 arc(122.53,47.29) 122.43,47.2 122.28,47.01 arc(122.1,46.87) 121.88,46.81 121.79,46.81 arc(121.57,46.87) 121.39,47.01 121.24,47.2 arc(121.14,47.29) 121.01,47.31 120.93,47.31 arc(120.8,47.29) 120.7,47.2 120.55,47.01 arc(120.37,46.87) 120.15,46.81 120.06,46.81 arc(119.84,46.87) 119.66,47.01 119.5,47.2 arc(119.4,47.29) 119.28,47.31 119.2,47.31 arc(119.07,47.29) 118.97,47.2 118.82,47.01 arc(118.64,46.87) 118.41,46.81 116.6,46.81 arc(116.37,46.87) 116.19,47.01 116.04,47.2 arc(115.94,47.29) 115.82,47.31 115.73,47.31 arc(115.61,47.29) 115.51,47.2 115.35,47.01 arc(115.17,46.87) 114.95,46.81 114.87,46.81 arc(114.64,46.87) 114.46,47.01 114.31,47.2 arc(114.21,47.29) 114.08,47.31 114,47.31 arc(113.77,47.37) 113.59,47.51 113.44,47.7 arc(113.34,47.79) 113.22,47.81 113.13,47.81 arc(112.91,47.87) 112.73,48.01 112.58,48.2 arc(112.48,48.29) 112.35,48.31 112.27,48.31 arc(112.04,48.37) 111.86,48.51 111.71,48.7 arc(111.61,48.78) 111.49,48.81 111.33,48.81 111.12,48.9 110.94,49.08 110.85,49.3 110.85,49.58 110.96,49.86 111.15,50.04 111.35,50.04 111.45,50.14 v1(111.45,50.43)
DDR4_DIMM_CH3_TDQS_N11: length 91.3
  L05_SIG2 w0.079: v1(168.19,24.8) 168.5,25.1 168.5,25.45 168.13,25.81 146.46,25.81 145.46,26.81 142.45,26.81 141.46,27.8 138.17,27.8 137.07,28.9 130.89,28.9 129.89,29.9 129.69,29.9 129.56,29.78 129.56,28.24 129.3,27.98 128.78,27.98 128.52,28.24 128.52,29.78 128.39,29.9 128.06,29.9 127.93,29.78 127.93,28.24 127.67,27.98 127.15,27.98 126.89,28.24 126.89,29.78 126.76,29.9 126.43,29.9 126.3,29.78 126.3,28.58 126.04,28.32 125.52,28.32 125.26,28.58 125.26,30.66 124.69,31.23 123.28,31.23 122.83,30.79 116.11,30.79 113.22,33.68 112.28,33.68 108.15,37.81 107.53,37.81 106.54,38.8 106.02,38.8 105.64,39.19 105.64,39.71 104.92,40.43 104.92,41.45 104.79,41.78 104.79,42.07 104.9,42.33 104.9,42.52 104.78,42.8 104.78,43.06 104.9,43.34 104.9,43.52 104.78,43.81 104.78,44.06 104.9,44.36 104.9,44.53 104.78,44.81 104.78,45.06 104.89,45.33 104.89,45.54 104.78,45.81 104.78,46.08 104.89,46.35 104.89,46.5 104.77,46.8 104.77,47.04 104.9,47.36 104.9,47.53 104.78,47.81 104.78,48.07 104.89,48.33 104.89,48.52 104.78,48.79 104.78,49.08 104.86,49.25 105.08,49.53 v1(105.39,49.93)
DDR4_DIMM_CH3_TDQS_N12: length 71.7
  L07_SIG3 w0.085: v1(158.89,24.8) 159.19,25.1 159.19,26.61 157,28.8 156.85,28.8 156.72,28.67 156.72,27.88 156.46,27.62 155.92,27.62 155.66,27.88 155.66,28.67 155.53,28.8 155.19,28.8 155.06,28.67 155.06,27.65 154.8,27.39 154.27,27.39 154.01,27.65 154.01,28.67 153.88,28.8 153.54,28.8 153.41,28.67 153.41,27.66 153.15,27.4 152.61,27.4 152.35,27.66 152.35,28.67 152.23,28.8 151.88,28.8 151.75,28.67 151.75,27.74 151.49,27.48 150.96,27.48 150.7,27.74 150.7,28.67 150.57,28.8 150.23,28.8 150.1,28.67 150.1,27.74 149.84,27.48 149.26,27.48 149,27.74 149,28.67 148.87,28.8 148.46,28.8 148.33,28.67 148.33,27.77 148.07,27.51 147.49,27.51 147.23,27.77 147.23,28.67 147.11,28.8 143.99,28.8 141.99,30.8 136.51,30.8 134.69,32.61 132.35,32.61 131.21,33.75 129.75,33.75 128.73,34.77 126.84,34.77 126.43,35.18 126.43,35.68 125.41,36.7 122.45,36.7 122.34,36.81 114.22,36.81 112.68,38.35 112.68,38.66 111.75,39.59 111.75,40.2 110.97,40.98 110.84,41.3 110.84,41.59 110.9,41.72 111,41.87 111.23,42.11 v1(111.45,42.43)
DDR4_DIMM_CH3_TDQS_N13: length 37.9
  L05_SIG2 w0.079: v1(103.59,24.8) 103.9,25.11 103.9,25.91 104.03,26.04 104.03,26.52 103.66,26.89 102.24,26.89 102,27.13 102,27.7 102.24,27.93 104.49,27.93 104.6,28.04 104.6,28.42 104.49,28.52 101.43,28.52 101.19,28.76 101.19,29.49 101.43,29.73 104.55,29.73 104.65,29.83 104.65,30.32 104.55,30.42 101.9,30.42 101.36,30.96 101.36,32.05 100.4,33.02 100.4,35.05 98.63,36.81 98.63,40.91 98.72,40.99 98.72,41.57 98.84,41.86 98.84,42 98.71,42.3 98.71,42.55 98.84,42.86 98.84,43 98.72,43.29 98.72,43.56 98.83,43.83 98.83,44.03 98.72,44.31 98.72,44.54 98.83,44.82 98.83,45.03 98.72,45.3 98.72,45.56 98.83,45.83 98.83,46.05 98.72,46.31 98.72,46.58 98.83,46.85 99.09,47.11 v1(99.32,47.43)
DDR4_DIMM_CH3_TDQS_N14: length 40.6
  L14_SIG5 w0.079: v1(99.32,50.43) 99.32,50.14 99.19,50.01 99,50.01 98.83,49.83 98.72,49.57 98.72,49.3 98.83,49.03 98.83,48.82 98.72,48.55 98.72,48.31 98.83,48.04 98.83,47.84 98.77,47.69 98.69,47.61 98.53,47.54 98.42,47.54 arc(98.23,47.5) 98.06,47.39 97.81,47.11 arc(97.73,47.06) 97.64,47.04 97.56,47.04 arc(97.36,47) 97.2,46.89 96.94,46.61 arc(96.87,46.56) 96.78,46.54 96.7,46.54 96.54,46.51 96.38,46.45 96.22,46.28 96.12,46.05 96.12,45.79 96.24,45.51 96.24,45.37 96.18,45.22 96.05,45.09 95.93,45.04 95.74,45.04 95.49,44.94 95.37,44.82 95.26,44.56 95.26,44.3 95.38,44.02 95.38,43.86 95.25,43.57 95.25,43.32 95.37,43.05 95.37,42.81 95.24,42.52 95.24,42.32 95.37,42.02 95.37,41.82 95.26,41.55 95.26,41.26 95.75,40.06 95.75,36.23 95.29,35.77 95.29,33.66 96.14,32.8 96.14,32.44 95.71,32.01 94.07,32.01 93.83,31.77 93.83,30.92 94.07,30.69 96.03,30.69 96.13,30.59 96.13,30.07 96.03,29.97 93.83,29.97 93.59,29.73 93.59,29.09 93.83,28.86 95.83,28.86 95.94,28.75 95.94,28.28 95.83,28.17 93.9,28.17 93.66,27.94 93.66,27.17 93.9,26.93 94.29,26.93 94.75,26.47 94.75,26.19 94.59,26.03 94.59,25.14 v1(94.24,24.8)
DDR4_DIMM_CH3_TDQS_N15: length 58.7
  L05_SIG2 w0.079: v1(84.89,24.8) 85.15,25.05 85.15,25.86 85.47,26.19 85.47,26.38 84.23,27.62 84.23,28.83 85.01,29.61 85.01,31.36 83.55,32.82 81.21,32.82 80.85,33.18 80.85,34.9 81.08,35.13 81.65,35.13 81.89,34.9 81.89,33.99 81.99,33.88 82.37,33.88 82.48,33.99 82.48,35.02 82.71,35.25 83.34,35.25 83.58,35.02 83.58,34.01 83.68,33.91 84.18,33.91 84.28,34.01 84.28,35.91 84.58,36.21 85.16,36.21 85.39,35.98 85.39,33.25 85.49,33.14 85.88,33.14 85.98,33.25 85.98,40.86 82.94,43.89 82.94,44.22 83.35,44.63 83.68,44.63 85.57,42.74 85.71,42.74 85.98,43.01 85.98,43.16 85.17,43.97 85.17,44.31 85.57,44.71 85.91,44.71 86.37,44.24 86.52,44.24 86.79,44.52 86.79,44.66 86.19,45.25 86.19,45.59 86.6,45.99 86.93,45.99 87.39,45.54 87.9,45.54 88.91,46.54 89.83,46.54 arc(90.03,46.5) 90.2,46.38 90.42,46.14 arc(90.53,46.07) 90.65,46.04 92.48,46.04 92.62,46.1 92.7,46.18 92.77,46.34 92.77,46.53 92.65,46.81 92.65,47.06 92.78,47.36 93.06,47.64 v1(93.26,47.93)
DDR4_DIMM_CH3_TDQS_N16: length 51.2
  L07_SIG3 w0.085: v1(93.26,49.93) 92.82,49.34 92.62,49.12 92.61,49.1 92.46,49.04 92.35,49.04 arc(92.12,48.99) 91.94,48.84 91.79,48.65 arc(91.69,48.57) 91.57,48.54 91.48,48.54 arc(91.36,48.57) 91.26,48.65 91.11,48.85 arc(90.93,48.99) 90.7,49.04 90.62,49.04 arc(90.39,48.99) 90.21,48.84 90.06,48.65 arc(89.96,48.57) 89.84,48.54 89.48,48.54 87.88,47.88 86.19,46.2 86.19,41.09 86.09,40.99 85.69,40.99 85.58,41.09 85.58,43.78 85.35,44.02 84.74,44.02 84.5,43.78 84.5,42.78 84.4,42.68 83.98,42.68 83.88,42.78 83.88,43.23 83.47,43.64 82.87,43.64 82.64,43.42 80.16,43.42 77.7,40.96 77.7,33.16 76.38,31.84 76.38,31.28 76.79,30.87 77.29,30.87 78.01,31.59 78.25,31.59 78.49,31.35 78.49,31.09 74.09,26.68 74.09,25.86 74.45,25.5 75.74,25.5 75.85,25.38 75.85,25.11 v1(75.54,24.8)
DDR4_DIMM_CH3_TDQS_N17: length 84
  L14_SIG5 w0.081: v1(149.49,24.8) 149.79,25.09 149.79,25.26 149.5,25.56 148.44,25.56 147.66,25.23 147.4,24.97 147.4,24.28 147.82,23.85 148.27,23.85 148.51,23.62 148.51,23.04 148.27,22.81 147.31,22.81 147.2,22.71 147.2,22.33 147.33,22.2 148.27,22.2 148.48,21.99 148.48,21.4 148.26,21.18 146.45,21.18 146.12,21.51 146.12,22.09 146.02,22.19 145.18,22.19 144.35,21.36 142.37,21.36 142.12,21.61 130.88,21.61 130.2,20.92 127.85,20.92 124.86,17.93 121.14,17.93 120.56,17.35 114.15,17.35 112.33,19.17 109.45,19.17 106.63,21.99 106.63,23.21 105.42,24.42 105.42,25.09 105.69,25.36 105.69,26.78 105.54,26.92 105.54,31.12 105.68,31.27 105.68,32 105.5,32.18 105.5,35.61 105.22,35.88 105.22,39.91 104.94,40.19 104.94,41.43 104.78,41.82 104.78,42.05 104.89,42.32 104.89,42.51 104.78,42.78 104.78,43.07 104.91,43.37 104.91,43.5 104.77,43.82 104.77,44.04 104.9,44.34 104.9,44.52 104.78,44.81 104.78,45.07 104.89,45.35 104.89,45.51 104.78,45.79 104.78,46.07 104.91,46.38 104.91,46.49 104.79,46.78 104.79,47.1 104.89,47.35 105.08,47.54 v1(105.39,47.93)
DDR4_DIMM_SCL: length 18.6
  L14_SIG5 w0.081: v1(108.85,81.93) 107.83,81.93 107.59,82.17 107.59,82.89 106.69,83.79 106.69,84.67 105.32,86.05 105.32,87.89 105.16,88.05 105.16,89.84 104.88,90.12 104.88,91.9 104.48,92.3 104.48,94.21 104.94,94.67 104.94,95.08 104.6,95.43 v1(103.89,95.43)
  BOTTOM w0.149: v1(108.85,81.93) R36.1
DDR4_DIMM_SDA: length 16.6
  L14_SIG5 w0.081: v1(103.24,94.92) 103.99,94.17 103.99,90.43 104.73,89.7 104.73,87.96 104.91,87.79 104.91,85.88 105.76,85.02 105.76,84.26 107.12,82.91 v1(107.12,81.93)
  BOTTOM w0.149: R37.1 107.99,83.17 107.12,82.3 v1(107.12,81.93)
DDR4D_SCL: length 426.5
  L03_SIG1 w0.081: v1(57.67,101.3) 56.27,102.69 55.13,102.69 52.59,105.23 48.52,105.23 47.12,106.63 47.12,107.52 46.46,108.18 45.24,108.18 42.13,105.07 42.13,104.43 40.52,102.82 35.95,102.82 35.44,102.31 31.63,102.31 30.77,101.45 30.77,100.61 27.16,97.01 27.16,92.84 26.33,92.01 26.03,92.01 25.66,91.65 24.31,91.65 23.38,90.71 23.38,82.6 24.16,81.82 24.16,80.32 25.03,79.45 25.03,76.81 24.62,76.41 24.62,74.53 27.44,71.71 27.44,68.15 26.17,66.88 26.17,60.66 27.49,59.34 27.49,52.48 29.29,50.68 31.5,50.68 35.69,46.48 35.69,39.63 40.37,34.95 43.36,34.95 43.72,35.31 47.45,35.31 48.33,34.43 50.24,34.43 52.46,32.21 55.21,32.21 55.63,31.78 56.08,31.78 56.71,32.41 v1(68.74,32.41)
  L05_SIG2 w0.081: v1(190.29,99.52) 190.75,99.06 190.75,91.9 v1(190.29,91.44) 188.98,92.75 188.98,97.98 188.13,98.83 188.13,100.98 188.98,101.83 188.98,105.43 186.89,107.52 163.96,107.52 163.1,106.66 135.62,106.66 132.98,104.02 132.98,102.34 131.27,100.64 131.27,100.18 131.02,99.93 130.54,99.93 130.16,100.31 126.8,100.31 123.63,103.48 123.02,103.48 122.69,103.81 122.69,105.51 120.94,107.27 111.46,107.27 109.74,105.55 97.37,105.55 94.25,108.66 73.77,108.66 72.34,110.09 69.66,110.09 65.57,106 60.59,106 58.05,103.46 58.05,101.68 v1(57.67,101.3)
  L16_SIG6 w0.081: v1(68.74,32.41) 68.74,27.47 69.22,26.99 69.22,25.27 v1(68.74,24.79) ; v1(190.29,99.52) 190.55,99.78 190.55,104.1 186.79,107.86 133.54,107.86 131.2,105.52 131.2,104.85 130.75,104.41 130.51,104.41 130.1,103.99 127.09,103.99 126.17,104.91 126.17,105.26 125.85,105.58 125.85,105.9 124.88,106.86 123.83,106.86 122.83,107.86 105.91,107.86 v1(104.2,106.15)
  BOTTOM w0.149: U1.11 103.89,102.85 103.02,103.72 103.02,104.97 v1(104.2,106.15)
DDR4D_SDA: length 416.4
  L03_SIG1 w0.081: v1(68.74,26.42) 67.4,26.42 61.86,31.96 58.05,31.96 56.83,30.74 55.84,30.74 54.81,31.76 52.4,31.76 50.22,33.94 48.01,33.94 47,34.95 43.97,34.95 43.59,34.57 40.27,34.57 35.31,39.53 35.31,46.36 31.58,50.09 29.06,50.09 26.65,52.5 26.65,59.54 25.79,60.4 25.79,62.94 25.15,63.58 25.15,66.75 26.17,67.77 26.17,72.34 23.66,74.85 23.66,79.43 23.25,79.83 23.25,82.15 22.97,82.43 22.97,91.47 23.5,92 24.45,92 25.28,92.84 25.61,92.84 26.04,93.27 26.04,96.57 29.7,100.23 29.7,101.11 32.05,103.46 39.61,103.46 41.23,105.08 41.49,105.08 45.27,108.87 46.29,108.87 47.51,107.65 47.51,106.76 48.65,105.62 52.99,105.62 54.01,104.6 56.14,104.6 57.67,103.08 v1(57.67,102.57)
  L05_SIG2 w0.081: v1(190.29,105.06) 190.29,101.08 189.75,100.53 189.75,99.39 190.29,98.85 v1(190.29,97.44) 188.98,98.75 188.98,100.6 189.87,101.49 189.87,105.1 186.95,108.02 163.09,108.02 162.3,107.23 135.55,107.23 132.49,104.17 132.49,102.87 130.28,100.66 127.21,100.66 123.04,104.83 123.04,105.67 121.11,107.6 111.03,107.6 110.1,106.67 103.96,106.67 103.34,106.05 97.48,106.05 94.49,109.04 74.33,109.04 72.94,110.43 69.09,110.43 65.16,106.5 60.59,106.5 57.67,103.58 v1(57.67,102.57)
  L16_SIG6 w0.081: v1(103.46,106.87) 104.77,108.19 123.04,108.19 124.01,107.22 125,107.22 126.17,106.05 126.17,105.72 126.39,105.5 126.72,105.5 127.86,104.36 129.4,104.36 133.22,108.19 187.17,108.19 v1(190.29,105.06) ; v1(68.74,19.5) 68.4,19.84 68.4,24.17 68.21,24.36 68.21,25.88 v1(68.74,26.42)
  BOTTOM w0.149: v1(103.46,106.87) 103.46,106.04 102.6,105.17 102.6,103.53 103.24,102.89 U1.10
E_RX_CLK: length 3.5
  TOP w0.149: v1(25.92,82.51) 25.5,82.1 R127.1 R152.2 R153.1
  BOTTOM w0.149: U7.35 v1(25.92,82.51)
E_RX_DV: length 3.6
  BOTTOM w0.149: R129.1 R150.2 R151.1 27.28,82 26.92,82.37 U7.33
E_RXD0: length 3.6
  TOP w0.149: v1(27.42,82.51) 28.17,81.76 R149.1 R148.2 R130.1
  BOTTOM w0.149: U7.32 v1(27.42,82.51)
E_RXD1: length 3.6
  BOTTOM w0.149: U7.31 27.92,82.38 28.17,82.13 R147.1 R146.2 R131.1
E_RXD2: length 13.7
  L12_SIG4 w0.089: v1(27.57,75.45) 27.06,75.96 27.06,79.71 27.69,80.34 27.69,81.05 28.25,81.61 28.52,81.61 v1(29.42,82.51)
  BOTTOM w0.149: R132.1 R144.2 R145.1 26.17,76.85 v1(27.57,75.45) ; U7.28 v1(29.42,82.51)
E_RXD3: length 3.8
  BOTTOM w0.149: U7.27 29.92,82.48 R142.1 R141.2 R133.1
EMMC_CLK: length 134.7
  L05_SIG2 w0.081: v1(93.26,68.93) 93.63,69.3 93.63,70.1 93.3,70.44 93.06,70.44 92.58,70.92 92.38,70.92 91.99,71.31 91.99,72 91.68,72.3 91.27,72.3 91.03,72.06 90.26,72.06 89.85,72.47 86.33,72.47 86.06,72.19 84.24,72.19 83.94,72.49 79.65,72.49 78.65,73.48 78.19,73.48 77.73,73.94 66.73,73.94 66.63,74.04 66.63,74.63 66.53,74.73 66.35,74.73 66.25,74.63 66.25,74.04 66.15,73.94 65.56,73.94 65.13,74.37 65.13,74.88 64.88,75.14 63.22,75.14 61.8,76.56 61.65,76.56 61.52,76.43 61.52,76.29 63.03,74.78 63.03,74.64 62.9,74.51 62.76,74.51 60.67,76.59 60.53,76.59 60.4,76.46 60.4,76.32 62.46,74.26 62.46,74.12 62.33,73.99 62.19,73.99 59.66,76.52 54.66,76.52 53.95,75.81 47.79,75.81 46.9,74.92 46.9,74.67 46.75,74.52 40.65,74.52 39.01,72.88 35.21,72.88 34.4,73.68 31.93,73.68 31.58,73.33 29.16,73.33 28.53,73.97 26.55,73.97 25.31,75.21 24.09,75.21 23.76,75.55 23.76,76.23 22.32,77.67 22.32,81.9 23.12,82.7 23.12,86.12 23.8,86.79 24.18,86.79 26.44,89.05 26.44,89.7 26.67,89.93 26.67,90.43 26.48,90.62 26.48,91.14 26.75,91.41 26.75,91.85 27.33,92.44 27.33,94.12 27.53,94.31 27.81,94.31 28.58,93.54 28.74,93.54 28.85,93.65 28.85,93.81 28.05,94.62 28.05,94.78 28.16,94.89 28.32,94.89 29.13,94.09 29.29,94.09 29.4,94.2 29.4,94.36 28.59,95.17 28.59,95.33 28.71,95.44 28.87,95.44 29.67,94.63 29.83,94.63 29.95,94.75 29.95,94.91 29.14,95.71 29.14,95.87 29.25,95.99 29.41,95.99 30.22,95.18 30.38,95.18 30.49,95.29 30.49,95.45 29.68,96.26 29.68,96.42 v1(34.17,100.91)
  BOTTOM w0.149: v1(34.17,100.91) 33.67,100.41 U16.P7 U16.N7 U16.M6
EMMC_CMD: length 120.6
  L05_SIG2 w0.081: v1(89.8,70.93) 89.77,70.95 78.71,70.95 77.86,71.81 67.72,71.81 67.57,71.96 66.66,71.96 66.5,71.81 65.49,71.81 64.68,72.62 61.96,72.62 58.78,69.45 58.33,69.45 57.97,69.8 53.32,69.8 53.06,69.55 47.75,69.55 46.71,70.59 44.79,70.59 44.42,70.95 39.89,70.95 39.4,70.46 36.38,70.46 35.73,71.11 34.75,71.11 33.87,71.98 31.97,71.98 31.79,72.17 26.57,72.17 24.57,74.17 22.95,74.17 22.63,74.49 22.63,74.79 21.12,76.3 20.13,76.3 19.19,77.24 19.19,80.47 21.98,83.26 21.98,87.62 23.07,88.7 24.03,88.7 24.54,89.21 24.54,89.87 24.37,90.04 24.37,90.51 24.95,91.09 24.95,93.58 25.38,94.01 25.38,100.34 25.21,100.51 25.21,101.48 25.76,102.03 25.76,106.86 26.12,107.22 26.12,109.02 26.27,109.17 32.84,109.17 v1(33.28,108.73)
  BOTTOM w0.149: R226.1 v1(33.28,108.73)
EMMC_COMMAND: length 7.1
  BOTTOM w0.149: U16.M5 31.22,101.91 U16.L3 U16.L2 U16.L1 31.22,103.96 32.39,105.14 R226.2
EMMC_DAT0: length 3.2
  BOTTOM w0.149: v1(23.57,103.74) 24.9,102.41 U16.A3
EMMC_DAT1: length 3
  BOTTOM w0.149: v1(23.57,102.85) 24.51,101.91 U16.A4
EMMC_DAT2: length 2.9
  BOTTOM w0.149: v1(23.57,101.96) 24.12,101.41 U16.A5
EMMC_DAT3: length 5.7
  BOTTOM w0.149: R218.2 24.77,104.85 U16.A1 U16.B2
EMMC_DAT4: length 4.2
  BOTTOM w0.149: v1(23.5,104.73) 25.32,102.91 U16.A2 U16.B3
EMMC_DAT5: length 6.5
  BOTTOM w0.149: R219.2 27.44,104.98 27.72,104.7 U16.D1 U16.D2 U16.C3 U16.B4
EMMC_DAT6: length 11.4
  L03_SIG1 w0.081: v1(24.52,92.6) 24.18,92.94 24.18,97.75 v1(27.72,101.3)
  BOTTOM w0.149: v1(27.72,101.3) 27.61,101.41 U16.C5 U16.B5
EMMC_DAT7: length 7.1
  BOTTOM w0.149: U16.B6 U16.B7 26.72,100.4 U16.A8 25.84,99.52 21.39,99.52 R225.2
EMMC_DATA0: length 130
  TOP w0.149: R227.1 v1(22.68,103.74)
  L05_SIG2 w0.081: v1(22.68,103.74) 22.18,104.24 20.67,104.24 20.06,103.63 19.77,103.63 17.94,101.8 17.33,101.8 14.44,98.91 14.44,77.96 16.01,76.39 16.01,75.52 18.56,72.97 19.15,72.97 20.84,71.28 22.11,71.28 24.9,68.49 31.37,68.49 32.27,67.59 34.7,67.59 35.3,68.18 42.43,68.18 43.02,67.6 43.02,66.65 43.37,66.3 58.43,66.3 58.71,66.02 58.71,64.06 58.94,63.83 59.41,63.83 59.54,63.96 59.54,64.34 59.66,64.47 59.87,64.47 60,64.34 60,63.96 60.13,63.83 60.76,63.83 61.05,64.12 61.05,64.3 60.81,64.54 60.81,64.72 60.96,64.87 61.14,64.87 61.38,64.63 61.56,64.63 61.99,65.06 61.99,65.24 61.28,65.95 61.28,66.13 61.43,66.28 61.61,66.28 62.32,65.57 62.5,65.57 62.65,65.72 62.65,65.9 61.94,66.61 61.94,66.79 62.09,66.93 62.27,66.93 62.97,66.22 63.15,66.22 64.6,67.67 76.74,67.67 77.13,68.06 89.05,68.06 91.25,69.31 91.92,69.31 92.19,69.05 92.61,69.05 93.1,68.55 93.41,68.55 94.13,69.27 v1(94.13,69.43)
EMMC_DATA1: length 129.4
  TOP w0.149: R228.1 v1(22.68,102.85)
  L05_SIG2 w0.081: v1(22.68,102.85) 22.94,102.85 23.42,103.32 23.94,103.32 24.47,103.85 24.47,108.31 25.69,109.53 33.26,109.53 33.89,108.89 33.89,107.22 29.71,103.04 29.71,99.69 26.99,96.96 26.99,92.62 26.36,92 26.05,92 25.81,91.75 25.81,89.53 24.3,88.02 23.85,88.02 22.74,86.91 22.74,82.88 21.33,81.47 21.33,80.35 21.93,79.74 21.93,77.54 23.43,76.05 23.43,75.4 23.95,74.88 25.15,74.88 26.41,73.61 28.41,73.61 29.02,73 31.76,73 32.09,73.33 34.15,73.33 34.93,72.55 39.15,72.55 40.33,73.72 46.6,73.72 47.32,74.44 47.32,74.85 47.93,75.47 54.06,75.47 54.08,75.49 54.09,75.49 54.55,75.95 59.57,75.95 61.69,73.83 61.87,73.83 62.06,73.64 62.47,73.64 62.66,73.83 64.79,73.83 65.03,73.59 65.06,73.59 65.69,72.95 77.93,72.95 78.72,72.16 83.79,72.16 84.16,71.8 86.13,71.8 86.45,72.12 89.6,72.12 v1(89.8,71.93)
EMMC_DATA2: length 128.9
  TOP w0.149: R229.1 v1(22.68,101.96)
  L05_SIG2 w0.081: v1(22.68,101.96) 22.35,101.63 21.8,101.63 21.65,101.78 21.65,103.13 21.48,103.29 20.71,103.29 18.2,100.79 16.97,100.79 16.23,100.04 16.23,99.2 14.87,97.84 14.87,95.87 14.96,95.77 15.17,95.77 15.27,95.67 15.27,95.53 15.17,95.43 14.96,95.43 14.87,95.33 14.87,95.2 14.96,95.1 15.17,95.1 15.27,95 15.27,94.86 15.17,94.76 14.96,94.76 14.87,94.66 14.87,94.29 14.96,94.19 15.17,94.19 15.27,94.09 15.27,93.95 15.17,93.86 14.96,93.86 14.87,93.76 14.87,78.18 15.14,77.91 15.3,77.91 15.63,78.24 15.79,78.24 15.9,78.13 15.9,77.97 15.57,77.64 15.57,77.48 15.69,77.36 15.85,77.36 16.18,77.7 16.34,77.7 16.45,77.58 16.45,77.42 16.12,77.09 16.12,76.93 16.39,76.66 16.39,75.64 17.97,74.06 19.07,74.06 20.52,72.62 21,72.62 21.43,72.2 21.43,71.94 21.73,71.63 22.41,71.63 24.52,69.51 25.71,69.51 25.86,69.67 25.86,69.98 26.02,70.13 26.19,70.13 26.32,70 26.32,69.67 26.47,69.51 27.19,69.51 27.35,69.36 27.35,68.98 27.45,68.88 27.58,68.88 27.68,68.98 27.68,69.41 27.78,69.51 27.92,69.51 28.02,69.41 28.02,68.98 28.12,68.88 28.25,68.88 28.35,68.98 28.35,69.41 28.45,69.51 29.84,69.51 29.97,69.39 29.97,68.99 30.09,68.86 30.3,68.86 30.43,68.99 30.43,69.39 30.56,69.51 32.05,69.51 32.21,69.34 32.21,68.2 32.37,68.05 32.79,68.05 32.91,68.18 32.91,69.29 33.04,69.42 33.25,69.42 33.38,69.29 33.38,68.18 33.64,67.92 34.32,67.92 35.01,68.6 42.47,68.6 43.84,67.24 46.31,67.24 46.9,66.65 57.77,66.65 58.22,67.11 59.32,67.11 60.21,68.01 76.59,68.01 77.48,68.89 87.69,68.89 87.7,68.9 89.24,68.9 89.66,69.32 90.03,69.32 90.54,69.82 91.07,69.82 91.37,69.53 92.29,69.53 v1(92.4,69.43)
EMMC_DATA3: length 126.2
  L05_SIG2 w0.081: v1(25.66,108.73) 24.98,108.04 24.98,102.62 21.92,99.56 18.38,99.56 17.89,99.06 17.89,97.89 18.37,97.41 21.57,97.41 23.11,95.88 23.11,92.45 23.43,92.13 23.65,92.13 24.04,91.75 24.04,91.32 23.83,91.11 21.92,91.11 19.21,88.4 19.21,84.03 18.47,83.29 18.47,76.99 19.97,75.49 20.27,75.49 20.74,75.03 20.74,74.37 21.17,73.93 21.74,73.93 22.71,72.96 24.08,72.96 25.24,71.8 25.89,71.8 26.31,71.38 29.37,71.38 30.08,70.66 30.45,70.66 30.56,70.78 30.56,71.26 30.68,71.38 30.84,71.38 30.95,71.26 30.95,70.78 31.06,70.66 33.8,70.66 34.68,69.79 43.15,69.79 43.68,69.26 46.13,69.26 47.08,68.3 53.52,68.3 53.91,68.69 59.07,68.69 60.49,70.11 64.81,70.11 65.24,70.55 66.21,70.55 66.96,71.3 67.27,71.3 68.02,70.55 76.34,70.55 76.54,70.74 77.96,70.74 78.4,70.3 90.01,70.3 90.51,70.8 91.41,70.8 v1(91.53,70.93)
  BOTTOM w0.149: R218.1 v1(25.66,108.73)
EMMC_DATA4: length 128.2
  TOP w0.149: R231.1 v1(22.61,104.73)
  L05_SIG2 w0.081: v1(22.61,104.73) 23.1,104.24 23.1,103.61 22.78,103.29 22.49,103.29 22.21,103.02 22.21,102.6 22.39,102.43 22.86,102.43 23.11,102.18 23.11,101.28 22.23,100.4 21.91,100.4 21.8,100.51 21.8,101.15 21.69,101.26 21.53,101.26 21.41,101.15 21.41,100.24 21.3,100.13 21.14,100.13 21.03,100.24 21.03,101.15 20.91,101.26 20.75,101.26 20.64,101.15 20.64,100.24 20.53,100.13 20.37,100.13 20.25,100.24 20.25,100.76 20.14,100.88 19.98,100.88 19.87,100.76 19.87,100.24 19.76,100.13 19.6,100.13 19.48,100.24 19.48,101.15 19.37,101.26 19.21,101.26 19.1,101.15 19.1,100.24 18.98,100.13 18.24,100.13 16.96,98.84 16.47,98.84 15.64,98.02 15.64,90.16 15.54,90.06 15.32,90.06 15.22,89.96 15.22,89.83 15.32,89.73 15.54,89.73 15.64,89.63 15.64,89.49 15.54,89.39 15.32,89.39 15.22,89.29 15.22,89.16 15.32,89.06 15.54,89.06 15.64,88.96 15.64,88.82 15.54,88.72 15.32,88.72 15.22,88.62 15.22,88.48 15.32,88.39 15.54,88.39 15.64,88.29 15.64,88.15 15.54,88.05 15.32,88.05 15.22,87.95 15.22,87.81 15.32,87.72 15.54,87.72 15.64,87.62 15.64,79.7 15.83,79.5 15.83,78.67 19.09,75.41 19.09,74.68 20.69,73.08 21.6,73.08 24.15,70.53 27.21,70.53 27.43,70.31 29.49,70.31 29.91,69.89 33.57,69.89 34.43,69.03 42.63,69.03 44.03,67.63 46.39,67.63 47.03,66.98 57.31,66.98 58.21,67.88 59.61,67.88 60.38,68.66 65.59,68.66 66.96,70.03 67.27,70.03 68.08,69.22 89.13,69.22 89.44,69.53 89.94,69.53 90.45,70.04 90.81,70.04 91.15,70.38 91.84,70.38 92.3,69.93 v1(93.26,69.93)
EMMC_DATA5: length 122.8
  L05_SIG2 w0.081: v1(90.67,71.43) 89.57,71.43 89.2,71.8 86.62,71.8 86.27,71.45 83.93,71.45 83.55,71.83 78.39,71.83 77.98,72.24 77.14,72.24 76.77,72.62 65.16,72.62 64.83,72.95 61.63,72.95 59.8,71.12 58.86,71.12 58.01,70.27 53.21,70.27 52.85,69.9 47.94,69.9 47.07,70.77 47.07,71.22 46.57,71.73 44.67,71.73 44.38,72.02 44.38,73.04 44.27,73.15 44.11,73.15 43.99,73.04 43.99,71.41 43.88,71.3 43.72,71.3 43.61,71.41 43.61,73.04 43.5,73.15 43.34,73.15 43.22,73.04 43.22,71.41 43.11,71.3 42.95,71.3 42.84,71.41 42.84,73.04 42.72,73.15 42.56,73.15 42.45,73.04 42.45,71.41 42.34,71.3 40.15,71.3 39.24,72.21 34.73,72.21 34.51,72.43 32.05,72.43 31.91,72.57 26.65,72.57 24.72,74.5 23.78,74.5 23.04,75.24 22.77,75.24 21.6,76.41 21.6,79.38 20.78,80.19 20.78,81.56 22.36,83.14 22.36,87.03 23.68,88.35 24.16,88.35 25.35,89.54 25.35,91.77 25.79,92.21 25.79,92.73 25.92,92.86 25.92,95.35 26.02,95.45 26.53,95.45 26.63,95.55 26.63,95.69 26.53,95.78 26.02,95.78 25.92,95.88 25.92,96.02 26.02,96.12 26.53,96.12 26.63,96.22 26.63,96.36 26.53,96.46 26.02,96.46 25.92,96.55 25.92,100.11 26.55,100.74 v1(26.55,108.73)
  BOTTOM w0.149: R219.1 v1(26.55,108.73)
EMMC_DATA6: length 116.7
  L05_SIG2 w0.081: v1(89.8,69.93) 89.36,69.93 88.98,69.55 77.73,69.55 77.07,70.21 67.57,70.21 67.42,70.36 66.81,70.36 66.66,70.21 65.37,70.21 64.4,69.24 60.33,69.24 59.33,68.24 58.05,68.24 57.3,67.49 47.33,67.49 45.91,68.91 43.41,68.91 42.97,69.35 34.57,69.35 33.61,70.31 29.95,70.31 29.61,70.65 27.65,70.65 27.36,70.94 26.22,70.94 25.71,71.45 25.02,71.45 24.33,72.14 23.59,72.14 23.11,72.62 22.59,72.62 21.62,73.59 20.72,73.59 19.41,74.89 19.41,75.57 18.09,76.89 18.09,78.77 17.12,79.74 17.12,81.46 16.15,82.43 16.15,93.23 16.26,93.34 16.86,93.34 16.98,93.46 16.98,93.62 16.86,93.73 16.26,93.73 16.15,93.84 16.15,94 16.26,94.12 16.86,94.12 16.98,94.23 16.98,94.39 16.86,94.5 16.26,94.5 16.15,94.61 16.15,94.77 16.26,94.89 16.86,94.89 16.98,95 16.98,95.16 16.86,95.27 16.26,95.27 16.15,95.39 16.15,95.55 16.26,95.66 16.86,95.66 16.98,95.77 16.98,95.93 16.86,96.05 16.26,96.05 16.15,96.16 16.15,96.74 16.36,96.95 21.29,96.95 22.41,95.84 22.41,92.2 23.1,91.52 v1(23.63,91.52)
  BOTTOM w0.149: R224.1 R233.1
EMMC_DATA7: length 123.4
  L05_SIG2 w0.081: v1(91.53,71.93) 91.53,71.56 90.98,71.01 90.42,71.01 89.96,70.55 89.45,70.55 89.37,70.63 78.55,70.63 77.7,71.48 67.57,71.48 67.42,71.63 66.8,71.63 66.63,71.45 65.69,71.45 64.68,70.44 60.31,70.44 58.96,69.09 58.2,69.09 57.82,69.47 53.75,69.47 52.99,68.71 48.11,68.71 46.76,70.06 44.53,70.06 44.26,70.34 39.91,70.34 39.7,70.13 34.9,70.13 34.37,70.67 34.37,71 33.75,71.62 31.73,71.62 31.55,71.8 26.46,71.8 24.85,73.41 24.38,73.41 24.02,73.76 22.41,73.76 21.66,74.52 21.66,74.72 20.47,75.9 20.04,75.9 18.82,77.13 18.82,81.94 18.93,82.06 20.14,82.06 20.25,82.17 20.25,82.33 20.14,82.44 18.93,82.44 18.82,82.55 18.82,82.82 19.57,83.57 19.57,88.19 22.16,90.78 24.09,90.78 24.47,91.16 24.47,92.03 24.06,92.43 24.06,96.57 23.96,96.66 23,96.66 22.91,96.76 22.91,96.9 23,97 23.96,97 24.06,97.1 24.06,97.24 23.96,97.33 22.58,97.33 22.48,97.43 22.48,97.57 22.58,97.67 23.96,97.67 24.06,97.77 24.06,97.91 23.96,98 21.97,98 21.87,98.1 21.87,98.24 21.97,98.34 23.96,98.34 24.06,98.44 24.06,98.75 23.92,98.9 v1(18.55,98.9)
  BOTTOM w0.149: R225.1 v1(18.55,98.9)
EMMC_RSTN: length 106.7
  L03_SIG1 w0.081: v1(31.25,101.17) 31.63,100.79 31.63,94.82 v1(29.98,93.17) 28.68,93.17 27.79,92.28 27.13,92.28 26.73,91.87 26.73,91.44 26.42,91.14 24.77,91.14 24.39,90.76 24.39,85.12 25.51,84 25.51,80.85 25.92,80.44 25.92,79.58 25.69,79.35 25.69,78.46 28.71,75.44 28.71,72.6 27.95,71.83 27.95,67.9 26.93,66.88 26.93,62.94 31.27,58.6 31.27,56.09 31.69,55.67 31.69,52.39 37.32,46.76 37.32,40.44 39.48,38.28 39.48,37.77 40.85,36.4 42.55,36.4 v1(43.06,35.89)
  L12_SIG4 w0.089: v1(33.23,18.82) 32.83,19.22 32.83,19.77 33.08,20.02 33.36,20.02 33.63,20.29 33.63,21.36 33.9,21.62 34.18,21.62 34.43,21.88 34.43,22.16 34.7,22.42 34.98,22.42 35.23,22.68 35.23,22.96 35.5,23.22 39.03,23.22 40.27,24.46 40.27,29.92 40.84,30.5 41.31,30.5 42.17,31.36 42.17,35 v1(43.06,35.89)
  BOTTOM w0.149: v1(29.98,93.17) 30.17,92.98 R236.1 ; v1(31.25,101.17) 31.02,101.41 U16.K5
EN: length 2.5
  BOTTOM w0.149: U14.20 47.89,99.52 48.14,99.77 48.58,99.77 R187.1
ENET_1.2V_AVDDL: length 1.7
  BOTTOM w0.254: v1(29.29,89.33) 29.29,89.44 29.42,89.56 U7.9 ; v1(26.92,89.36) U7.4
ENET_1.2V_AVDLL_PLL: length 0.8
  BOTTOM w0.254: v1(23.98,87.59) 24.12,87.45 U7.44
  vias: v1(16.39,81.49) v1(17.66,81.49)
ENET_1.2V_DVDDL: length 8
  TOP w0.381: v1(30.87,88.84) 30.63,88.6 C239.2 ; v1(30.87,86.95) 30.61,86.69 C240.2 ; v1(30.87,84.79) 30.74,84.91 C237.2 ; C238.2 v1(28.17,84.16)
  BOTTOM w0.254: v1(30.87,84.79) 30.87,84.61 31.02,84.45 U7.23 ; U7.39 25.22,84.95 v1(25.5,84.67) ; v1(30.2,84.04) 30.42,83.82 U7.26 ; v1(30.87,88.84) 30.99,88.95 U7.14 ; U7.18 v1(30.87,86.95)
  BOTTOM w0.305: v1(28.17,84.16) 28.42,83.91 U7.30
  vias: v1(38.36,84.15) v1(38.36,83.39) v1(39.38,83.39)
ENET_1.8V_DVDDH: length 8.1
  TOP w0.381: C221.2 v1(26.9,84.16) ; v1(30.87,87.84) 30.74,87.71 C222.2
  BOTTOM w0.254: v1(25.5,85.69) 25.27,85.45 U7.40 ; U7.34 26.42,83.68 v1(26.9,84.16) ; U7.16 30.99,87.95 v1(30.87,87.84) ; v1(36.39,90.95) 36.39,92.31 36.23,92.47 R136.1
  BOTTOM w0.305: R144.1 22.99,76.22 v1(22.99,75.83)
  vias: v1(15.37,79.07) v1(16.26,79.07) v1(17.15,79.07) v1(24.01,83.64) v1(26.39,80.66) v1(29.06,80.66) v1(31.73,80.67) v1(37.28,80.6)
ENET_3.3V_AVDDH: length 3.5
  BOTTOM w0.254: U7.12 31.55,90.17 31.76,90.38 ; v1(25.79,88.98) 25.42,89.35 U7.1
  BOTTOM w0.381: 31.76,90.38 32.01,90.63 v1(32.01,91.52)
  vias: v1(35.31,83.39) v1(36.33,83.39)
ENET_GTX_CLK: length 91.8
  L05_SIG2 w0.081: v1(92.4,71.43) 92.4,71.89 91.76,72.52 91.4,72.52 91.12,72.8 91.12,73.5 90.8,73.82 90.35,73.82 90.09,73.55 89.05,73.55 88.8,73.3 84.29,73.3 83.89,73.71 79.47,73.71 78.96,74.22 78.47,74.22 78.04,74.65 77.15,74.65 76.26,75.54 70.39,75.54 70.24,75.69 70.24,75.97 69.66,76.55 63.49,76.55 62.8,77.24 54.33,77.24 53.54,76.46 47.42,76.46 46.13,75.17 44.46,75.17 44.2,75.43 40.46,75.43 38.56,73.54 35.47,73.54 34.49,74.51 30.12,74.51 29.99,74.63 26.89,74.63 26.27,75.25 26.27,76.02 25.59,76.7 24.42,76.7 23.01,78.12 23.01,79.48 23.83,80.3 23.83,80.94 24.27,81.38 25.05,81.38 25.79,82.12 26.09,82.12 26.9,82.93 31.27,82.93 v1(33.54,80.66)
ENET_INTN: length 104.2
  L05_SIG2 w0.081: v1(23.63,81.74) 24.21,82.32 24.21,82.55 24.42,82.76 24.42,83.36 24.77,83.71 25.29,83.71 25.98,84.4 25.98,86.37 28.06,88.45 29.22,88.45 29.87,89.1 29.87,89.53 30.22,89.88 39.06,89.88 41.11,91.93 48.55,91.93 49.19,91.29 54.62,91.29 55.28,90.63 64.14,90.63 70.92,83.85 76.74,83.85 79.87,80.71 83.14,80.71 87.09,82.35 89.9,82.35 90.44,81.82 90.81,81.82 91.32,81.3 91.69,81.3 91.9,81.09 91.9,79.39 92.28,79.01 92.86,79.01 93.68,78.19 93.68,77.8 93.55,77.67 93.55,77.19 93.91,76.83 95.65,76.83 97.54,74.93 97.72,74.93 98.06,74.59 98.06,72 97.14,71.07 97.14,69.81 96.86,69.54 96.48,69.54 96.16,69.86 95.55,69.86 95.23,69.54 94.85,69.54 94.71,69.69 94.58,69.81 94.58,70.51 94.13,70.96 v1(94.13,71.43)
  BOTTOM w0.149: v1(23.63,81.74) 23.38,81.99 23.38,83.64 24.18,84.45 U7.38
