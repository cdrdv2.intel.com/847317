# Allegro board TS28247BC0_FM61_agilex_PCIe_DEVKIT_ADI_REVB1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_DIMM_CH3_DQ27: length 74.4
  L07_SIG3 w0.089: v1(154.59,18.8) 155.05,18.34 157.39,18.34 157.74,17.99 162.14,17.99 162.65,18.49 162.65,25.65 163.47,26.47 163.47,27.35 160.94,29.88 160.4,29.88 158.43,31.84 154.47,31.84 154.15,31.53 153.34,31.53 153.03,31.84 152.75,31.84 152.29,31.39 150.36,31.39 150.18,31.56 149.02,31.56 148.78,31.32 147.72,31.32 147.12,31.93 145.81,31.93 143.67,34.06 137.88,34.06 136.14,35.81 134.76,35.81 134.05,36.52 130.73,36.52 129.25,38 129.25,38.5 128.84,38.91 127.27,38.91 126.84,39.09 125.52,40.42 124.67,40.42 123.52,40.89 115.12,40.89 114.54,41.13 114.05,41.63 v1(114.05,41.93)
DDR4_DIMM_CH3_DQ28: length 72.2
  L07_SIG3 w0.089: v1(110.58,42.93) 111.66,42.93 112.04,43.31 112.53,43.31 112.9,42.93 113.44,42.93 113.95,42.43 114.15,42.43 114.7,41.88 115.1,41.88 115.54,41.44 115.94,41.44 116.39,41.89 116.84,41.89 117.28,41.45 117.73,41.45 118.16,41.88 118.63,41.88 119.07,41.45 119.5,41.45 119.94,41.88 120.32,41.88 120.77,41.43 121.18,41.43 121.68,41.92 122.04,41.92 122.55,41.41 122.87,41.41 123.35,41.89 123.78,41.89 124.79,40.88 125.63,40.88 126.6,39.9 127.14,39.9 127.77,39.28 128.97,39.28 130.41,37.84 130.7,37.84 131.51,37.03 135.64,37.03 138.26,34.41 144.09,34.41 145.6,32.89 146.74,32.89 147.68,31.95 148.28,31.95 148.56,32.23 148.95,32.23 149.17,32.01 150.65,32.01 150.88,32.24 151.41,32.24 151.67,31.98 152.38,31.98 152.64,32.24 153.19,32.24 153.46,31.97 153.86,31.97 154.12,32.23 154.78,32.23 155.35,32.8 157.97,32.8 160.29,30.48 161.04,30.48 164.35,27.17 164.35,22.4 164.25,22.29 163.39,22.29 163.29,22.4 163.29,24.6 v1(163.09,24.8)
DDR4_DIMM_CH3_DQ29: length 71.8
  L07_SIG3 w0.089: v1(162.24,18.8) 161.81,18.37 157.87,18.37 157.53,18.7 157.53,22.34 158.43,23.24 158.43,24.33 158.19,24.57 157.98,24.57 157.88,24.67 157.88,24.85 157.98,24.96 158.23,24.96 158.33,25.06 158.33,25.19 158.23,25.29 157.79,25.29 157.69,25.39 157.69,25.52 157.79,25.63 158.25,25.63 158.35,25.73 158.35,25.86 158.25,25.96 157.4,25.96 156.57,26.79 156.04,26.79 155.83,26.58 155.19,26.58 154.98,26.8 154.3,26.8 154.13,26.62 153.45,26.62 153.28,26.79 152.58,26.79 152.41,26.63 151.74,26.63 151.49,26.88 150.93,26.88 150.64,26.59 149.89,26.59 149.69,26.79 148.26,26.79 148.12,26.65 147.4,26.65 146.23,27.82 144.09,27.82 142.08,29.83 136.63,29.83 134.57,31.89 129.9,31.89 127.82,33.97 126.79,33.97 125.69,35.07 125.69,35.58 125.32,35.95 114.24,35.95 112.73,37.47 112.19,37.47 111.95,37.7 111.95,38.52 110.98,39.49 110.98,40.03 110.46,40.55 110.34,40.84 110.19,40.99 110.19,41.54 v1(110.58,41.93)
DDR4_DIMM_CH3_DQ30: length 70.2
  L07_SIG3 w0.089: v1(109.72,41.43) 109.72,40.99 110.02,40.68 110.16,40.36 110.49,40.02 110.49,39.48 111.04,38.93 111.04,37.26 111.29,37.02 112.69,37.02 112.79,36.91 112.79,36.78 112.69,36.68 112.21,36.68 112.11,36.58 112.11,36.45 112.21,36.34 112.64,36.34 113.07,35.92 113.3,35.92 114.19,35.03 124.74,35.03 126.44,33.34 127.88,33.34 130.18,31.04 130.74,31.04 130.84,31.14 130.84,31.39 130.94,31.49 131.08,31.49 131.17,31.39 131.17,31.14 131.27,31.04 131.96,31.04 132.06,31.14 132.06,31.44 132.16,31.53 132.3,31.53 132.4,31.44 132.4,31.14 132.5,31.04 132.63,31.04 132.73,31.14 132.73,31.44 132.83,31.53 132.97,31.53 133.07,31.44 133.07,31.14 133.17,31.04 133.31,31.04 133.4,31.14 133.4,31.44 133.5,31.53 133.64,31.53 133.74,31.44 133.74,31.14 133.88,31 134.92,31 136.49,29.43 141.75,29.43 144.33,26.86 145.46,26.86 146.3,26.01 156.73,26.01 156.87,25.86 156.87,25.73 156.77,25.63 156.36,25.63 156.26,25.53 156.26,25.4 156.36,25.29 156.74,25.29 156.84,25.19 156.84,25.06 156.74,24.96 156.39,24.96 156.29,24.86 156.29,24.74 156.77,24.27 156.77,21.11 156.87,21.01 157.04,21.01 157.14,21.11 v1(157.14,24.8)
DDR4_DIMM_CH3_DQ31: length 70.4
  L07_SIG3 w0.089: v1(156.29,18.8) 155.89,19.2 155.89,20.63 155.79,20.73 154.15,20.73 154.05,20.83 154.05,20.97 154.15,21.07 155.79,21.07 155.89,21.16 155.89,21.3 155.79,21.4 154.15,21.4 154.05,21.5 154.05,21.64 154.15,21.74 155.79,21.74 155.89,21.84 155.89,24.94 155.6,25.22 152.84,25.22 152.43,25.63 144.36,25.63 143.96,26.03 143.96,26.69 141.68,28.97 136.44,28.97 135.41,30 134.02,30 133.32,30.7 129.24,30.7 128.64,31.29 128.64,31.7 128.44,31.9 128.04,31.9 127.76,32.19 127.76,32.5 127.34,32.92 126.36,32.92 124.6,34.68 113.38,34.68 111.5,36.57 111.2,36.57 110.67,37.09 110.67,38.8 110.12,39.35 110.12,39.62 109.79,39.95 109.6,39.95 109.33,40.22 109.33,41.57 109.72,41.96 v1(109.72,42.43)
DDR4_DIMM_CH3_DQ32: length 40
  L05_SIG2 w0.081: v1(101.06,46.43) 101.3,46.18 101.3,45.71 101.43,45.58 101.43,45.27 101.3,45.15 101.3,44.71 101.43,44.58 101.43,44.27 101.3,44.15 101.3,43.71 101.43,43.58 101.43,43.27 101.3,43.15 101.3,42.71 101.43,42.58 101.43,42.27 101.3,42.15 101.3,41.71 101.43,41.58 101.43,41.19 101.14,40.91 100.96,40.91 100.65,40.6 100.65,37.16 100.95,36.87 101.14,36.87 103.8,34.21 103.94,34.21 104.23,34.51 104.37,34.51 104.47,34.41 104.47,34.27 104.17,33.97 104.17,33.84 104.27,33.74 104.41,33.74 104.74,34.07 104.88,34.07 104.98,33.97 104.98,33.83 104.65,33.5 104.65,33.2 106.03,31.82 106.19,31.82 107.05,30.96 107.05,30.73 106.95,30.64 106.39,30.64 106.3,30.54 106.3,30.4 106.39,30.3 106.95,30.3 107.05,30.2 107.05,30.06 106.95,29.97 106.39,29.97 106.3,29.87 106.3,29.73 106.39,29.63 106.95,29.63 107.05,29.53 107.05,29.39 106.95,29.3 106.39,29.3 106.3,29.2 106.3,29.06 106.39,28.96 106.95,28.96 107.05,28.86 107.05,28.72 106.95,28.62 106.39,28.62 106.3,28.53 106.3,28.39 106.39,28.29 106.95,28.29 107.05,28.19 107.05,28.05 106.95,27.95 106.39,27.95 106.3,27.86 106.3,27.72 106.39,27.62 106.95,27.62 107.05,27.52 107.05,27 106.62,26.57 106.62,25.93 105.69,25 105.69,22.32 105.79,22.22 106.04,22.22 106.14,22.32 v1(106.14,24.8)
DDR4_DIMM_CH3_DQ33: length 40
  L05_SIG2 w0.081: v1(101.06,47.43) 101.06,47.43 101.55,46.93 101.55,45.77 101.75,45.57 101.75,45.29 101.55,45.08 101.55,44.78 101.75,44.57 101.75,44.29 101.55,44.08 101.55,43.77 101.75,43.57 101.75,43.28 101.55,43.08 101.55,42.77 101.75,42.57 101.75,42.29 101.55,42.08 101.55,41.77 101.67,41.65 101.67,36.92 102.59,36 103.12,36 104.1,35.02 104.8,35.02 106.62,33.2 106.62,32.61 107.38,31.85 107.38,25.84 106.56,25.02 106.56,24.47 106.85,24.18 106.85,21.89 106.75,21.79 105.95,21.79 105.85,21.69 105.85,21.4 105.95,21.3 106.69,21.3 106.79,21.19 106.79,20.94 106.69,20.84 105.91,20.84 105.81,20.73 105.81,20.59 105.91,20.49 106.81,20.49 106.91,20.38 106.91,20.16 106.81,20.05 105.9,20.05 105.8,19.95 105.8,19.76 105.9,19.66 106.85,19.66 106.95,19.56 106.95,19.35 106.85,19.25 105.74,19.25 v1(105.29,18.8)
DDR4_DIMM_CH3_DQ34: length 41
  L05_SIG2 w0.081: v1(101.92,47.93) 101.92,48.26 101.26,48.92 100.91,48.92 100.41,49.42 99.92,49.42 99.44,48.93 99.1,48.93 98.56,48.39 98.19,48.39 97.73,47.94 97.41,47.94 97.17,47.7 97.17,46.85 96.69,46.37 96.52,46.37 96.31,46.15 96.31,39.12 96.5,38.92 96.5,36.52 97.17,35.85 97.17,34.29 98.09,33.38 98.09,31.27 98.88,30.48 98.88,26.28 99.74,25.43 99.74,24.11 99.42,23.79 99.42,23.09 99.74,22.78 99.74,20.21 99.84,20.1 100.09,20.1 100.19,20.21 v1(100.19,24.8)
DDR4_DIMM_CH3_DQ35: length 41
  L05_SIG2 w0.081: v1(101.92,46.93) 102.21,46.64 102.21,46.19 102.31,46.08 102.31,45.77 102.21,45.67 102.21,45.19 102.31,45.08 102.31,44.77 102.21,44.67 102.21,44.19 102.31,44.08 102.31,43.77 102.21,43.67 102.21,43.19 102.31,43.08 102.31,42.77 102.21,42.67 102.21,42.19 102.31,42.08 102.31,41.77 102.04,41.5 102.04,37.58 102.69,36.93 102.93,36.93 103.96,35.9 104.57,35.9 107.47,33 107.47,32.26 107.79,31.95 107.79,28.23 108.22,27.8 108.22,27.22 107.77,26.77 107.77,25.66 107.45,25.34 107.45,18.57 106.86,17.99 101.78,17.99 101.37,18.4 100.05,18.4 99.65,18.8 v1(99.34,18.8)
DDR4_DIMM_CH3_DQ36: length 38.1
  L05_SIG2 w0.081: v1(107.84,24.8) 107.84,21.64 107.94,21.53 108.18,21.53 108.29,21.64 108.29,26.72 108.58,27.01 108.58,27.99 108.21,28.36 108.21,32.13 108.31,32.23 108.31,33.37 106.73,34.95 106.08,34.95 104.63,36.4 104.08,36.4 103.21,37.27 103.21,37.66 102.39,38.48 102.39,41.55 102.6,41.76 102.6,42.09 102.42,42.27 102.42,42.58 102.6,42.76 102.6,43.09 102.42,43.27 102.42,43.58 102.6,43.76 102.6,44.09 102.42,44.27 102.42,44.58 102.6,44.76 102.6,45.09 102.42,45.27 102.42,45.58 102.6,45.76 102.6,46.09 102.42,46.27 102.42,47.15 102.12,47.44 101.72,47.44 101.22,47.94 100.91,47.94 100.45,48.4 99.96,48.4 99.49,47.93 v1(98.46,47.93)
DDR4_DIMM_CH3_DQ37: length 38.3
  L05_SIG2 w0.081: v1(106.99,18.8) 106.58,18.38 102.57,18.38 102.31,18.63 102.31,22.3 102.76,22.75 103.6,22.75 103.71,22.85 103.71,24.05 103.6,24.15 102.59,24.15 102.31,24.43 102.31,25.36 101.5,26.16 101.5,26.53 100.5,27.54 100.5,31.38 99.66,32.22 99.66,34.57 99.31,34.92 98.97,34.92 98.68,35.22 98.68,35.92 98.04,36.56 98.04,41.01 98.26,41.23 98.26,41.6 98.09,41.77 98.09,42.08 98.26,42.25 98.26,42.6 98.09,42.77 98.09,43.08 98.26,43.25 98.26,43.6 98.09,43.77 98.09,44.08 98.26,44.25 98.26,44.61 98.09,44.78 98.09,45.08 98.26,45.25 98.26,45.6 98.09,45.77 98.09,46.08 98.26,46.25 98.26,46.73 v1(98.46,46.93)
DDR4_DIMM_CH3_DQ38: length 36
  L05_SIG2 w0.081: v1(101.89,24.8) 101.89,24.05 102.16,23.78 103.15,23.78 103.25,23.68 103.25,23.32 103.15,23.22 102.12,23.22 101.93,23.03 101.93,20.36 101.83,20.26 101.6,20.26 101.5,20.36 101.5,25.28 100.6,26.18 100.6,26.57 100.06,27.11 100.06,31.27 99.27,32.06 99.27,33.67 98.34,34.61 98.34,35.72 97.2,36.86 97.2,38.56 97.7,39.06 97.7,40.98 98.01,41.3 98.01,41.55 97.88,41.69 97.88,42.17 98.01,42.3 98.01,42.56 97.88,42.69 97.88,43.17 98.01,43.3 98.01,43.56 97.88,43.69 97.88,44.17 98.01,44.3 98.01,44.56 97.88,44.69 97.88,45.17 98.01,45.3 98.01,45.56 97.88,45.69 97.88,46.14 v1(97.59,46.43)
DDR4_DIMM_CH3_DQ39: length 36.7
  L05_SIG2 w0.081: v1(97.59,47.43) 97.59,46.95 97.22,46.58 97.22,46.23 97.13,46.14 97.13,38.98 96.85,38.69 96.85,36.7 97.97,35.58 97.97,34.38 98.88,33.47 98.88,31.26 99.55,30.59 99.55,26.76 99.73,26.57 99.73,26.18 100.63,25.29 100.63,24.48 101.04,24.06 101.04,22.05 100.94,21.95 100.7,21.95 100.6,21.85 100.6,21.71 100.7,21.61 100.94,21.61 101.04,21.51 101.04,21.38 100.94,21.28 100.7,21.28 100.6,21.18 100.6,21.04 100.7,20.94 100.94,20.94 101.04,20.84 101.04,20.7 100.94,20.61 100.7,20.61 100.6,20.51 100.6,20.37 100.7,20.27 100.94,20.27 101.04,20.17 101.04,19.91 100.79,19.67 99.75,19.67 99.65,19.56 99.65,19.36 99.75,19.26 101.75,19.26 101.85,19.16 101.85,18.9 101.75,18.8 v1(101.04,18.8)
DDR4_DIMM_CH3_DQ40: length 42.3
  L14_SIG5 w0.081: v1(96.79,24.8) 96.79,23.83 96.62,23.65 95.85,23.65 95.75,23.55 95.75,23.42 95.85,23.32 96.68,23.32 96.78,23.22 96.78,23.09 96.68,22.98 95.49,22.98 95.39,22.88 95.39,22.74 95.49,22.64 96.66,22.64 96.76,22.54 96.76,22.36 96.66,22.26 95.14,22.26 95.04,22.16 95.04,21.88 95.14,21.78 97.12,21.78 97.22,21.88 97.22,26.66 98.28,27.72 98.28,31.23 98.11,31.4 98.11,41.45 97.68,41.87 97.35,41.87 97.2,42.02 97.2,43.62 97.55,43.97 97.68,43.97 98.04,44.32 98.04,45.16 98.3,45.43 98.65,45.43 99.19,45.97 99.56,45.97 100.11,46.52 100.32,46.52 100.58,46.79 100.58,47.61 100.91,47.93 101.1,47.93 101.43,48.26 101.43,48.59 101.28,48.75 101.28,49.21 v1(101.06,49.43)
DDR4_DIMM_CH3_DQ41: length 42.3
  L14_SIG5 w0.081: v1(101.92,48.93) 101.92,48.45 101.92,48.45 102.3,48.08 102.3,47.77 102.06,47.54 101.83,47.54 101.71,47.41 101.71,47.24 101.51,47.05 101.51,46.16 101.3,45.94 101.03,45.94 100.58,45.49 100.58,44.79 100.28,44.48 100.1,44.48 99.73,44.12 99.73,43.14 99.52,42.92 99.14,42.92 98.89,42.67 98.89,37.2 99.57,36.53 99.57,34.23 99.34,34 99.34,32.1 99.75,31.69 99.75,27.53 98.9,26.68 98.9,22.69 98.8,22.59 97.7,22.59 97.6,22.49 97.6,22.35 97.7,22.25 98.8,22.25 98.9,22.15 98.9,22.02 98.8,21.92 97.7,21.92 97.6,21.82 97.6,21.68 97.7,21.58 98.8,21.58 98.9,21.48 98.9,21.35 98.8,21.25 97.7,21.25 97.6,21.15 97.6,21.01 97.7,20.91 98.8,20.91 98.9,20.81 98.9,20.39 97.73,19.23 96.38,19.23 v1(95.94,18.8)
DDR4_DIMM_CH3_DQ42: length 42.1
  L14_SIG5 w0.081: v1(90.84,24.8) 90.84,21.49 90.74,21.39 90.47,21.39 90.37,21.49 90.37,25.25 91.26,26.14 91.26,32.58 91.97,33.29 91.97,46.61 92.29,46.93 92.5,46.93 92.82,47.25 92.82,48.11 93.16,48.45 93.4,48.45 93.85,48.9 94.28,48.9 94.79,49.41 95.14,49.41 95.65,49.91 96,49.91 96.54,50.45 96.88,50.45 97.37,50.95 97.81,50.95 98.18,51.32 98.61,51.32 98.88,51.06 99.78,51.06 100.13,51.4 100.52,51.4 101.06,50.86 v1(101.06,50.43)
DDR4_DIMM_CH3_DQ43: length 42.9
  L14_SIG5 w0.081: v1(89.99,18.8) 92.03,17.95 97.46,17.95 98.06,18.54 98.06,18.94 99.77,20.66 99.77,26.73 100.13,27.09 100.13,31.9 99.74,32.29 99.74,32.76 99.93,32.96 99.93,41.53 99.74,41.72 99.74,42.14 100.07,42.47 100.28,42.47 100.67,42.86 100.67,44.57 101.01,44.92 101.19,44.92 101.65,45.38 101.99,45.38 102.38,45.78 102.38,47.56 102.57,47.75 102.57,48.12 102.38,48.31 102.38,49.47 v1(101.92,49.93)
DDR4_DIMM_CH3_DQ44: length 36.7
  L14_SIG5 w0.081: v1(98.49,24.8) 98.49,23.11 98.39,23 98.12,23 98.02,23.11 98.02,26.7 99.37,28.05 99.37,30.76 98.89,31.24 98.89,32.65 98.77,32.78 98.77,36.37 98.46,36.68 98.46,41.4 98.02,41.84 98.02,43.2 98.25,43.42 98.57,43.42 98.9,43.76 98.9,44.62 99.34,45.05 99.58,45.05 99.98,45.45 100.25,45.45 100.62,45.82 100.62,46.53 100.82,46.73 100.82,46.85 100.93,46.96 101.12,46.96 101.46,47.3 101.46,48 101.68,48.22 101.68,48.63 101.53,48.79 101.53,49.76 101.34,49.94 100.88,49.94 100.38,50.45 99.83,50.45 99.47,50.82 99.01,50.82 98.62,50.43 v1(97.59,50.43)
DDR4_DIMM_CH3_DQ45: length 39.1
  L14_SIG5 w0.081: v1(97.64,18.8) 97.18,18.33 93.35,18.33 92.96,18.72 92.96,22.9 92.86,23 92.5,23 92.41,23.1 92.41,23.23 92.5,23.33 92.86,23.33 92.96,23.43 92.96,31.8 94.57,33.41 94.57,45.16 94.81,45.4 95.07,45.4 95.43,45.76 95.43,46.63 95.8,47 96.14,47 96.59,47.45 96.87,47.45 97.35,47.93 97.69,47.93 98.1,48.34 98.1,48.57 v1(98.46,48.93)
DDR4_DIMM_CH3_DQ46: length 39.3
  L14_SIG5 w0.081: v1(92.54,24.8) 92.54,23.78 92.44,23.68 92.2,23.68 92.1,23.78 92.1,25.21 92.54,25.66 92.54,26.58 92.14,26.98 92.14,27.77 92.24,27.86 92.51,27.86 92.61,27.96 92.61,28.1 92.51,28.2 92.24,28.2 92.14,28.3 92.14,28.44 92.24,28.54 92.51,28.54 92.61,28.63 92.61,28.77 92.51,28.87 92.24,28.87 92.14,28.97 92.14,29.11 92.24,29.21 92.51,29.21 92.61,29.3 92.61,29.44 92.51,29.54 92.24,29.54 92.14,29.64 92.14,29.78 92.24,29.88 92.51,29.88 92.61,29.97 92.61,30.11 92.51,30.21 92.24,30.21 92.14,30.31 92.14,30.45 92.24,30.55 92.51,30.55 92.61,30.65 92.61,30.78 92.51,30.88 92.24,30.88 92.14,30.98 92.14,31.14 92.46,31.45 92.46,31.79 93.7,33.04 93.7,39.09 93.8,39.19 94.11,39.19 94.2,39.29 94.2,39.43 94.11,39.52 93.38,39.52 93.28,39.62 93.28,39.76 93.38,39.86 94.11,39.86 94.2,39.96 94.2,40.1 94.11,40.2 93.33,40.2 93.23,40.29 93.23,40.43 93.33,40.53 94.11,40.53 94.2,40.63 94.2,40.77 94.11,40.87 93.8,40.87 93.7,40.96 93.7,45.7 93.92,45.92 94.28,45.92 94.54,46.18 94.54,47.1 94.89,47.44 95.25,47.44 95.74,47.93 96.05,47.93 96.53,48.42 96.95,48.42 97.46,48.92 97.77,48.92 98.1,49.26 98.1,49.57 v1(98.46,49.93)
DDR4_DIMM_CH3_DQ47: length 36.6
  L14_SIG5 w0.081: v1(97.59,49.43) 96.57,49.43 96.05,48.92 95.67,48.92 95.16,48.41 94.72,48.41 94.23,47.92 94.03,47.92 93.68,47.57 93.68,46.73 93.38,46.43 93.09,46.43 92.85,46.19 92.85,33.55 92.08,32.77 92.08,31.62 91.77,31.32 91.77,26.87 92.14,26.51 92.14,26.25 91.3,25.41 91.3,22.62 91.4,22.52 92.06,22.52 92.16,22.42 92.16,22.28 92.06,22.19 91.4,22.19 91.3,22.09 91.3,19.19 v1(91.69,18.8)
DDR4_DIMM_CH3_DQ48: length 60.5
  L05_SIG2 w0.081: v1(87.44,24.8) 87.44,24.32 88.44,23.32 88.44,19.63 88.54,19.53 88.67,19.53 88.77,19.63 88.77,21.28 88.87,21.38 89.01,21.38 89.11,21.28 89.11,20.02 89.21,19.92 89.34,19.92 89.44,20.02 89.44,23.75 89.34,23.85 89.21,23.85 89.11,23.75 89.11,21.86 89.01,21.76 88.87,21.76 88.77,21.86 88.77,24.21 88.61,24.37 88.09,24.37 87.87,24.59 87.87,27.08 88.04,27.24 88.46,27.24 88.56,27.35 88.56,27.48 88.46,27.58 87.74,27.58 87.64,27.68 87.64,27.82 87.74,27.91 88.42,27.91 88.51,28.01 88.51,28.15 88.42,28.25 86.8,28.25 86.7,28.35 86.7,28.49 86.8,28.59 87.49,28.59 87.58,28.68 87.58,28.82 87.49,28.92 86.8,28.92 86.7,29.02 86.7,29.16 86.8,29.26 87.39,29.26 87.49,29.35 87.49,29.49 87.39,29.59 86.8,29.59 86.7,29.69 86.7,29.83 86.8,29.93 87.45,29.93 87.55,30.02 87.55,30.16 87.45,30.26 86.8,30.26 86.7,30.36 86.7,30.5 86.8,30.6 87.35,30.6 87.45,30.7 87.45,30.83 87.35,30.93 86.8,30.93 86.7,31.03 86.7,31.17 86.8,31.27 87.43,31.27 87.53,31.37 87.53,31.5 87.43,31.6 87.09,31.6 86.99,31.7 86.99,31.84 87.09,31.94 87.71,31.94 87.94,32.17 87.94,32.5 87.85,32.6 87.85,35.08 88.06,35.3 88.06,37.65 87.66,38.06 87.66,42.97 89.21,44.52 90.05,44.52 90.54,44.02 90.91,44.02 91.38,43.55 91.68,43.55 92.16,44.02 92.53,44.02 93.04,44.53 93.4,44.53 93.89,45.02 94.25,45.02 94.77,45.54 95.13,45.54 95.4,45.81 95.4,46.04 95.21,46.23 95.21,46.71 v1(95,46.93)
DDR4_DIMM_CH3_DQ49: length 60.2
  L05_SIG2 w0.081: v1(86.59,18.8) 86.59,18.34 86.26,18 81.45,18 81.05,18.41 81.05,19.03 80.84,19.23 80.7,19.23 79.4,20.53 78.57,22.55 78.57,23.45 78.67,23.55 78.81,23.55 78.9,23.45 78.9,22.64 79,22.55 79.14,22.55 79.24,22.64 79.24,24.14 79.14,24.24 78.67,24.24 78.57,24.34 78.57,26.65 78.37,26.85 78.37,30.01 76.83,31.54 76.83,32.52 76.71,32.65 76.71,41.42 80.28,44.99 80.28,46.02 81.12,46.86 82.11,46.86 84.55,49.3 90.09,49.3 90.35,49.04 91.02,49.04 91.28,49.31 91.95,49.31 92.2,49.05 92.63,49.05 92.88,49.3 93.62,49.3 93.87,49.05 94.31,49.05 94.56,49.3 95.19,49.3 95.41,49.08 95.41,47.35 95.86,46.9 v1(95.86,46.43)
DDR4_DIMM_CH3_DQ50: length 60.4
  L05_SIG2 w0.081: v1(95,47.93) 95,48.27 94.46,48.81 93.71,48.81 93.45,48.54 92.92,48.54 92.66,48.8 92.13,48.8 91.81,48.48 91.27,48.48 90.93,48.83 90.39,48.83 90.11,48.55 86.8,48.55 86.7,48.45 86.7,48.17 86.61,48.07 86.47,48.07 86.37,48.17 86.37,48.45 86.27,48.55 84.52,48.55 82.38,46.42 81.62,46.42 81.28,46.07 81.28,45.48 77.04,41.25 77.04,32.85 78.87,31.02 78.87,28.85 78.97,28.75 79.11,28.75 79.21,28.85 79.21,30.54 79.31,30.64 79.45,30.64 79.54,30.54 79.54,28.83 79.64,28.73 79.78,28.73 79.88,28.83 79.88,29.78 79.98,29.88 80.12,29.88 80.22,29.78 80.22,28.44 80.12,28.34 78.97,28.34 78.87,28.25 78.87,26.89 78.97,26.79 79.11,26.79 79.21,26.89 79.21,27.91 79.31,28.01 79.45,28.01 79.54,27.91 79.54,26.9 79.64,26.8 79.78,26.8 79.88,26.9 79.88,27.91 79.98,28.01 80.12,28.01 80.22,27.91 80.22,26.17 80.43,25.96 81.54,25.96 81.64,25.86 81.64,25.64 81.54,25.54 79.03,25.54 78.93,25.44 78.93,25.31 79.03,25.2 81.08,25.2 v1(81.49,24.8)
DDR4_DIMM_CH3_DQ51: length 60
  L05_SIG2 w0.081: v1(95.86,47.43) 96.28,47.85 96.28,49.54 95.98,49.84 95.57,49.84 95.27,49.54 94.8,49.54 94.49,49.85 93.74,49.85 93.45,49.55 93.08,49.55 92.77,49.87 92.1,49.87 91.78,49.54 91.31,49.54 90.96,49.9 90.43,49.9 90.08,49.55 89.43,49.55 89.06,49.93 84.65,49.93 80.58,47.76 80.37,47.52 80.12,47.2 79.34,46.42 79.34,44.54 76.33,41.53 76.33,33.23 75.95,32.84 75.95,32.21 76.41,31.76 76.41,28.63 76.31,28.53 75.89,28.53 75.8,28.63 75.8,30.86 75.69,30.96 75.31,30.96 75.2,30.86 75.2,27.99 75.68,27.51 76.63,27.51 76.82,27.32 76.82,25.96 77.66,25.12 77.66,22.26 77.5,22.1 77.5,21.19 79.9,18.8 v1(80.64,18.8)
DDR4_DIMM_CH3_DQ52: length 57.1
  L05_SIG2 w0.081: v1(91.53,47.93) 92.58,47.93 92.97,48.31 93.66,48.31 94.14,47.83 94.39,47.83 94.77,47.45 95,47.45 95.46,46.99 95.46,46.29 95.64,46.12 95.64,45.74 95.22,45.32 94.85,45.32 94.34,44.81 93.98,44.81 93.49,44.32 93.12,44.32 92.62,43.82 92.24,43.82 91.77,43.34 91.29,43.34 90.82,43.81 90.46,43.81 89.96,44.31 89.49,44.31 88.95,43.77 88.95,43.46 88.85,43.36 88.53,43.36 88.43,43.26 88.43,43.12 88.53,43.03 88.85,43.03 88.95,42.93 88.95,42.79 88.85,42.69 88.24,42.69 88.14,42.59 88.14,42.45 88.24,42.35 88.85,42.35 88.95,42.26 88.95,42.12 88.85,42.02 88.1,42.02 88.01,41.92 88.01,41.78 88.1,41.68 88.85,41.68 88.95,41.59 88.95,41.45 88.85,41.35 88.1,41.35 88.01,41.25 88.01,41.11 88.1,41.01 88.85,41.01 88.95,40.92 88.95,40.78 88.85,40.68 88.1,40.68 88.01,40.58 88.01,40.44 88.1,40.34 88.85,40.34 88.95,40.24 88.95,40.11 88.85,40.01 88.1,40.01 88.01,39.91 88.01,39.77 88.1,39.67 88.85,39.67 88.95,39.57 88.95,39.44 88.85,39.34 88.1,39.34 88.01,39.24 88.01,39.1 88.1,39 88.85,39 88.95,38.9 88.95,38.76 88.85,38.67 88.1,38.67 88.01,38.57 88.01,38.43 88.1,38.33 88.79,38.33 88.89,38.23 88.89,38.05 88.79,37.95 88.56,37.95 88.4,37.79 88.4,34.84 88.5,34.74 88.79,34.74 88.88,34.64 88.88,34.5 88.79,34.4 88.28,34.4 88.18,34.3 88.18,34.16 88.28,34.06 88.81,34.06 88.91,33.97 88.91,33.83 88.81,33.73 88.28,33.73 88.18,33.63 88.18,33.49 88.28,33.39 88.77,33.39 88.87,33.3 88.87,33.16 88.77,33.06 88.28,33.06 88.18,32.96 88.18,32.76 88.46,32.48 88.46,32.23 88.95,31.74 88.95,31.54 88.85,31.44 88,31.44 87.9,31.35 87.9,31.21 88,31.11 88.85,31.11 88.95,31.01 88.95,30.87 88.85,30.77 88,30.77 87.9,30.68 87.9,30.54 88,30.44 88.85,30.44 88.95,30.34 88.95,30.2 88.85,30.1 88,30.1 87.9,30.01 87.9,29.87 88,29.77 88.85,29.77 88.95,29.67 88.95,29.53 88.85,29.43 88,29.43 87.9,29.33 87.9,29.2 88,29.1 88.85,29.1 88.95,29 88.95,27.07 88.71,26.83 88.71,25.23 v1(89.14,24.8)
DDR4_DIMM_CH3_DQ53: length 56.8
  L05_SIG2 w0.081: v1(88.29,18.8) 87.64,18.8 87.15,19.28 86.53,19.28 86.2,18.95 86.2,18.66 85.88,18.34 83.09,18.34 82.77,18.66 82.77,18.92 81.91,19.77 81.35,19.77 80.55,20.58 80.55,22.4 81.84,23.7 84.19,23.7 84.43,23.94 84.43,25.21 83.62,26.01 83.62,30 83.72,30.1 84.28,30.1 84.38,30.2 84.38,30.34 84.28,30.44 83.72,30.44 83.62,30.53 83.62,30.67 83.72,30.77 84.28,30.77 84.38,30.87 84.38,31.01 84.28,31.11 83.72,31.11 83.62,31.21 83.62,31.49 83.13,31.98 80.74,31.98 80.13,32.59 80.13,35.19 78.06,37.26 78.06,40.74 80.18,42.87 80.55,42.87 84.31,46.63 88.03,46.63 88.58,47.18 89.25,47.18 89.37,47.3 89.97,47.3 90.31,46.96 90.9,46.96 91.32,46.55 92.28,46.55 v1(92.4,46.43)
DDR4_DIMM_CH3_DQ54: length 57.1
  L05_SIG2 w0.081: v1(92.4,47.43) 92.28,47.54 91.39,47.54 90.91,48.02 90.24,48.02 89.91,48.34 89.5,48.34 89.11,47.96 88.02,47.96 87.7,47.64 86.15,47.64 85.94,47.86 84.4,47.86 80.3,43.75 80.1,43.75 77.38,41.03 77.38,36.64 79.41,34.6 79.41,34.46 79.31,34.36 79.17,34.36 77.78,35.76 77.64,35.76 77.55,35.66 77.55,35.52 79.37,33.7 79.37,33.56 79.27,33.46 79.13,33.46 77.75,34.84 77.61,34.84 77.51,34.74 77.51,34.6 78.86,33.26 78.86,33.12 78.76,33.02 78.62,33.02 77.65,33.99 77.51,33.99 77.42,33.89 77.42,33.75 78.56,32.61 78.56,32.04 80.71,29.89 80.71,28.89 80.81,28.79 80.94,28.79 81.04,28.89 81.04,29.6 81.14,29.7 81.27,29.7 81.38,29.6 81.38,29.18 81.48,29.08 81.61,29.08 81.71,29.18 81.71,29.44 81.81,29.54 81.97,29.54 82.07,29.44 82.07,28.08 81.86,27.86 80.91,27.86 80.81,27.76 80.81,27.63 80.91,27.53 82.11,27.53 82.21,27.43 82.21,27.29 82.11,27.19 80.93,27.19 80.83,27.09 80.83,26.96 80.93,26.86 81.65,26.86 81.92,26.59 81.92,26.07 v1(83.19,24.8)
DDR4_DIMM_CH3_DQ55: length 56.8
  L05_SIG2 w0.081: v1(82.34,18.8) 81.74,19.4 81.25,19.4 79.75,20.89 79.75,21.41 80.17,21.84 80.17,22.2 79.75,22.62 79.75,24.14 79.92,24.31 83.25,24.31 83.57,24.64 83.57,25.06 82.78,25.85 82.78,27.98 82.49,28.27 82.49,28.73 83.18,29.42 83.18,31.42 83.08,31.52 82.94,31.52 82.84,31.42 82.84,30.16 82.74,30.06 82.61,30.06 82.51,30.16 82.51,31.48 82.4,31.59 82.27,31.59 82.17,31.48 82.17,30.22 82.07,30.11 81.94,30.11 81.84,30.22 81.84,31.48 81.73,31.59 81.6,31.59 81.5,31.48 81.5,30.51 81.4,30.41 81.27,30.41 81.17,30.51 81.17,30.89 81.06,30.99 80.47,30.99 79.41,32.06 79.41,32.63 79.78,33 79.78,34.81 77.72,36.86 77.72,40.89 80.16,43.33 80.54,43.33 84.17,46.96 87.82,46.96 88.4,47.55 90.07,47.55 90.32,47.81 90.82,47.81 91.18,47.45 91.18,47.28 v1(91.53,46.93)
DDR4_DIMM_CH3_DQ56: length 53.3
  L07_SIG3 w0.089: v1(95,48.93) 94.57,48.5 94.57,48.34 94.29,48.05 93.92,48.05 93.42,47.55 93.05,47.55 92.55,47.05 92.19,47.05 91.69,46.55 91.38,46.55 90.87,47.05 90.45,47.05 89.95,46.55 89.55,46.55 89.22,46.23 88.96,46.12 87.92,45.08 87.92,39.8 86.77,38.64 86.77,36.4 83.83,33.46 83.44,33.46 83.29,33.61 83.29,33.97 83.19,34.08 83.01,34.08 82.91,33.97 82.91,33.38 82.81,33.28 82.53,33.28 82.43,33.38 82.43,34.01 82.33,34.11 82,34.11 81.9,34.01 81.9,32.2 81.42,31.72 81.42,29.84 81.3,29.72 80.86,29.72 80.75,29.62 80.75,29.4 80.86,29.3 82.05,29.3 82.15,29.2 82.15,29.04 82.05,28.94 80.07,28.94 79.97,28.84 79.97,28.57 80.07,28.47 81.16,28.47 81.26,28.37 81.26,28.15 81.16,28.05 79.72,28.05 79.62,27.94 79.62,27.68 79.72,27.58 82.04,27.58 82.14,27.48 82.14,27.31 82.04,27.21 79.4,27.21 79.3,27.11 79.3,26.92 79.4,26.82 81.8,26.82 81.9,26.72 81.9,26.16 81.77,26.03 78.71,26.03 78.09,25.41 v1(78.09,24.8)
DDR4_DIMM_CH3_DQ57: length 53.1
  L07_SIG3 w0.089: v1(77.24,18.8) 77.24,19.74 77.95,20.45 78.92,20.45 79.02,20.55 79.02,20.69 78.92,20.79 78.37,20.79 78.27,20.89 78.27,21.02 78.37,21.12 78.92,21.12 79.02,21.22 79.02,21.36 78.92,21.46 78.37,21.46 78.27,21.56 78.27,21.69 78.37,21.79 78.92,21.79 79.02,21.89 79.02,22.03 78.92,22.13 78.14,22.13 78.04,22.23 78.04,22.37 78.14,22.46 78.92,22.46 79.02,22.56 79.02,22.7 78.92,22.8 77.84,22.8 77.74,22.9 77.74,23.04 77.84,23.13 78.92,23.13 79.02,23.23 79.02,23.37 78.92,23.47 77.88,23.47 77.79,23.57 77.79,23.71 77.88,23.8 78.92,23.8 79.02,23.9 79.02,24.04 78.92,24.14 78.66,24.14 78.49,24.31 78.49,25.07 79.07,25.65 82.25,25.65 82.75,26.15 82.75,28.04 82.5,28.29 82.5,28.68 82.79,28.97 82.79,31.54 83.72,32.47 83.72,32.79 87.11,36.18 87.11,38.29 88.44,39.62 88.44,45.11 89.64,46.3 90.01,46.3 90.51,46.8 90.82,46.8 91.29,46.33 91.77,46.33 92.24,46.8 92.6,46.8 93.1,47.3 93.47,47.3 93.97,47.8 94.34,47.8 94.99,48.46 95.06,48.46 95.38,48.78 95.38,49.54 v1(95,49.93)
DDR4_DIMM_CH3_DQ58: length 54.4
  L07_SIG3 w0.089: v1(72.14,24.79) 71.7,25.23 71.7,31.85 71.8,31.95 72.07,31.95 72.17,31.85 72.17,29.76 72.27,29.65 72.47,29.65 72.57,29.76 72.57,32.6 73.06,33.09 73.06,36.02 73.16,36.12 73.39,36.12 73.49,36.02 73.49,34.04 73.59,33.94 73.73,33.94 74.56,34.76 74.56,38.05 74.02,38.59 74.02,40.03 74.35,40.36 74.65,40.36 79.26,44.96 79.26,45.98 79.66,46.39 82.44,46.39 84.6,48.54 86.01,48.54 86.59,49.12 86.59,49.34 87.3,50.04 88.17,50.04 88.68,50.55 89.96,50.55 90.45,51.05 90.87,51.05 91.48,50.45 91.8,50.45 92.2,50.05 92.78,50.05 93.03,50.31 93.48,50.31 93.97,50.81 94.28,50.81 94.79,50.3 95.74,50.3 v1(95.86,50.43)
DDR4_DIMM_CH3_DQ59: length 54.4
  L07_SIG3 w0.089: v1(95.86,49.43) 95.62,49.19 95.62,48.72 95.37,48.47 95.37,47.77 95.15,47.55 94.79,47.55 94.29,47.05 93.92,47.05 93.42,46.55 93.05,46.55 92.55,46.05 90.46,46.05 89.96,45.55 89.42,45.55 88.93,45.06 88.93,39.4 87.96,38.42 87.96,36.14 87.71,35.89 87.31,35.89 84.07,32.64 84.07,32.28 83.58,31.79 83.58,25.74 83.11,25.28 79.65,25.28 79.38,25.01 79.38,20.59 79.55,20.43 80.19,20.43 80.29,20.33 80.29,20.13 80.19,20.03 78.36,20.03 78.27,19.93 78.27,19.79 78.36,19.69 79.28,19.69 79.38,19.59 79.38,18.64 78.75,18 72.08,18 v1(71.29,18.8)
DDR4_DIMM_CH3_DQ60: length 51.2
  L07_SIG3 w0.089: v1(79.79,24.8) 81.34,23.24 84.79,23.24 84.9,23.34 84.9,23.58 84.79,23.69 81.61,23.69 81.3,23.99 81.3,24.26 81.41,24.36 83.6,24.36 84.47,25.23 84.47,32.54 86.84,34.92 87.84,34.92 88.32,35.4 88.32,38.08 89.31,39.06 89.31,44.98 89.63,45.3 90.01,45.3 90.51,45.8 92.6,45.8 93.1,46.3 93.47,46.3 93.97,46.8 94.34,46.8 94.84,47.3 95.21,47.3 95.83,47.92 95.97,47.92 96.28,48.24 96.28,50.57 96.04,50.81 95.43,50.81 95.16,50.54 94.85,50.54 94.37,51.02 93.89,51.02 93.41,50.55 92.8,50.55 92.68,50.43 v1(92.4,50.43)
DDR4_DIMM_CH3_DQ61: length 51.4
  L07_SIG3 w0.089: v1(92.4,49.43) 92.28,49.54 91.39,49.54 90.87,50.05 90.45,50.05 89.95,49.55 88.9,49.55 88.37,49.33 87.64,49.33 87.35,49.04 87.35,48.82 86.33,47.81 85.57,47.81 85.26,47.5 85.26,47.26 84.91,46.91 84.24,46.91 81.95,44.62 79.95,44.62 75.75,40.42 75.75,39.4 76.51,38.64 76.51,33.86 75.83,33.18 75.15,33.18 74.28,32.31 74.28,30.37 72.98,29.06 72.98,27.12 72.57,26.71 72.57,25.8 73.44,24.92 73.44,18.59 73.64,18.39 78.54,18.39 v1(78.94,18.8)
DDR4_DIMM_CH3_DQ62: length 49.4
  L07_SIG3 w0.089: v1(73.84,24.8) 73.84,25.13 73.4,25.57 73.4,28.88 73.5,28.98 73.71,28.98 73.81,28.88 73.81,27.82 73.91,27.71 74.17,27.71 74.27,27.82 74.27,28.76 74.49,28.98 74.49,29.95 74.59,30.06 74.8,30.06 74.9,29.95 74.9,28.87 75,28.76 75.19,28.76 75.3,28.87 75.3,30.42 75.4,30.52 75.59,30.52 75.69,30.42 75.69,29.57 75.79,29.47 75.96,29.47 76.07,29.57 76.07,30.66 75.08,31.64 75.08,32.57 75.34,32.82 76,32.82 76.96,33.77 76.96,41.14 80.05,44.23 82.33,44.23 83.04,44.94 85.46,44.94 85.57,45.04 85.57,45.29 85.46,45.39 84,45.39 83.9,45.5 83.9,46.08 84,46.18 85.33,46.18 87.56,48.42 89.72,49.31 90.02,49.31 90.51,49.8 90.82,49.8 91.53,49.1 v1(91.53,48.93)
DDR4_DIMM_CH3_DQ63: length 49.2
  L07_SIG3 w0.089: v1(91.53,49.93) 91.28,50.18 91.28,50.35 90.82,50.8 90.51,50.8 90.01,50.31 89.72,50.31 88.19,49.67 87.47,49.67 86.95,49.16 86.95,48.94 86.17,48.16 84.8,48.16 81.85,45.21 80.05,45.21 75.41,40.56 75.41,34.25 74.3,33.15 73.98,33.15 73.43,32.6 73.43,30.08 72.54,29.19 72.54,27.4 72.2,27.05 72.2,25.41 72.53,25.07 72.53,24.42 72.15,24.04 72.15,21.85 72.26,21.75 72.5,21.75 72.6,21.85 72.6,23.75 72.7,23.85 72.89,23.85 72.99,23.75 v1(72.99,18.8)
DDR4_DIMM_CH3_DQ64: length 86.4
  L14_SIG5 w0.081: v1(152.09,24.8) 152.59,24.8 153.28,24.11 153.28,23.24 153.38,23.14 153.56,23.14 153.66,23.24 153.66,24.26 152.63,25.28 152.63,25.5 150.5,27.63 147.39,27.63 145.71,26.26 145.12,25.87 144.52,25.26 143.12,25.26 143.02,25.16 143.02,24.99 143.12,24.89 143.77,24.89 143.88,24.79 143.88,24.61 143.77,24.51 142.99,24.51 142.73,24.25 141.6,24.25 141.42,24.07 139.77,24.07 139.63,24.2 139.03,24.2 138.82,23.99 137.07,23.99 136.9,24.17 136.59,24.17 136.41,23.99 134.6,23.99 134.37,24.22 133.76,24.22 133.64,24.09 132.2,24.09 132.07,24.22 131.21,24.22 131.08,24.09 129.92,24.09 129.25,23.43 127.09,23.43 126.87,23.64 125.73,23.64 125.63,23.54 125.63,22.76 125.53,22.66 125.39,22.66 125.29,22.76 125.29,23.54 125.2,23.64 122.85,23.64 121.15,21.94 120.38,21.94 120.03,21.59 113.81,21.59 113.19,22.21 111.45,22.21 109.92,23.74 109.92,24.99 109.39,25.52 109.39,26.42 108.27,27.55 108.27,32.75 108.37,32.84 109.11,32.84 109.21,32.94 109.21,33.08 109.11,33.18 108.17,33.18 108.08,33.28 108.08,33.42 108.17,33.52 109.12,33.52 109.22,33.61 109.22,33.75 109.12,33.85 108.16,33.85 108.07,33.95 108.07,34.09 108.16,34.19 108.74,34.19 108.84,34.28 108.84,34.42 108.74,34.52 108.37,34.52 108.27,34.62 108.27,35.04 108.41,35.18 108.41,44.58 108.05,44.95 107.8,44.95 107.57,45.18 107.57,46.01 107.29,46.29 107.29,46.76 v1(107.12,46.93)
DDR4_DIMM_CH3_DQ65: length 85.4
  L14_SIG5 w0.081: v1(151.19,18.8) 151.19,20.22 154.17,23.21 154.17,25.09 153.26,26 153.26,26.57 152.3,27.53 151.69,27.53 150.86,28.36 146.85,28.36 146.4,27.9 145.65,27.9 144.8,27.04 144.21,27.04 143.98,26.82 143.98,26.25 143.73,26 142.82,26 141.99,25.17 139.97,25.17 139.83,25.03 138.76,25.03 138.62,25.17 129.55,25.17 129.37,24.99 128.65,24.99 128.52,25.12 127.09,25.12 126.87,24.9 126.87,24.59 126.59,24.31 121.95,24.31 120.89,23.25 120.52,23.25 119.68,22.41 116.04,22.41 115.88,22.57 115.88,23.01 115.62,23.26 113.65,23.26 113.42,23.04 112.3,23.04 110.73,24.61 110.73,25.23 110.46,25.5 110.46,26.41 109.8,27.07 109.8,27.51 110.14,27.85 110.14,30.93 109.92,31.15 109.92,34.02 110.13,34.22 110.13,34.79 109.99,34.93 109.39,34.93 109.29,35.02 109.29,35.88 109.39,35.97 110,35.97 110.1,36.07 110.1,36.21 110,36.31 109.39,36.31 109.29,36.41 109.29,36.55 109.39,36.65 110,36.65 110.1,36.74 110.1,36.88 110,36.98 109.39,36.98 109.29,37.08 109.29,40.69 109.62,41.01 109.93,41.01 110.17,41.25 110.17,45.6 109.81,45.96 109.5,45.96 109.03,46.43 v1(107.99,46.43)
DDR4_DIMM_CH3_DQ66: length 86
  L14_SIG5 w0.081: v1(107.12,47.93) 106.07,47.93 105.82,47.68 105.82,41.18 106.05,40.95 106.31,40.95 106.64,40.62 106.64,32.22 106.52,32.1 106.52,31.25 106.59,31.18 106.59,26.16 107.41,25.34 107.41,24.57 107.92,24.06 107.92,22.03 108.66,21.29 108.93,21.29 109.19,21.55 110.04,21.55 110.15,21.45 110.15,21.32 110.04,21.22 109.42,21.22 109.32,21.12 109.32,20.98 109.42,20.88 110.69,20.88 110.79,20.78 110.79,20.65 110.69,20.55 109.61,20.55 109.51,20.44 109.51,20.31 109.61,20.21 113.15,20.21 114.09,19.27 114.28,19.27 114.38,19.17 114.38,18.5 114.48,18.4 114.61,18.4 114.71,18.5 114.71,19.17 114.81,19.27 115.9,19.27 116,19.17 116,18.5 116.09,18.4 116.23,18.4 116.33,18.5 116.33,19.17 116.43,19.27 117.59,19.27 117.68,19.17 117.68,18.53 117.78,18.44 117.92,18.44 118.02,18.53 118.02,19.17 118.12,19.27 118.26,19.27 118.36,19.17 118.36,18.53 118.45,18.44 118.59,18.44 118.69,18.53 118.69,19.17 118.79,19.27 118.93,19.27 119.03,19.17 119.03,18.53 119.12,18.44 119.26,18.44 119.36,18.53 119.36,19.17 119.46,19.27 122.45,19.27 122.75,18.97 124.73,18.97 127.63,21.88 129.99,21.88 130.54,22.43 144.25,22.43 145.09,23.26 146.56,23.26 146.67,23.37 146.67,23.5 146.56,23.6 145.55,23.6 145.45,23.7 145.45,23.83 145.55,23.93 146.47,23.93 146.57,24.04 146.57,24.69 146.47,24.8 v1(146.09,24.8)
DDR4_DIMM_CH3_DQ67: length 85.7
  L14_SIG5 w0.081: v1(145.24,18.8) 145.24,18.43 144.87,18.05 142.73,18.05 141.7,19.09 140.7,19.09 140.4,19.39 139.9,19.39 139.66,19.15 139.66,18.45 139.55,18.33 139.01,18.33 138.77,18.58 138.3,18.58 138.06,18.34 136.45,18.34 136.25,18.54 135.45,18.54 135.32,18.4 134,18.4 133.54,18.86 133.09,18.86 132.72,19.22 132.2,19.22 131.86,18.88 131.86,18.2 131.4,17.74 130.7,17.74 130.28,17.32 127.8,17.32 126.82,16.34 121.8,16.34 121.22,15.76 113.48,15.76 112.3,16.94 109.38,16.94 108.98,17.34 106.04,17.34 104.86,18.53 104.86,21.17 102.33,23.69 102.33,38.51 102.43,38.61 102.79,38.61 102.89,38.71 102.89,38.85 102.79,38.94 102.43,38.94 102.33,39.04 102.33,40.23 103.17,41.07 103.17,41.58 103.04,41.71 103.04,42.15 103.17,42.28 103.17,42.59 103.06,42.7 103.06,43.17 103.17,43.28 103.17,43.57 103.01,43.74 103.01,44.12 103.18,44.29 103.18,44.57 103,44.75 103,45.1 103.18,45.28 103.18,45.57 103.03,45.72 103.03,46.14 103.18,46.29 103.18,48.09 103.51,48.43 103.86,48.43 104.38,48.95 104.73,48.95 105.19,49.41 105.55,49.41 105.95,49.81 106.5,49.81 106.92,49.4 107.27,49.4 107.58,49.09 107.58,48.3 107.99,47.89 v1(107.99,47.43)
DDR4_DIMM_CH3_DQ68: length 82.7
  L14_SIG5 w0.081: v1(153.74,24.8) 152.98,25.56 152.98,25.64 150.6,28.01 147.1,28.01 146.64,27.56 145.79,27.56 144.84,26.6 144.84,26.23 144.25,25.64 142.98,25.64 142.13,24.79 141.57,24.79 141.18,24.4 139.91,24.4 139.77,24.54 138.76,24.54 138.55,24.32 137.21,24.32 137.03,24.5 136.45,24.5 136.27,24.32 134.74,24.32 134.45,24.62 133.69,24.62 133.5,24.43 132.34,24.43 132.21,24.55 131.07,24.55 130.95,24.43 128.8,24.43 128.55,24.17 127.09,24.17 126.9,23.98 122.44,23.98 120.88,22.43 120.32,22.43 119.93,22.03 115.39,22.03 115.29,22.13 115.29,22.82 115.19,22.91 115.05,22.91 114.95,22.82 114.95,22.13 114.86,22.03 114.72,22.03 114.62,22.13 114.62,22.82 114.52,22.91 114.38,22.91 114.28,22.82 114.28,22.13 114.18,22.03 113.91,22.03 113.32,22.61 112.19,22.61 110.37,24.44 110.37,25.1 110.06,25.41 110.06,26.29 109.22,27.14 109.22,29.85 108.87,30.2 108.87,30.56 109.57,31.26 109.57,34.2 108.87,34.91 108.87,41.26 109.27,41.66 109.27,45.16 109,45.43 108.7,45.43 108.24,45.89 107.99,45.89 107.58,46.3 107.58,48 107.19,48.39 106.96,48.39 106.49,48.86 105.97,48.86 105.64,48.53 105.16,48.53 104.55,47.93 v1(103.66,47.93)
DDR4_DIMM_CH3_DQ69: length 82.3
  L14_SIG5 w0.081: v1(104.52,47.43) 104.03,46.93 104.03,46.77 103.89,46.64 103.89,46.22 104.03,46.08 104.03,45.77 103.89,45.64 103.89,45.24 104.04,45.09 104.04,44.78 103.9,44.64 103.9,44.23 104.04,44.08 104.04,43.77 103.86,43.59 103.86,43.24 104.03,43.08 104.03,42.77 103.87,42.62 103.87,42.24 104.03,42.08 104.03,41.77 103.76,41.51 103.76,35.15 104.01,34.9 104.01,23.05 106.51,20.55 106.51,18.29 106.79,18.01 109.26,18.01 109.66,17.61 112.57,17.61 113.76,16.43 120.95,16.43 121.53,17.01 126.54,17.01 127.96,18.43 128.4,18.43 128.78,18.81 129.43,18.81 130.85,20.23 131.79,20.23 131.94,20.08 134.99,20.08 135.7,19.36 136.1,19.36 136.35,19.61 137.97,19.61 138.23,19.35 138.59,19.35 139.48,20.24 141.11,20.24 141.45,19.89 141.93,19.89 142.49,19.34 144.64,19.34 144.91,19.6 145.62,19.6 145.88,19.34 147.03,19.34 147.36,19.01 147.36,18.61 147.63,18.33 151.31,18.33 151.77,18.8 v1(152.89,18.8)
DDR4_DIMM_CH3_DQ70: length 82.8
  L14_SIG5 w0.081: v1(104.52,46.43) 104.26,46.16 104.26,45.69 104.15,45.58 104.15,45.27 104.26,45.17 104.26,44.69 104.15,44.58 104.15,44.27 104.26,44.17 104.26,43.69 104.15,43.58 104.15,43.27 104.26,43.17 104.26,42.69 104.15,42.58 104.15,42.27 104.24,42.18 104.24,41.67 104.12,41.55 104.12,35.3 104.81,34.61 104.81,22.73 107.34,20.2 107.34,19.28 108.21,18.41 112.25,18.41 113.9,16.76 120.81,16.76 121.39,17.34 126.4,17.34 127.69,18.64 127.69,18.91 128,19.22 129.34,19.22 130.69,20.56 131.93,20.56 132.07,20.42 135.45,20.42 135.63,20.25 138.81,20.25 139.2,20.63 141.25,20.63 141.63,20.25 148.39,20.25 149.86,21.72 149.86,23.16 149.68,23.34 149.21,23.34 149.11,23.44 149.11,23.6 149.21,23.7 150.56,23.7 150.66,23.8 150.66,23.99 150.56,24.1 149.16,24.1 148.79,24.46 148.12,24.46 v1(147.79,24.8)
DDR4_DIMM_CH3_DQ71: length 82.6
  L14_SIG5 w0.081: v1(103.66,46.93) 103.45,46.73 103.45,46.25 103.27,46.07 103.27,45.79 103.45,45.6 103.45,45.25 103.28,45.08 103.28,44.77 103.45,44.6 103.45,44.27 103.27,44.09 103.27,43.77 103.48,43.57 103.48,43.28 103.28,43.08 103.28,42.77 103.48,42.58 103.48,42.28 103.28,42.08 103.28,41.77 103.43,41.63 103.43,34.99 103.55,34.86 103.55,33.06 103.1,32.61 103.1,32.21 103.27,32.04 103.27,31.48 103.17,31.38 102.81,31.38 102.71,31.29 102.71,31.15 102.81,31.05 103.58,31.05 103.68,30.95 103.68,30.81 103.58,30.71 102.81,30.71 102.71,30.62 102.71,30.48 102.81,30.38 103.54,30.38 103.64,30.28 103.64,30.14 103.54,30.04 102.81,30.04 102.71,29.94 102.71,29.81 102.81,29.71 103.5,29.71 103.6,29.61 103.6,29.47 103.5,29.37 102.81,29.37 102.71,29.27 102.71,29.14 102.81,29.04 103.12,29.04 103.22,28.94 103.22,23.35 105.66,20.91 105.66,18.44 106.42,17.68 109.12,17.68 109.52,17.28 112.43,17.28 113.62,16.09 121.09,16.09 121.67,16.67 126.68,16.67 127.66,17.66 129.78,17.66 130.42,18.3 130.42,18.95 130.64,19.17 131.64,19.17 132.21,19.74 134.7,19.74 135.48,18.96 136.36,18.96 136.66,19.26 137.84,19.26 138.09,19.01 138.81,19.01 139.56,19.76 140.5,19.76 140.84,19.42 141.84,19.42 142.87,18.39 144.58,18.39 144.83,18.64 144.83,18.95 145.08,19.2 145.44,19.2 145.83,18.8 v1(146.94,18.8)
DDR4_DIMM_CH3_DQS_N0: length 94.5
  L05_SIG2 w0.079: v1(186.89,18.8) 186.55,19.14 186.55,19.73 186.66,19.84 187.43,19.84 187.72,20.12 187.72,20.68 187.43,20.97 186.8,20.97 186.56,21.21 186.56,21.71 186.8,21.95 187.46,21.95 189.17,23.66 189.17,24.26 188.8,24.63 188.8,25.38 187.21,26.97 185.03,28.43 179.16,30.86 177.34,32.07 177.1,32.31 176.13,32.96 175.7,33.14 174.22,33.43 169.69,33.88 150.25,33.88 147.77,34.37 147.33,34.51 145.38,35.21 140.92,37.05 139.01,37.05 137.03,37.82 135.83,38.04 135.68,38.04 135.53,38.09 134.37,38.95 134.14,39.02 133.52,39.12 127.13,41.05 120.96,41.05 120.76,41.26 120.55,41.26 120.35,41.05 120.07,41.05 arc(119.96,41.08) 119.87,41.14 119.65,41.38 arc(119.48,41.5) 119.27,41.54 119.23,41.54 arc(119.1,41.57) 119,41.64 118.78,41.88 arc(118.61,42) 118.41,42.04 118.36,42.04 arc(118.24,42.07) 118.13,42.14 117.91,42.38 arc(117.74,42.5) 117.54,42.54 117.49,42.54 arc(117.37,42.57) 117.27,42.64 117.05,42.88 arc(116.88,43) 116.67,43.04 116.63,43.04 arc(116.51,43.07) 116.4,43.14 116.18,43.38 arc(116.01,43.5) 115.81,43.54 115.76,43.54 arc(115.64,43.57) 115.54,43.64 115.32,43.88 arc(115.15,44) 114.94,44.04 114.9,44.04 arc(114.77,44.07) 114.67,44.14 114.45,44.38 arc(114.28,44.5) 114.08,44.54 114.03,44.54 arc(113.91,44.57) 113.8,44.64 113.58,44.88 arc(113.41,45) 113.21,45.04 113.16,45.04 arc(113.04,45.07) 112.94,45.13 112.88,45.19 arc(112.83,45.27) 112.81,45.37 112.81,45.54 112.92,45.8 112.92,46.06 112.81,46.33 112.81,46.55 112.92,46.81 112.92,47.08 112.81,47.35 112.64,47.52 112.44,47.52 112.32,47.64 v1(112.32,47.93)
DDR4_DIMM_CH3_DQS_N1: length 92.6
  L07_SIG3 w0.085: v1(177.54,18.8) 177.23,19.11 177.23,22.76 179,24.53 179,25.94 177.43,27.5 177.43,28.18 174.58,31.03 168.95,31.03 167.38,32.6 167.38,33.24 165.04,35.58 164.67,35.58 163.21,37.04 155.01,37.04 154.7,37.35 154.7,40.78 152.31,43.16 148.59,43.16 144.45,39.02 143.84,39.02 142.44,40.42 139.61,40.42 138.49,41.54 138.25,41.54 arc(138.12,41.57) 138.02,41.65 137.87,41.85 arc(137.69,41.99) 137.47,42.04 137.38,42.04 arc(137.26,42.07) 137.16,42.15 137,42.35 arc(136.82,42.49) 136.6,42.54 136.52,42.54 arc(136.39,42.57) 136.29,42.65 136.14,42.85 arc(135.96,42.99) 135.73,43.04 135.65,43.04 arc(135.42,42.99) 135.24,42.85 135.09,42.65 arc(134.99,42.57) 134.87,42.54 134.78,42.54 arc(134.66,42.57) 134.56,42.65 134.41,42.85 arc(134.23,42.99) 134,43.04 133.92,43.04 arc(133.79,43.07) 133.69,43.15 133.54,43.35 arc(133.36,43.49) 133.14,43.54 133.05,43.54 arc(132.93,43.57) 132.83,43.65 132.67,43.85 arc(132.49,43.99) 132.27,44.04 132.19,44.04 arc(132.06,44.07) 131.96,44.15 131.81,44.35 arc(131.63,44.49) 131.4,44.54 131.32,44.54 arc(131.19,44.57) 131.09,44.65 130.94,44.85 arc(130.76,44.99) 130.54,45.04 130.45,45.04 arc(130.33,45.07) 130.23,45.15 130.08,45.35 arc(129.9,45.49) 129.67,45.54 129.59,45.54 arc(129.46,45.57) 129.36,45.65 129.21,45.85 arc(129.03,45.99) 128.81,46.04 128.72,46.04 arc(128.6,46.07) 128.5,46.15 128.34,46.35 arc(128.16,46.49) 127.94,46.54 127.86,46.54 arc(127.73,46.57) 127.63,46.65 127.48,46.85 arc(127.3,46.99) 127.07,47.04 126.99,47.04 arc(126.86,47.07) 126.76,47.15 126.61,47.35 arc(126.43,47.49) 126.21,47.54 125.75,47.54 125.25,48.04 123.53,48.04 arc(123.4,48.07) 123.3,48.15 123.15,48.35 arc(122.97,48.49) 122.74,48.54 122.66,48.54 arc(122.43,48.49) 122.25,48.34 122.1,48.15 arc(122,48.07) 121.88,48.04 121.79,48.04 arc(121.67,48.07) 121.57,48.15 121.42,48.35 arc(121.24,48.49) 121.01,48.54 120.93,48.54 arc(120.7,48.49) 120.52,48.34 120.37,48.15 arc(120.27,48.07) 120.15,48.04 120.06,48.04 arc(119.94,48.07) 119.84,48.15 119.68,48.35 arc(119.5,48.49) 119.28,48.54 119.2,48.54 arc(118.97,48.49) 118.79,48.34 118.64,48.15 arc(118.54,48.07) 118.41,48.04 116.6,48.04 arc(116.47,48.07) 116.37,48.15 116.22,48.35 arc(116.04,48.49) 115.82,48.54 115.73,48.54 arc(115.51,48.49) 115.33,48.34 115.17,48.15 arc(115.07,48.07) 114.95,48.04 114.87,48.04 arc(114.74,48.07) 114.64,48.15 114.49,48.35 arc(114.31,48.49) 114.08,48.54 114,48.54 arc(113.87,48.57) 113.77,48.65 113.62,48.85 arc(113.44,48.99) 113.22,49.04 113.11,49.04 112.98,49.09 112.87,49.21 112.8,49.36 112.62,49.54 112.47,49.54 112.32,49.69 v1(112.32,49.93)
DDR4_DIMM_CH3_DQS_N2: length 91.2
  L05_SIG2 w0.079: v1(168.19,18.8) 167.88,19.11 167.88,21.54 168.06,21.73 170.16,21.73 170.64,22.21 170.64,24.2 169.89,24.95 169.89,25.58 168.45,27.03 166.96,27.03 166.8,26.87 166.09,26.87 165.8,27.16 164.33,27.16 163.78,27.71 147.04,27.71 146.73,28.02 143.14,28.02 142.01,29.15 138.76,29.15 137.89,30.02 131.29,30.02 130.32,30.99 127.13,30.99 125.76,32.36 122.78,32.36 122.46,32.04 117.17,32.04 114.8,34.41 114.17,34.41 113.55,35.04 112.95,35.04 109.96,38.03 109.52,38.03 108.49,39.05 107.83,39.05 106.89,39.99 106.89,40.69 106.55,41.03 106.16,41.03 106.04,41.09 105.91,41.22 105.87,41.3 105.87,41.52 105.99,41.8 105.99,42.07 105.88,42.33 105.88,42.52 105.99,42.79 105.99,43.05 105.87,43.36 105.87,43.5 106,43.82 106,44.05 105.88,44.34 105.88,44.53 105.99,44.79 105.99,45.07 105.88,45.33 105.88,45.53 105.99,45.8 105.99,46.07 105.87,46.35 105.87,46.53 105.99,46.82 105.99,47.07 105.87,47.36 105.87,47.53 105.99,47.81 105.99,48.08 105.88,48.35 105.88,48.52 105.93,48.64 106.04,48.76 106.21,48.82 106.5,48.82 106.77,49.09 106.85,49.3 106.85,49.57 106.73,49.86 106.55,50.04 v1(106.25,50.43)
DDR4_DIMM_CH3_DQS_N3: length 73.4
  L07_SIG3 w0.085: v1(112.32,42.93) 112.32,42.68 112.5,42.49 112.62,42.49 112.84,42.27 112.92,42.09 112.92,41.8 112.8,41.52 112.8,40.28 113.04,40.04 113.43,40.04 113.88,39.59 113.88,38.73 114.59,38.03 125.57,38.03 126.57,37.04 127.34,37.04 128.33,36.05 129.02,36.05 130.23,34.83 132.02,34.83 133.01,33.84 135.67,33.84 137.5,32.02 142.52,32.02 144.66,29.88 158.01,29.88 161.18,26.71 161.18,25.86 160.56,25.24 160.56,24.74 159.55,23.72 159.55,23.3 159.65,23.2 160.63,23.2 160.89,22.93 160.89,22.31 160.63,22.05 158.67,22.05 158.54,21.92 158.54,21.55 158.67,21.42 160.52,21.42 160.76,21.19 160.76,20.56 160.52,20.33 158.71,20.33 158.6,20.23 158.6,19.03 v1(158.84,18.8)
DDR4_DIMM_CH3_DQS_N4: length 39.7
  L05_SIG2 w0.079: v1(103.59,18.8) 103.28,19.11 103.28,21.78 103.41,21.9 103.74,21.9 103.87,21.78 103.87,19.65 104.13,19.39 104.65,19.39 104.91,19.65 104.91,24.06 105.09,24.24 105.09,25.34 105.92,26.18 105.92,26.68 105.7,26.9 105.7,30.82 104.53,32 103.44,32 103.18,32.26 103.18,33.77 99.97,36.98 99.97,40.83 100.7,41.56 100.79,41.8 100.79,42.06 100.68,42.33 100.68,42.53 100.79,42.79 100.79,43.07 100.68,43.34 100.68,43.5 100.79,43.78 100.79,44.05 100.66,44.37 100.66,44.48 100.8,44.8 100.8,45.06 100.68,45.33 100.68,45.51 100.8,45.78 100.8,46.07 100.68,46.34 100.68,46.52 100.79,46.79 100.79,47.05 100.71,47.25 100.48,47.5 v1(100.19,47.93)
DDR4_DIMM_CH3_DQS_N5: length 40.6
  L14_SIG5 w0.079: v1(100.19,49.93) 100.48,49.54 100.67,49.36 100.8,49.04 100.8,48.81 100.71,48.58 100.44,48.32 100.05,48.32 99.86,48.12 99.82,48.01 99.82,47.85 99.93,47.57 99.93,47.29 99.85,47.1 99.67,46.91 99.43,46.81 99.29,46.81 arc(99.18,46.79) 99.1,46.73 98.84,46.46 arc(98.69,46.35) 98.51,46.31 98.42,46.31 arc(98.32,46.29) 98.23,46.23 97.97,45.96 arc(97.82,45.85) 97.64,45.81 97.61,45.81 97.46,45.78 97.39,45.75 97.27,45.64 97.22,45.52 97.22,45.33 97.33,45.05 97.33,44.81 97.25,44.6 97.06,44.41 96.83,44.31 96.66,44.31 96.52,44.26 96.4,44.14 96.35,44.01 96.35,43.84 96.47,43.56 96.47,43.31 96.35,43.03 96.35,42.82 96.46,42.56 96.46,42.31 96.35,42.03 96.35,41.86 96.47,41.56 97.34,40.69 97.34,39 97.11,38.78 97.11,33.64 97.41,33.34 97.41,31.61 97.21,31.41 97.21,28.06 96.32,27.17 96.32,26.92 96.57,26.67 96.57,26.03 96.01,25.48 96.01,24.8 94.12,22.9 94.12,21.24 94.24,21.12 96.02,21.12 96.35,20.79 96.35,20.3 96.02,19.97 94.22,19.97 93.94,19.7 93.94,19.04 v1(94.19,18.8)
DDR4_DIMM_CH3_DQS_N6: length 58.8
  L05_SIG2 w0.079: v1(94.13,47.43) 94.42,47.05 94.61,46.86 94.73,46.58 94.73,46.29 94.65,46.09 94.47,45.92 94.22,45.81 94.1,45.81 arc(93.99,45.79) 93.89,45.72 93.67,45.48 arc(93.49,45.36) 93.28,45.31 93.23,45.31 arc(93.12,45.29) 93.03,45.22 92.8,44.98 arc(92.63,44.86) 92.43,44.81 92.37,44.81 arc(92.25,44.79) 92.16,44.72 91.94,44.49 arc(91.76,44.36) 91.55,44.31 91.53,44.31 arc(91.3,44.36) 91.11,44.5 90.89,44.73 arc(90.81,44.79) 90.71,44.81 90.65,44.81 arc(90.43,44.86) 90.25,44.99 90,45.26 arc(89.94,45.3) 89.87,45.31 89.17,45.31 87.07,43.22 87.07,32.81 86.11,31.86 86.11,27.82 87.28,26.65 87.28,25.38 85.24,23.34 85.24,23.2 85.42,23.01 87.59,23.01 87.83,22.78 87.83,21.87 87.59,21.63 84.58,21.63 84.2,22.01 84.2,22.71 84.1,22.81 83.72,22.81 83.62,22.71 83.62,21.82 83.31,21.51 81.51,21.51 81.37,21.37 81.37,21.06 81.51,20.92 82.75,20.92 83.02,20.65 83.02,19.85 83.22,19.65 83.43,19.65 83.63,19.85 83.63,20.58 84.05,21 87.61,21 87.84,20.76 87.84,20.19 87.61,19.96 85.2,19.96 84.58,19.34 84.58,19.11 v1(84.89,18.8)
DDR4_DIMM_CH3_DQS_N7: length 52.9
  L07_SIG3 w0.085: v1(94.13,50.43) 94.36,50.2 94.64,49.77 94.73,49.56 94.73,49.37 arc(94.6,49.01) 94.27,48.83 94.02,48.8 arc(93.91,48.75) 93.82,48.66 93.78,48.59 arc(93.58,48.39) 93.31,48.31 93.23,48.31 arc(93.1,48.28) 93,48.2 92.85,48.01 arc(92.67,47.87) 92.44,47.81 92.36,47.81 arc(92.24,47.78) 92.14,47.7 91.98,47.51 arc(91.8,47.37) 91.58,47.31 91.49,47.31 arc(91.27,47.37) 91.09,47.51 90.94,47.7 arc(90.84,47.78) 90.71,47.81 90.63,47.81 arc(90.5,47.78) 90.4,47.7 90.25,47.51 arc(90.07,47.37) 89.85,47.31 89.54,47.31 89.09,46.86 88.72,46.86 87.27,45.4 87.27,40 86.15,38.88 86.15,36.74 84.13,34.72 79.41,34.72 79.24,34.55 79.24,33.75 79.41,33.59 80.14,33.59 80.52,33.2 80.52,32.04 80.13,31.64 80.13,29.89 76.81,26.57 76.81,26.07 77.04,25.83 77.04,24.57 76.85,24.38 76.85,23.87 76.55,23.57 75.41,23.57 75.31,23.47 75.31,22.96 75.41,22.86 76.51,22.86 76.75,22.63 76.75,21.99 76.51,21.75 75.23,21.75 75.13,21.65 75.13,21.25 75.23,21.15 76.55,21.15 76.78,20.91 76.78,20.16 76.55,19.93 75.66,19.93 75.24,19.51 75.24,19.09 v1(75.54,18.8)
DDR4_DIMM_CH3_DQS_N8: length 84.2
  L14_SIG5 w0.079: v1(106.25,47.43) 106.55,47.03 106.73,46.84 106.85,46.55 106.85,46.29 106.74,46.02 106.74,45.87 106.86,45.58 106.86,45.29 106.75,45.01 106.75,44.85 106.86,44.57 106.86,44.31 106.74,44.02 106.74,43.84 106.87,43.54 106.87,43.32 106.73,43 106.73,42.87 106.86,42.57 106.86,42.28 106.75,42.01 106.75,41.83 106.8,41.7 107.46,41.04 107.46,32.24 107.62,32.08 107.62,28.37 107.46,28.21 107.46,27 108.72,25.74 108.72,24.63 109.29,24.06 109.29,23.46 108.9,23.07 108.9,22.58 109.07,22.41 110.38,22.41 111.39,21.41 113.11,21.41 114.11,20.41 122.74,20.41 123.22,19.94 124.49,19.94 127.31,22.76 129.55,22.76 130.19,23.4 143.77,23.4 144.31,23.95 144.31,24.19 145.6,25.48 145.97,25.72 147.73,26.45 148.3,27.02 149.82,27.02 151.25,25.59 151.25,24.95 152.32,23.88 152.32,22.27 152.03,21.99 151.56,21.99 151.28,22.27 151.28,22.66 151.17,22.76 150.79,22.76 150.69,22.66 150.69,20.93 149.18,19.42 149.18,19.06 v1(149.44,18.8)
DDR4_DIMM_CH3_DQS_P0: length 93.9
  L05_SIG2 w0.079: v1(186.04,18.8) 186.32,19.07 186.32,19.82 186.56,20.07 187.34,20.07 187.49,20.22 187.49,20.59 187.34,20.74 186.7,20.74 186.33,21.11 186.33,21.8 186.7,22.18 187.36,22.18 188.94,23.76 188.94,24.16 188.57,24.53 188.57,25.29 187.06,26.79 184.92,28.23 179.05,30.66 177.2,31.89 176.96,32.13 176.02,32.76 175.63,32.92 174.19,33.21 169.68,33.65 150.23,33.65 147.72,34.15 147.26,34.29 145.29,34.99 140.87,36.83 138.96,36.83 136.97,37.59 135.81,37.81 135.64,37.81 135.42,37.88 134.27,38.74 134.08,38.8 133.47,38.89 127.1,40.82 120.07,40.82 arc(119.87,40.87) 119.7,40.99 119.48,41.22 arc(119.38,41.29) 119.27,41.31 119.23,41.31 arc(119.01,41.36) 118.83,41.49 118.61,41.72 arc(118.52,41.79) 118.41,41.81 118.36,41.81 arc(118.15,41.86) 117.97,41.99 117.75,42.22 arc(117.65,42.29) 117.54,42.31 117.49,42.31 arc(117.28,42.36) 117.1,42.49 116.88,42.72 arc(116.79,42.79) 116.67,42.81 116.63,42.81 arc(116.41,42.86) 116.23,42.99 116.02,43.22 arc(115.92,43.29) 115.81,43.31 115.76,43.31 arc(115.55,43.36) 115.37,43.49 115.15,43.72 arc(115.06,43.79) 114.94,43.81 114.9,43.81 arc(114.68,43.86) 114.5,43.99 114.28,44.22 arc(114.19,44.29) 114.08,44.31 114.03,44.31 arc(113.82,44.36) 113.64,44.49 113.42,44.72 arc(113.32,44.79) 113.21,44.81 113.16,44.81 arc(112.95,44.85) 112.78,44.97 112.72,45.03 arc(112.62,45.18) 112.58,45.37 112.58,45.58 112.69,45.85 112.69,46.02 112.58,46.28 112.58,46.59 112.69,46.86 112.69,47.04 112.61,47.22 112.55,47.29 112.42,47.29 112.32,47.19 v1(112.32,46.93)
