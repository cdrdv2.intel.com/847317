# Allegro board TS28247BC0_FM61_agilex_PCIe_DEVKIT_ADI_REVB1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
QSFPDD1_TX7_P: length 56.4
  L16_SIG6 w0.079: v1(92.4,53.43) 92.64,53.29 arc(92.69,53.22) 92.68,53.15 92.63,53.06 92.63,53.06 arc(92.57,53.02) 92.5,53.01 92.34,53.01 arc(92.18,53.05) 92.06,53.17 92,53.27 arc(91.8,53.47) 91.52,53.54 91.5,53.54 arc(91.23,53.47) 91.03,53.27 91,53.22 arc(90.9,53.1) 90.75,53.05 arc(90.72,53.04) 90.7,53.04 90.61,53.04 arc(90.45,53.08) 90.34,53.2 90.31,53.25 arc(90.27,53.31) 90.23,53.36 89.78,53.81 arc(89.52,53.98) 89.2,54.05 88.63,54.05 88.16,54.53 87.4,54.53 87,54.13 86.85,54.13 86.6,54.37 86.35,54.37 86.21,54.24 85.93,54.24 85.8,54.36 85.52,54.36 85.4,54.24 85.12,54.24 84.99,54.36 84.71,54.36 84.48,54.13 65.71,54.13 64.13,52.55 63.95,52.55 63.9,52.59 63.72,52.59 63.58,52.45 63.58,52.27 63.62,52.22 63.62,52.04 63.48,51.9 63.3,51.9 63.25,51.94 63.07,51.94 62.93,51.8 62.93,51.62 62.97,51.57 62.97,51.39 62.31,50.73 62.31,47.32 60.99,46 60.99,45.26 60.79,45.06 60.79,44.04 58.84,42.09 58.77,42.02 55.94,42.02 55.26,42.7 54.53,42.7 54.4,42.83 54.4,42.85 54.28,42.98 54.07,42.98 53.94,42.85 53.94,42.83 53.82,42.7 53.43,42.7 52.38,43.75 52.38,44.09 52.15,44.33 51.77,44.33 51.29,44.8 51.29,46.36 51.52,46.6 51.76,46.6 52.03,46.33 v1(52.03,46.3)
QSFPDD1_VCC:
  vias: v1(54.11,44.32) v1(54.96,44.32) v1(56.69,44.32) v1(57.54,44.32)
QSFPDD1_VCCR:
  vias: v1(47.9,43.12) v1(48.75,43.12) v1(50.83,43.12) v1(51.68,43.12)
QSFPDD1_VCCT:
  vias: v1(54.11,43.52) v1(54.96,43.52) v1(57.44,43.56) v1(58.05,43.57)
QSFPDD_FPGA_I2C_SCL: length 39
  L14_SIG5 w0.081: v1(114.05,80.93) 112.99,80.93 112.43,81.48 112.07,81.48 111.68,81.87 111.22,81.87 110.64,82.45 110.26,82.45 109.88,82.83 108.97,82.83 108.24,83.56 107.85,83.56 107.37,84.03 107.37,85.06 106.57,85.86 106.57,88.56 106.35,88.78 106.35,90.33 106.57,90.55 106.57,91.65 106.36,91.86 105.95,91.86 105.25,92.56 105.25,94.02 105.89,94.66 105.89,95.9 105.28,96.51 102.32,96.51 102.09,96.28 94.75,96.28 94.34,95.88 93.77,95.88 93.53,95.64 93.53,95.21 93.8,94.95 v1(94.62,94.95)
  BOTTOM w0.149: R46.1 114.91,83.11 114.45,82.65 114.45,81.34 v1(114.05,80.93)
QSFPDD_FPGA_I2C_SDA: length 38.1
  L14_SIG5 w0.081: v1(113.18,79.43) 113.18,79.81 112.57,80.42 112.09,80.42 111.55,80.96 111.13,80.96 110.53,81.55 110.21,81.55 109.89,81.87 109.44,81.87 108.08,83.23 107.71,83.23 107.05,83.9 107.05,84.93 106.02,85.95 106.02,89.71 105.7,90.03 105.7,91.65 104.93,92.42 104.93,94.15 105.57,94.79 105.57,95.66 105.06,96.16 102.47,96.16 101.71,95.41 96.85,95.41 96.41,95.85 94.99,95.85 94.56,95.43 v1(93.97,95.43)
  BOTTOM w0.149: R47.1 114.05,82.75 113.6,82.3 113.6,79.85 v1(113.18,79.43)
QSFPDD_I2C_SCL: length 106.8
  TOP w0.149: v4(47.38,66.63) 47.84,67.09 J5.11
  L03_SIG1 w0.081: v4(48.5,42.3) 48.32,42.48 48.32,44.99 48.14,45.17 47.23,45.17 46.67,45.72 46.67,52.41 48.04,53.78 48.04,56.51 46.9,57.66 46.9,62.97 46.6,63.27 46.04,63.27 45.82,63.49 45.82,64.19 45.66,64.35 45.66,65.17 45.95,65.46 46.62,65.46 47.38,66.21 v4(47.38,66.63) 47.02,66.27 45.5,66.27 44.39,65.16 v1(44.39,63.71)
  L12_SIG4 w0.089: v1(44.39,63.71) 44.99,63.11 46.53,63.11 47.1,63.68 47.1,67.3 50.36,70.56 50.36,74.06 57.03,80.72 61.98,80.72 71.76,90.5 71.76,92.41 75.95,96.6 76.21,96.6 76.85,97.25 76.85,97.75 77.15,98.05 77.79,98.05 79.51,99.77 83.19,99.77 83.95,100.54 93.96,100.54 v1(94.62,101.2)
QSFPDD_I2C_SDA: length 101.3
  L03_SIG1 w0.081: v1(46.3,63.71) 46.64,64.05 46.64,65 47.93,66.29 v4(48.14,66.29) 48.14,65.79 47.93,65.59 47.7,65.59 47.22,65.11 47.22,57.79 48.37,56.64 48.37,53.65 47,52.28 47,45.93 47.43,45.5 48.57,45.5 49.16,44.91 49.16,42.42 48.23,41.5 v4(47.89,41.5)
  L12_SIG4 w0.089: v1(46.3,63.71) 46.62,64.02 46.62,67.69 47.76,68.84 47.76,72.09 56.9,81.23 61.95,81.23 70.87,90.15 70.87,92.95 78.09,100.17 82.95,100.17 83.7,100.92 91.67,100.92 92.33,101.58 93.74,101.58 v1(93.97,101.81)
QSPI_RESETN: length 101.5
  L14_SIG5 w0.081: v1(139.16,52.43) 140.24,52.43 140.69,52.87 140.96,52.87 141.47,53.39 141.86,53.39 142.34,53.87 142.87,53.87 143.25,54.25 148.24,54.25 149.37,55.37 158.11,55.37 158.34,55.6 160.92,55.6 164.73,51.79 166.63,51.79 168.69,49.74 171.13,49.74 172.19,48.67 172.19,48.03 173.59,46.64 173.59,46 173.87,45.72 176.36,45.72 178.04,44.05 178.44,44.05 185.45,37.04 190.02,37.04 190.28,37.29 191.32,37.29 196.64,31.97 200.14,31.97 204.85,27.26 208.54,27.26 v1(209.05,26.75)
  BOTTOM w0.149: R5772.2 209.01,26.79 v1(209.05,26.75) ; R5774.2 132.68,41.07 132.68,47.15 132.95,47.42 133.26,47.42 133.78,47.95 134.22,47.95 134.68,48.41 135.02,48.41 135.53,48.92 135.78,48.92 136.24,49.39 136.82,49.39 137.38,49.95 137.61,49.95 138.14,50.48 138.46,50.48 138.91,50.93 139.3,50.93 139.66,51.29 139.66,51.67 139.38,51.95 139.38,52.21 v1(139.16,52.43)
REFCLK_156M_QSFPDD_N: length 131.5
  L16_SIG6 w0.079: v1(47.65,18.81) 47.94,18.81 48.04,18.91 48.04,19.64 47.99,19.7 47.99,19.96 48.04,20.01 48.04,21.99 49.85,23.81 49.85,34.25 48.15,35.96 48.15,36.94 46.9,38.18 46.9,41.27 47.31,41.68 47.31,42.77 46.62,43.46 46.62,51.12 46.34,51.8 46.34,58.88 42.79,62.43 42.79,67.22 42.19,67.82 42.19,75.31 46.61,79.73 52.01,79.73 53,80.72 65.54,80.72 69.96,76.3 76.74,76.3 arc(76.87,76.28) 76.99,76.2 77.53,75.66 arc(77.69,75.55) 77.87,75.52 82.1,75.52 arc(82.24,75.49) 82.36,75.41 82.73,75.04 arc(82.81,74.98) 82.9,74.95 arc(83.11,74.87) 83.29,74.73 83.42,74.6 arc(83.46,74.57) 83.51,74.56 89.77,74.56 arc(90.09,74.47) 90.32,74.24 90.33,74.24 arc(90.47,74.09) 90.66,74.04 90.74,74.04 arc(90.93,74.09) 91.06,74.23 91.06,74.23 arc(91.29,74.46) 91.6,74.54 arc(91.86,74.47) 92.05,74.28 92.08,74.23 arc(92.22,74.09) 92.41,74.04 92.46,74.04 arc(92.6,74.08) 92.7,74.19 92.74,74.24 arc(92.95,74.46) 93.25,74.54 93.32,74.54 arc(93.58,74.47) 93.76,74.28 93.8,74.23 arc(93.93,74.09) 94.11,74.04 94.13,74.04 arc(94.44,73.96) 94.67,73.73 arc(94.81,73.59) 94.99,73.54 95.07,73.54 arc(95.32,73.47) 95.51,73.28 95.54,73.23 arc(95.68,73.09) 95.86,73.04 95.87,73.04 arc(96.18,72.96) 96.4,72.73 96.41,72.73 arc(96.54,72.59) 96.72,72.54 96.8,72.54 arc(97.06,72.47) 97.24,72.28 97.28,72.23 arc(97.41,72.09) 97.59,72.04 97.65,72.04 arc(97.91,71.97) 98.09,71.78 98.13,71.73 arc(98.26,71.59) 98.44,71.54 98.48,71.54 arc(98.78,71.46) 98.99,71.25 99,71.23 arc(99.14,71.09) 99.32,71.04 99.38,71.04 arc(99.64,70.97) 99.83,70.78 99.86,70.73 arc(99.99,70.59) 100.18,70.54 100.18,70.54 arc(100.42,70.5) 100.62,70.36 100.67,70.31 arc(100.77,70.17) 100.8,69.99 100.8,69.91 arc(100.79,69.8) 100.76,69.69 100.7,69.57 arc(100.69,69.5) 100.68,69.44 100.68,69.42 arc(100.69,69.35) 100.71,69.28 100.74,69.2 arc(100.78,69.06) 100.8,68.92 100.8,68.89 arc(100.79,68.78) 100.75,68.67 100.71,68.57 arc(100.69,68.5) 100.68,68.42 arc(100.69,68.34) 100.72,68.26 100.74,68.19 arc(100.78,68.08) 100.79,67.96 100.79,67.9 arc(100.78,67.8) 100.75,67.7 100.71,67.61 arc(100.69,67.54) 100.69,67.47 100.69,67.41 arc(100.7,67.31) 100.73,67.21 100.75,67.15 arc(100.78,67.04) 100.79,66.94 arc(100.78,66.81) 100.74,66.7 100.71,66.63 arc(100.69,66.53) 100.68,66.43 100.68,66.39 arc(100.69,66.31) 100.72,66.23 100.78,66.13 100.84,66.09 100.96,66.09 101.06,66.2 v1(101.06,66.43)
REFCLK_156M_QSFPDD_P: length 131.5
  L16_SIG6 w0.079: v1(48.66,18.81) 48.37,18.81 48.27,18.91 48.27,21.9 50.08,23.71 50.08,34.34 48.37,36.05 48.37,37.03 47.13,38.28 47.13,41.18 47.54,41.58 47.54,42.87 46.84,43.56 46.84,51.17 46.57,51.84 46.57,58.97 43.02,62.52 43.02,67.31 42.42,67.91 42.42,75.21 46.71,79.5 52.1,79.5 53.09,80.5 65.45,80.5 69.87,76.08 76.74,76.08 arc(76.79,76.07) 76.83,76.04 77.37,75.5 arc(77.6,75.34) 77.87,75.29 82.1,75.29 arc(82.15,75.28) 82.2,75.25 82.56,74.88 arc(82.69,74.78) 82.84,74.73 arc(82.99,74.67) 83.12,74.57 83.26,74.43 arc(83.37,74.36) 83.51,74.33 89.77,74.33 arc(89.98,74.28) 90.12,74.13 90.13,74.12 arc(90.35,73.9) 90.66,73.81 90.74,73.81 arc(91.04,73.89) 91.26,74.11 91.26,74.12 arc(91.41,74.26) 91.6,74.31 arc(91.75,74.27) 91.85,74.17 91.88,74.12 arc(92.1,73.9) 92.41,73.81 92.46,73.81 arc(92.71,73.88) 92.9,74.07 92.93,74.13 arc(93.07,74.26) 93.25,74.31 93.32,74.31 arc(93.46,74.28) 93.56,74.17 93.6,74.11 arc(93.81,73.89) 94.11,73.81 94.13,73.81 arc(94.33,73.76) 94.48,73.61 arc(94.69,73.39) 94.99,73.31 95.07,73.31 arc(95.21,73.28) 95.31,73.17 95.34,73.11 arc(95.56,72.89) 95.86,72.81 95.87,72.81 arc(96.06,72.76) 96.21,72.62 96.21,72.61 arc(96.43,72.39) 96.72,72.31 96.8,72.31 arc(96.94,72.28) 97.04,72.17 97.08,72.11 arc(97.29,71.89) 97.59,71.81 97.65,71.81 arc(97.79,71.78) 97.89,71.67 97.93,71.61 arc(98.14,71.39) 98.44,71.31 98.48,71.31 arc(98.66,71.27) 98.79,71.13 98.81,71.11 arc(99.02,70.89) 99.32,70.81 99.38,70.81 arc(99.53,70.78) 99.63,70.67 99.66,70.61 arc(99.88,70.39) 100.18,70.31 100.18,70.31 arc(100.33,70.28) 100.46,70.2 100.51,70.15 arc(100.55,70.08) 100.57,69.99 100.57,69.91 arc(100.57,69.84) 100.55,69.78 100.49,69.65 arc(100.46,69.55) 100.45,69.44 100.45,69.42 arc(100.46,69.31) 100.5,69.2 100.53,69.12 arc(100.56,69.02) 100.57,68.92 100.57,68.89 arc(100.56,68.82) 100.54,68.75 100.5,68.66 arc(100.47,68.55) 100.45,68.42 arc(100.47,68.29) 100.51,68.17 100.53,68.1 arc(100.55,68.03) 100.56,67.96 100.56,67.9 arc(100.55,67.84) 100.54,67.78 100.5,67.7 arc(100.47,67.59) 100.46,67.47 100.46,67.41 arc(100.47,67.26) 100.51,67.12 100.54,67.06 arc(100.56,67) 100.56,66.94 arc(100.56,66.86) 100.53,66.78 100.5,66.71 arc(100.46,66.58) 100.45,66.43 100.45,66.39 arc(100.47,66.25) 100.52,66.12 100.61,65.96 100.78,65.86 101.14,65.86 101.24,65.76 101.24,65.61 v1(101.06,65.43)
REFCLK_322M_QSFPDD_N: length 124.1
  L16_SIG6 w0.079: v1(55.95,26.11) 55.95,26.41 55.85,26.51 55.14,26.51 52.86,28.79 52.86,33.56 47.99,38.44 47.99,40.99 49.21,42.21 49.21,43.61 48.6,44.22 48.6,44.23 48.01,44.82 48.01,47.54 48.44,47.98 48.44,58.28 44.78,61.94 44.78,64.3 44.52,64.56 44.52,67.06 43.14,68.43 43.14,74.89 46.35,78.1 51.96,78.1 53.52,79.66 65.25,79.66 69.57,75.34 76.25,75.34 76.61,74.98 76.61,74.96 78.04,73.53 89.84,73.53 arc(90.12,73.45) 90.33,73.24 90.33,73.24 arc(90.48,73.09) 90.67,73.04 90.7,73.04 arc(90.87,73.09) 90.99,73.21 90.99,73.21 arc(91.23,73.45) 91.56,73.54 arc(91.85,73.46) 92.06,73.25 92.07,73.25 arc(92.22,73.1) 92.42,73.04 arc(92.59,73.09) 92.71,73.21 92.71,73.21 arc(92.95,73.45) 93.28,73.54 93.31,73.54 arc(93.58,73.47) 93.78,73.27 93.79,73.25 arc(93.94,73.1) 94.15,73.04 arc(94.45,72.96) 94.67,72.74 94.7,72.69 arc(94.81,72.58) 94.96,72.54 95.03,72.54 arc(95.3,72.47) 95.5,72.27 arc(95.67,72.1) 95.89,72.04 95.94,72.04 arc(96.13,72) 96.3,71.89 96.89,71.3 arc(97.19,71.1) 97.54,71.03 97.61,71.03 arc(97.91,70.95) 98.13,70.73 98.14,70.73 arc(98.28,70.59) 98.47,70.53 98.48,70.53 arc(98.78,70.45) 99,70.23 99.03,70.18 arc(99.14,70.07) 99.28,70.03 99.38,70.03 arc(99.55,70) 99.7,69.9 99.78,69.82 arc(99.89,69.66) 99.93,69.47 99.93,69.43 arc(99.92,69.32) 99.88,69.21 99.85,69.12 arc(99.82,69.04) 99.81,68.95 99.81,68.9 arc(99.82,68.84) 99.84,68.78 99.89,68.65 arc(99.92,68.56) 99.93,68.47 99.93,68.41 arc(99.92,68.32) 99.89,68.23 99.85,68.14 arc(99.83,68.05) 99.82,67.97 99.82,67.94 arc(99.83,67.83) 99.86,67.73 99.88,67.68 arc(99.92,67.56) 99.93,67.43 99.93,67.4 arc(99.92,67.31) 99.89,67.22 99.85,67.12 arc(99.83,67.04) 99.82,66.96 99.82,66.93 arc(99.83,66.82) 99.86,66.71 99.89,66.64 arc(99.92,66.55) 99.93,66.46 99.93,66.42 arc(99.91,66.28) 99.87,66.14 99.85,66.09 arc(99.83,66.02) 99.82,65.94 99.82,65.83 arc(99.83,65.77) 99.86,65.71 99.89,65.64 99.91,65.63 99.98,65.58 100.09,65.58 100.19,65.68 v1(100.19,65.93)
REFCLK_322M_QSFPDD_P: length 124.4
  L16_SIG6 w0.079: v1(100.19,64.93) 100.44,65.18 100.44,65.28 100.37,65.35 99.92,65.35 99.77,65.44 99.71,65.5 99.66,65.59 arc(99.61,65.71) 99.59,65.83 99.59,65.94 arc(99.6,66.06) 99.64,66.18 99.66,66.23 arc(99.69,66.32) 99.7,66.42 99.7,66.46 arc(99.7,66.51) 99.68,66.55 99.65,66.62 arc(99.61,66.78) 99.59,66.93 99.59,66.96 arc(99.6,67.08) 99.64,67.21 99.68,67.31 arc(99.69,67.35) 99.7,67.4 99.7,67.43 arc(99.69,67.52) 99.67,67.6 99.65,67.64 arc(99.61,67.79) 99.59,67.94 99.59,67.97 arc(99.6,68.1) 99.64,68.22 99.68,68.31 arc(99.69,68.36) 99.7,68.41 99.7,68.47 arc(99.69,68.52) 99.68,68.57 99.63,68.69 arc(99.6,68.79) 99.59,68.9 99.59,68.95 arc(99.6,69.08) 99.63,69.21 99.67,69.3 arc(99.69,69.36) 99.7,69.43 99.7,69.47 arc(99.68,69.57) 99.62,69.66 99.54,69.74 arc(99.46,69.79) 99.38,69.81 99.28,69.81 arc(99.02,69.88) 98.83,70.07 98.8,70.12 arc(98.66,70.26) 98.48,70.31 98.47,70.31 arc(98.16,70.39) 97.94,70.61 97.93,70.62 arc(97.8,70.76) 97.61,70.81 97.54,70.81 arc(97.1,70.89) 96.73,71.14 96.14,71.73 arc(96.05,71.79) 95.94,71.81 95.89,71.81 arc(95.55,71.9) 95.31,72.15 95.31,72.15 arc(95.19,72.27) 95.03,72.31 94.96,72.31 arc(94.69,72.38) 94.5,72.58 94.47,72.63 arc(94.34,72.76) 94.15,72.81 arc(93.83,72.9) 93.6,73.13 93.58,73.16 arc(93.47,73.27) 93.31,73.31 93.28,73.31 arc(93.07,73.26) 92.91,73.1 92.91,73.09 arc(92.7,72.89) 92.42,72.81 arc(92.1,72.9) 91.87,73.13 91.87,73.14 arc(91.74,73.27) 91.56,73.31 arc(91.35,73.26) 91.19,73.1 91.18,73.09 arc(90.98,72.89) 90.7,72.81 90.67,72.81 arc(90.36,72.9) 90.14,73.12 90.13,73.13 arc(90.01,73.25) 89.84,73.3 89.56,73.3 89.43,73.17 89.15,73.17 89.03,73.3 88.75,73.3 88.62,73.17 88.34,73.17 88.21,73.3 77.95,73.3 76.38,74.86 76.38,74.88 76.16,75.11 69.48,75.11 65.16,79.43 53.62,79.43 52.05,77.87 46.44,77.87 43.37,74.8 43.37,68.53 44.75,67.15 44.75,64.66 45.01,64.39 45.01,62.04 48.67,58.37 48.67,47.88 48.24,47.45 48.24,44.91 48.83,44.33 48.83,44.32 49.44,43.71 49.44,42.12 48.22,40.9 48.22,38.53 53.09,33.66 53.09,28.88 54.7,27.28 54.83,27.28 54.94,27.38 55.08,27.38 55.17,27.29 55.17,27.15 55.07,27.04 55.07,26.91 55.24,26.74 55.85,26.74 55.95,26.84 v1(55.95,27.13)
REFCLK_PCIE_CH0_N: length 96.3
  L07_SIG3 w0.085: v1(199.78,106.7) 199.49,106.7 199.38,106.59 199.38,106.17 196.08,102.87 196.08,92.96 188.96,85.84 188.96,84.69 186.84,82.58 184.03,82.58 180.78,79.33 180.78,77.33 178.63,75.18 178.63,75.17 178.25,74.79 178.25,74.79 176.99,73.54 167.88,73.54 167.67,73.74 166.35,73.74 161.81,69.19 147.35,69.19 147.23,69.32 142.51,69.32 141.45,70.38 arc(141.33,70.51) 141.21,70.64 141.17,70.7 arc(141.07,70.78) 140.94,70.81 140.86,70.81 arc(140.73,70.78) 140.63,70.7 140.48,70.51 arc(140.3,70.37) 140.07,70.31 139.99,70.31 arc(139.77,70.37) 139.59,70.51 139.43,70.7 arc(139.33,70.78) 139.21,70.81 139.12,70.81 arc(139,70.78) 138.9,70.7 138.75,70.51 arc(138.57,70.37) 138.34,70.31 138.26,70.31 arc(138.03,70.37) 137.85,70.51 137.7,70.7 arc(137.6,70.78) 137.48,70.81 137.39,70.81 arc(137.27,70.78) 137.17,70.7 137.02,70.51 arc(136.84,70.37) 136.61,70.31 136.53,70.31 arc(136.4,70.28) 136.3,70.2 136.15,70.01 arc(135.97,69.87) 135.74,69.81 135.66,69.81 arc(135.54,69.79) 135.44,69.7 135.28,69.51 arc(135.1,69.37) 134.88,69.31 134.79,69.31 arc(134.57,69.37) 134.39,69.51 134.24,69.7 arc(134.14,69.78) 134.01,69.81 133.93,69.81 arc(133.7,69.87) 133.52,70.01 133.37,70.2 arc(133.27,70.28) 133.15,70.31 133.04,70.31 arc(132.95,70.3) 132.87,70.25 132.87,70.25 arc(132.82,70.2) 132.78,70.14 132.75,70.09 arc(132.62,69.94) 132.45,69.85 arc(132.43,69.85) 132.41,69.84 arc(132.39,69.84) 132.37,69.84 132.13,69.8 arc(132.01,69.75) 131.91,69.65 131.87,69.58 arc(131.72,69.41) 131.51,69.33 131.26,69.3 arc(131.15,69.26) 131.07,69.17 130.93,68.93 130.92,68.75 131.04,68.63 131.18,68.61 131.34,68.7 v1(131.37,68.93)
REFCLK_PCIE_CH0_P: length 96
  L07_SIG3 w0.085: v1(130.5,68.43) 130.69,68.96 130.87,69.28 arc(131.02,69.45) 131.23,69.53 131.47,69.56 arc(131.59,69.6) 131.67,69.7 131.72,69.77 arc(131.88,69.94) 132.1,70.03 132.34,70.06 arc(132.36,70.07) 132.38,70.07 arc(132.48,70.12) 132.55,70.2 132.58,70.25 arc(132.64,70.34) 132.72,70.42 arc(132.87,70.51) 133.04,70.54 133.15,70.54 arc(133.37,70.49) 133.55,70.34 133.7,70.15 arc(133.8,70.07) 133.93,70.04 134.01,70.04 arc(134.24,69.99) 134.42,69.84 134.57,69.65 arc(134.67,69.57) 134.79,69.54 134.88,69.54 arc(135,69.57) 135.1,69.65 135.26,69.85 arc(135.44,69.99) 135.66,70.04 135.74,70.04 arc(135.87,70.07) 135.97,70.15 136.12,70.35 arc(136.3,70.49) 136.53,70.54 136.61,70.54 arc(136.74,70.57) 136.84,70.65 136.99,70.85 arc(137.17,70.99) 137.39,71.04 137.48,71.04 arc(137.7,70.99) 137.88,70.84 138.03,70.65 arc(138.13,70.57) 138.26,70.54 138.34,70.54 arc(138.47,70.57) 138.57,70.65 138.72,70.85 arc(138.9,70.99) 139.12,71.04 139.21,71.04 arc(139.43,70.99) 139.61,70.84 139.77,70.65 arc(139.87,70.57) 139.99,70.54 140.07,70.54 arc(140.2,70.57) 140.3,70.65 140.45,70.85 arc(140.63,70.99) 140.86,71.04 140.94,71.04 arc(141.17,70.99) 141.35,70.84 141.39,70.78 arc(141.5,70.66) 141.61,70.54 142.6,69.55 147.32,69.55 147.45,69.42 161.71,69.42 166.26,73.97 167.77,73.97 167.97,73.76 176.89,73.76 178.12,74.99 178.12,74.99 178.4,75.27 178.4,75.27 180.55,77.42 180.55,79.42 183.94,82.81 186.75,82.81 188.73,84.79 188.73,85.93 195.85,93.05 195.85,102.96 197.8,104.91 197.8,105.06 198,105.26 198.15,105.26 199.16,106.26 199.16,106.59 199.05,106.7 v1(198.76,106.7)
REFCLK_PCIE_CH2_N: length 100.9
  L07_SIG3 w0.085: v1(203.33,106.7) 203.04,106.7 202.94,106.8 202.94,108.22 201.83,109.32 198.91,109.32 194.83,105.24 194.83,93.19 187.89,86.25 187.89,85.27 186.91,84.29 183.48,84.29 179.15,79.96 178.79,79.96 174.35,75.52 168.31,75.52 167.8,75.01 165.18,75.01 161.62,71.44 158.72,71.44 157.82,70.54 144.33,70.54 143.83,71.04 142.58,71.04 arc(142.46,71.07) 142.36,71.15 142.21,71.34 arc(142.03,71.49) 141.8,71.54 141.72,71.54 arc(141.6,71.57) 141.5,71.65 141.35,71.84 arc(141.17,71.99) 140.94,72.04 140.86,72.04 arc(140.63,71.99) 140.45,71.85 140.3,71.65 arc(140.2,71.57) 140.07,71.54 139.99,71.54 arc(139.87,71.57) 139.77,71.65 139.61,71.84 arc(139.43,71.99) 139.21,72.04 139.12,72.04 arc(138.9,71.99) 138.72,71.85 138.57,71.65 arc(138.47,71.57) 138.34,71.54 138.26,71.54 arc(138.13,71.57) 138.03,71.65 137.88,71.84 arc(137.7,71.99) 137.48,72.04 137.38,72.04 arc(137.15,71.99) 136.98,71.85 136.82,71.65 arc(136.72,71.57) 136.6,71.54 136.51,71.54 arc(136.29,71.49) 136.11,71.35 135.96,71.15 arc(135.86,71.07) 135.73,71.04 135.66,71.04 arc(135.53,71.07) 135.43,71.15 135.28,71.34 arc(135.1,71.49) 134.88,71.54 134.79,71.54 arc(134.66,71.57) 134.56,71.65 134.41,71.84 arc(134.23,71.99) 134,72.04 133.92,72.04 arc(133.69,71.99) 133.51,71.85 133.36,71.65 arc(133.26,71.57) 133.14,71.54 133.06,71.54 arc(132.84,71.49) 132.66,71.35 132.5,71.15 arc(132.4,71.07) 132.28,71.04 132.19,71.04 arc(131.97,70.99) 131.79,70.85 131.64,70.65 arc(131.54,70.57) 131.41,70.54 131.31,70.54 arc(131.22,70.58) 131.19,70.67 131.19,70.76 arc(131.23,70.88) 131.35,70.93 v1(131.37,70.93)
REFCLK_PCIE_CH2_P: length 100.8
  L07_SIG3 w0.085: v1(130.5,70.43) 131.07,70.31 131.41,70.31 arc(131.64,70.37) 131.82,70.51 131.97,70.7 arc(132.07,70.78) 132.19,70.81 132.28,70.81 arc(132.5,70.87) 132.68,71.01 132.84,71.2 arc(132.94,71.28) 133.06,71.31 133.14,71.31 arc(133.36,71.37) 133.54,71.51 133.69,71.7 arc(133.79,71.78) 133.92,71.81 134,71.81 arc(134.13,71.78) 134.23,71.7 134.38,71.51 arc(134.56,71.37) 134.79,71.31 134.88,71.31 arc(135,71.28) 135.1,71.2 135.25,71.01 arc(135.43,70.87) 135.66,70.81 135.73,70.81 arc(135.96,70.87) 136.14,71.01 136.29,71.2 arc(136.39,71.28) 136.51,71.31 136.6,71.31 arc(136.82,71.37) 137,71.51 137.15,71.7 arc(137.25,71.78) 137.38,71.81 137.48,71.81 arc(137.6,71.78) 137.7,71.7 137.85,71.51 arc(138.03,71.37) 138.26,71.31 138.34,71.31 arc(138.57,71.37) 138.75,71.51 138.9,71.7 arc(139,71.78) 139.12,71.81 139.21,71.81 arc(139.33,71.78) 139.43,71.7 139.59,71.51 arc(139.77,71.37) 139.99,71.31 140.07,71.31 arc(140.3,71.37) 140.48,71.51 140.63,71.7 arc(140.73,71.78) 140.86,71.81 140.94,71.81 arc(141.07,71.78) 141.17,71.7 141.32,71.51 arc(141.5,71.37) 141.72,71.31 141.8,71.31 arc(141.93,71.28) 142.03,71.2 142.18,71.01 arc(142.36,70.87) 142.58,70.81 143.73,70.81 144.24,70.31 157.92,70.31 158.82,71.21 161.71,71.21 165.28,74.78 167.89,74.78 168.4,75.29 174.44,75.29 178.89,79.73 179.25,79.73 183.57,84.06 187,84.06 188.12,85.18 188.12,86.16 195.06,93.1 195.06,105.15 199.01,109.1 201.74,109.1 202.71,108.12 202.71,106.8 202.61,106.7 v1(202.32,106.7)
REFCLK_PCIE_EP_EDGE_N: length 247.9
  L03_SIG1 w0.079: v1(60.54,9.73) 60.22,9.41 60.22,8.73 59.95,8.46 59.95,8.18 60.08,8.05 60.08,7.78 59.95,7.65 59.95,7.19 60.47,6.67 62.06,6.67 62.19,6.79 62.46,6.79 62.59,6.67 125.72,6.67 126.55,7.5 126.55,7.68 126.75,7.88 126.93,7.88 128.14,9.09 132.32,10.82 136.44,10.82 138.92,13.31 140.92,14.13 142.6,14.13 143.35,14.88 150.54,14.88 150.67,15.01 150.95,15.01 151.07,14.88 151.35,14.88 159.92,23.45 160.58,23.45 162.96,25.84 162.96,26.35 164.72,28.1 164.72,28.59 164.59,28.72 164.59,29 164.72,29.12 164.72,31.7 165.25,32.24 165.25,32.79 164.76,33.29 164.58,33.29 164.38,33.48 164.38,33.66 163.97,34.08 163.97,37.88 165.26,39.17 165.26,68.2 168.51,71.45 176.92,71.45 179.86,74.4 179.86,84.31 181.13,85.58 181.13,87.71 184.06,90.63 192.98,90.63 195.53,93.18 195.53,105.68 198.11,108.26 199.09,108.26 199.38,107.96 199.38,107.69 199.49,107.58 v1(199.78,107.58)
  L07_SIG3 w0.085: v1(204.45,98.45) 204.45,99.11 205.12,99.79 205.12,103.24 204.71,103.65 204.57,103.65 204.5,103.58 204.36,103.58 204.26,103.67 204.26,103.81 204.34,103.89 204.34,104.03 204.17,104.19 203.26,104.19 201.02,106.43 201.02,107.47 200.86,107.63 200.72,107.63 200.64,107.56 200.51,107.56 200.41,107.65 200.41,107.79 200.49,107.87 200.49,108.01 200.36,108.13 199.55,108.13 199.38,107.97 199.38,107.69 199.49,107.58 v1(199.78,107.58)
  BOTTOM w0.102: U72.2 204.59,99.37 204.73,99.23 204.73,98.73 v1(204.45,98.45) ; J7.A14 60.66,5.21 60.28,5.6 60.28,6.49 59.82,6.94 59.82,8.33 60.28,8.79 60.28,9.46 v1(60.54,9.73)
REFCLK_PCIE_EP_EDGE_P: length 247.8
  L03_SIG1 w0.079: v1(59.78,9.73) 60,9.52 60,8.83 59.72,8.56 59.72,7.1 60.38,6.44 125.81,6.44 128.27,8.89 132.36,10.59 136.53,10.59 139.05,13.11 140.96,13.9 142.7,13.9 143.45,14.65 151.45,14.65 160.02,23.22 160.67,23.22 163.19,25.74 163.19,26.25 164.95,28.01 164.95,31.61 165.48,32.15 165.48,32.89 164.2,34.17 164.2,37.78 165.49,39.07 165.49,68.1 168.61,71.22 177.01,71.22 180.09,74.3 180.09,84.21 181.36,85.48 181.36,87.61 184.15,90.4 193.07,90.4 195.76,93.08 195.76,105.58 196.96,106.79 197.1,106.79 197.27,106.62 197.41,106.62 197.51,106.71 197.51,106.85 197.33,107.02 197.33,107.16 198.2,108.03 198.99,108.03 199.16,107.86 199.16,107.69 199.05,107.58 v1(198.76,107.58)
  L07_SIG3 w0.085: v1(205.29,98.47) 205.29,98.91 205.13,99.07 205.13,99.47 205.35,99.69 205.35,103.34 204.27,104.42 203.35,104.42 201.25,106.52 201.25,107.56 200.46,108.36 199.45,108.36 199.16,108.06 199.16,107.69 199.05,107.58 v1(198.76,107.58)
  BOTTOM w0.102: J7.A13 59.66,5.25 60.05,5.64 60.05,6.39 59.6,6.84 59.6,8.43 60.05,8.88 60.05,9.46 v1(59.78,9.73) ; v1(205.29,98.47) 204.96,98.8 204.96,99.23 205.09,99.37 U72.1
REFCLK_PCIE_EP_N: length 24.9
  L03_SIG1 w0.079: v1(201.94,98.44) 202.24,98.44 202.34,98.34 202.34,97.38 202.12,97.16 201.78,97.16 201.3,97.63 201.3,98.97 201.43,99.1 201.63,99.1 201.76,99.22 201.76,99.43 201.63,99.56 201.43,99.56 201.3,99.68 201.3,99.88 202.34,100.92 202.34,105.18 202.94,105.78 202.94,107.19 v1(203.33,107.58) 202.97,107.58 202.85,107.7 202.85,107.98 203.05,108.18 204.96,108.18 206.28,106.86 206.28,104.02 206.52,103.79 206.85,103.79 206.95,103.69 v1(206.95,103.46)
  BOTTOM w0.102: v1(201.94,98.44) 202.37,98.87 202.37,99.1 202.73,99.45 202.73,99.62 202.59,99.75 U72.6
REFCLK_PCIE_EP_P: length 24.9
  L03_SIG1 w0.079: v1(206.95,104.35) 206.95,104.12 206.85,104.02 206.61,104.02 206.51,104.12 206.51,106.96 205.05,108.41 202.96,108.41 202.62,108.07 202.62,107.89 v1(202.32,107.58) 202.71,107.19 202.71,105.87 202.11,105.27 202.11,101.02 201.07,99.98 201.07,97.54 201.68,96.93 202.22,96.93 202.57,97.28 202.57,98.06 v1(202.95,98.44)
  BOTTOM w0.102: v1(202.95,98.44) 202.6,98.8 202.6,99 202.96,99.36 202.96,99.6 203.09,99.74 U72.5
RSV_SD_RESETN: length 154.6
  L03_SIG1 w0.081: v1(34.03,22.02) 33.63,21.62 33.63,18.58 31.64,16.59 v1(24.77,16.59)
  L07_SIG3 w0.089: v1(24.77,16.59) 23.76,17.6 23.76,22.18 21.6,24.34 21.6,27.64 20.58,28.65 20.58,30.97 20.81,31.2 20.81,35.36 22.49,37.04 22.49,43.39 23.63,44.53 23.63,50.88 23.12,51.39 23.12,53.93 23.5,54.31 23.5,61.55 27.06,65.1 27.69,65.1 28.07,65.48 30.49,65.48 34.3,69.29 46.36,69.29 46.62,69.55 52.97,69.55 53.6,70.18 55.63,70.18 56.27,70.82 56.27,72.85 66.56,83.14 73.87,83.14 79.94,89.21 84.26,89.21 86.34,87.12 86.34,79.61 88.4,77.55 88.4,74.7 89.59,73.51 89.9,73.51 90.67,72.74 v1(90.67,72.43)
RUN0: length 3.5
  TOP w0.152: v1(189.62,82.79) 189.07,83.34 189.07,83.61 188.8,83.89 U76.30
  BOTTOM w0.149: R6108.2 190.49,83.23 190.56,83.16 C1840.1 v1(189.62,82.79)
RUN2: length 3.1
  TOP w0.149: v1(189.54,55.34) 189.43,55.34 189.07,55.7 U78.30
  BOTTOM w0.203: R6107.2 190.47,55.83 190.45,55.81 C1996.1 v1(189.54,55.34)
RUN3: length 4.1
  TOP w0.149: v1(189.44,39.02) 188.94,39.52 U79.30
  BOTTOM w0.149: R6089.1 C1998.1 190.95,39.06 191.79,39.89 R6106.2
RUN4: length 3.5
  TOP w0.149: v1(189.7,70.35) 189.41,70.64 189.4,70.64 188.8,71.24 U77.30
  BOTTOM w0.149: v1(189.7,70.35) R6087.1 189.81,70.37 189.83,70.35 C1994.1 190.58,70.88 190.57,70.9 R6109.2
SD_3.3V: length 1
  BOTTOM w0.203: 43.19,106.76 43.37,106.94 U15.A1 42.99,107.32
  vias: v1(36.08,97.36) v1(38.3,98.5) v1(38.3,95.96) v1(40.52,95.46) v1(41.41,105.62) v1(41.41,104.6) v1(42.68,104.6) v1(50.24,97.23)
SD_CLK: length 68.8
  L03_SIG1 w0.081: v1(41.41,91.07) 41.83,91.49 42.48,91.49 42.71,91.26 42.71,89.77 42.48,89.53 42.48,88.57 42.71,88.34 42.71,87.83 44.74,85.8 53.69,85.8 58.21,81.29 66.5,81.29 67.7,80.09 76.78,80.09 79.47,77.4 87.38,77.4 89.34,75.44 90.06,75.44 90.46,75.05 90.88,75.05 91.37,74.56 91.61,74.56 92,74.17 92,73.27 92.32,72.94 92.7,72.94 93.11,72.54 93.49,72.54 94.07,71.96 94.44,71.96 94.85,71.55 95.29,71.55 95.67,71.93 v4(96.73,71.93)
  BOTTOM w0.149: v1(41.41,91.07) 41.41,91.7 42.04,92.33 U14.10
SD_CLK_3.3V: length 14.4
  TOP w0.149: v1(37.47,96.6) 37.21,96.34 J11.5
  L03_SIG1 w0.081: v1(37.47,96.6) 37.98,97.11 37.98,98.12 36.84,99.27 36.84,100.54 37.35,101.04 38.49,101.04 v1(38.62,101.17)
  BOTTOM w0.149: v1(38.62,101.17) 38.62,100.92 39,100.54 39.76,100.54 40.27,100.03 41.66,100.03 42.04,99.65 U14.11 ; v1(37.47,96.6) 37.74,96.87 D6.1
SD_CMD: length 62.3
  L03_SIG1 w0.081: v4(91.53,73.93) 91.06,74.4 91.06,74.57 90.82,74.81 90.22,74.81 89.91,74.5 89.46,74.5 88.67,75.29 88.67,75.59 87.72,76.53 79.53,76.53 76.87,79.2 69.15,79.2 68.87,79.48 67.67,79.48 66.38,80.77 55.18,80.77 52.68,83.26 45.09,83.26 44.2,84.15 44.2,85.3 41.87,87.63 41.87,90.64 v1(42.3,91.07)
  BOTTOM w0.149: v1(42.3,91.07) 42.69,91.47 U14.9
SD_CMD_3.3V: length 15.3
  TOP w0.149: v1(37.47,97.61) 36.55,98.54 J11.3
  L03_SIG1 w0.081: v1(37.47,97.61) 37.09,97.61 36.46,98.25 36.46,100.66 37.6,101.81 39.38,101.81 v1(40.01,101.17)
  BOTTOM w0.149: U14.12 42.69,99.89 42.04,100.54 40.65,100.54 v1(40.01,101.17) ; D6.2 37.74,97.35 v1(37.47,97.61)
SD_DATA0: length 67.7
  L03_SIG1 w0.081: v4(96.73,70.93) 97.62,70.93 97.98,71.29 97.98,71.73 97.71,72 97.5,72 96.95,72.55 96.58,72.55 96.08,73.05 95.56,73.05 95.3,73.31 94.98,73.31 94.37,73.92 93.92,73.92 93.65,74.19 93.65,75.27 93.36,75.56 93.1,75.56 92.94,75.71 92.88,75.86 92.88,76.63 92.58,76.93 92.32,76.93 92.12,77.13 92.12,77.18 91.75,77.55 91.38,77.55 90.89,78.04 90.39,78.04 89.88,78.55 88.54,78.55 87.38,79.71 79.57,79.71 77.41,81.87 68.97,81.87 64.08,86.76 61.7,86.76 61.6,86.86 61.6,87 61.7,87.09 62.4,87.09 62.5,87.19 62.5,87.33 62.4,87.43 52.03,87.43 51.16,88.29 48.55,88.29 46.87,89.97 46.87,90.78 46.58,91.07 v1(45.85,91.07)
  BOTTOM w0.149: U14.5 45.29,91.96 45.85,91.4 v1(45.85,91.07)
SD_DATA0_3.3V: length 17.1
  TOP w0.149: J11.7 v1(37.47,94.14)
  L03_SIG1 w0.081: v1(37.47,94.14) 38.8,95.47 39.31,95.47 40.44,96.6 41.66,96.6 v1(46.24,101.17)
  BOTTOM w0.149: v1(37.47,94.14) 37.79,94.45 D5.1 ; U14.16 45.29,100.23 v1(46.24,101.17)
SD_DATA1: length 62.5
  L03_SIG1 w0.081: v4(91.53,74.93) 91.53,74.94 91.94,75.35 91.94,76.06 91.61,76.38 90.99,76.38 90.06,77.31 88.64,77.31 87,78.95 79.05,78.95 77.02,80.98 68.08,80.98 66.25,82.81 63.82,82.81 63.72,82.71 63.72,82.23 63.62,82.14 62.09,82.14 62,82.23 62,82.37 62.09,82.47 63.29,82.47 63.39,82.57 63.39,82.71 63.29,82.81 58.35,82.81 54.46,86.69 46.24,86.69 45.32,87.61 45.32,88.24 44.56,89 44.56,90.67 v1(44.97,91.07)
  BOTTOM w0.149: U14.6 44.64,91.4 v1(44.97,91.07)
SD_DATA1_3.3V: length 17.8
  TOP w0.149: v1(37.47,95.2) 37.98,94.69 37.98,93.8 37.21,93.04 J11.8
  L03_SIG1 w0.081: v1(44.84,101.17) 41.54,97.87 39.38,97.87 37.47,95.96 v1(37.47,95.2)
  BOTTOM w0.149: U14.15 44.64,100.97 v1(44.84,101.17) ; D5.2 37.74,94.93 v1(37.47,95.2)
SD_DATA2: length 70.3
  L03_SIG1 w0.081: v1(44.08,91.07) 44.46,91.46 45.1,91.46 45.4,91.17 45.4,89.75 46.04,89.11 46.99,89.11 48.27,87.84 50.93,87.84 51.67,87.1 55.22,87.1 55.32,87 55.32,86.53 55.42,86.43 56.84,86.43 56.94,86.53 56.94,86.67 56.84,86.76 55.76,86.76 55.66,86.86 55.66,87 55.76,87.1 60.35,87.1 61.43,86.02 64.05,86.02 68.71,81.36 77.21,81.36 79.24,79.33 87.08,79.33 88.37,78.03 89.06,78.03 89.54,77.55 90.25,77.55 90.51,77.8 90.82,77.8 91.32,77.31 91.69,77.31 91.9,77.09 91.9,76.39 92.25,76.05 92.3,76.05 92.72,75.63 92.79,75.46 92.79,73.72 93.14,73.38 93.43,73.38 93.85,72.96 94.33,72.96 94.73,72.55 95.25,72.55 95.52,72.81 96.01,72.81 96.52,72.3 96.88,72.3 97.11,72.08 97.11,71.91 v4(97.59,71.43)
  BOTTOM w0.149: U14.7 43.99,91.16 v1(44.08,91.07)
SD_DATA2_3.3V: length 14.2
  TOP w0.149: v1(37.47,99.27) 38.11,99.9 38.11,100.54 37.91,100.74 J11.1
  L03_SIG1 w0.081: v1(43.44,101.17) 42.43,100.15 39,100.15 38.11,99.27 v1(37.47,99.27)
  BOTTOM w0.149: v1(37.47,99.27) 37.74,99.53 D4.1 ; v1(43.44,101.17) 43.44,100.79 43.99,100.24 U14.14
SD_DATA3: length 61
  L03_SIG1 w0.081: v4(91.53,75.93) 90.62,75.93 90.11,76.43 89.72,76.43 89.24,76.92 88.38,76.92 86.73,78.56 78.9,78.56 76.86,80.6 67.83,80.6 66.71,81.72 65.95,81.72 65.85,81.81 65.85,82.29 65.75,82.39 64.6,82.39 64.5,82.29 64.5,82.15 64.6,82.05 65.42,82.05 65.51,81.95 65.51,81.81 65.42,81.72 58.55,81.72 54.08,86.18 45.88,86.18 43.6,88.46 43.6,90.68 43.2,91.07 v1(43.19,91.07)
  BOTTOM w0.149: v1(43.19,91.07) 43.34,91.23 U14.8
SD_DATA3_3.3V: length 11.4
  TOP w0.149: J11.2 36.83,99.64 v1(37.47,100.28)
  L03_SIG1 w0.081: v1(37.47,100.28) 38.62,100.28 39,100.66 40.65,100.66 v1(41.16,101.17)
  BOTTOM w0.149: v1(37.47,100.28) 37.74,100.01 D4.2 ; v1(41.16,101.17) 41.22,101.23 R196.2 43.34,100.32 U14.13
SD_RSTN: length 118.1
  L03_SIG1 w0.081: v1(41.41,36.91) 41.16,36.91 40.39,37.67 40.39,38.05 37.83,40.62 37.83,46.79 32.54,52.07 32.54,55.37 31.63,56.29 31.63,61.29 27.82,65.1 27.82,67.01 28.58,67.77 28.58,71.71 29.22,72.34 29.22,75.52 32.77,79.07 34.5,79.07 36.47,81.04 37.08,81.04 37.35,81.31 37.35,90.55 36.35,91.54 36.35,93.91 35.19,95.07 35.19,100.41 37.09,102.31 41.41,102.31 44.97,105.87 44.97,107.01 45.73,107.77 v1(45.98,107.77)
  L12_SIG4 w0.089: v1(32.43,18.82) 32.03,19.22 32.03,21.38 32.27,21.62 32.58,21.62 32.83,21.88 32.83,22.18 33.07,22.42 33.38,22.42 33.63,22.68 33.63,22.98 34.67,24.02 35,24.02 35.23,24.25 35.23,24.58 35.47,24.82 38.35,24.82 38.98,25.45 38.98,28.25 39.38,28.65 39.38,30.46 41.41,32.49 v1(41.41,36.91)
  BOTTOM w0.149: v1(45.98,107.77) 46.3,108.09 R190.1 44.58,108.54 U15.B2
SH_CLK: length 2.2
  TOP w0.149: R5931.1 203.32,58.3 202.41,58.3 202.07,58.64 U47.29
SI2202_OUT0N: length 1.6
  TOP w0.102: R264.2 208.18,103.8 208.84,103.8 208.92,103.71 U18.13
SI2202_OUT0P: length 1.6
  TOP w0.102: U18.12 208.94,104.11 208.86,104.03 208.16,104.03 R262.2
SI5341_1P8V_VDDO: length 9.3
  TOP w0.254: U17.29 51.02,22.38 v1(50.97,22.43) ; v1(52.33,29.54) 52.33,29.78 52.53,29.97 U17.49 ; v1(53.23,21.67) U17.33 ; U17.26 v1(49.53,22.43) ; v1(52.33,27.19) 52.38,27.24 U17.43
  TOP w0.255: U17.52 v1(51.02,29.54) ; U17.36 52.56,23.74 52.33,23.97 v1(52.33,24.46) ; U17.57 v1(48.53,29.54)
  BOTTOM w0.381: C311.1 50.99,29.5 v1(51.02,29.54) ; v1(52.33,29.54) 52.27,29.48 C307.1 ; C314.1 52.29,27.15 v1(52.33,27.19)
  vias: v1(53.98,22.05) v1(54.49,21.41)
SI5341_2P5V_VDDO: length 1.8
  TOP w0.255: U17.40 v1(52.33,25.74) ; U17.22 v1(47.53,22.43)
SI5341_A0: length 1.9
  TOP w0.149: U17.19 46.02,21.41
  TOP w0.152: R241.1 46.02,19.78 46.02,21.41
SI5341_A1: length 3.1
  TOP w0.149: U17.17 45.02,21.35 44.84,21.16 R242.1
SI5341_ENN: length 99.9
  TOP w0.254: U17.11 v1(43.61,24.74)
  L03_SIG1 w0.081: v1(2.67,71.26) 1.79,70.37 1.79,63.96 0.77,62.94 0.77,34.09 6.19,28.66 6.19,23.62 9.23,20.58 10.51,20.58 13.11,17.99 20.71,17.99 21.22,17.48 23.12,17.48 24.52,16.08 32.25,16.08 34.43,18.26 34.43,21.62 v1(34.83,22.02)
  L05_SIG2 w0.081: v1(34.83,22.02) 35.23,21.62 37.83,21.62 38.28,22.08 39.98,22.08 42.64,24.74 v1(43.61,24.74)
  BOTTOM w0.149: v1(2.67,71.26) 2.81,71.12 SW2.2
SI5341_FDEC: length 21.6
  TOP w0.149: U17.25 v1(49.02,20.53)
  L07_SIG3 w0.089: v1(49.02,20.53) 48.04,19.54 46.03,19.54 45.51,19.02 38.47,19.02 37.79,18.34 34.19,18.34 33.63,18.9 33.63,22.42 v1(34.03,22.82)
SI5341_FINC: length 65.7
  TOP w0.159: U17.48 v1(54.11,29.74)
  L16_SIG6 w0.081: v1(54.11,29.74) 54.11,31.83 55.25,32.97 60.46,32.97 62.87,30.56 62.87,20.02 58.2,15.35 46.8,15.35 44.64,17.51 44.64,18.61 42.45,20.79 41.19,20.79 41.1,20.88 38.13,20.88 37.75,20.5 37.75,20.17 36.81,19.22 27.41,19.22 27.12,19.52 26.93,19.52 v1(26.83,19.62)
SI5341_I2C_SEL: length 1
  TOP w0.152: U17.39 v1(54.24,25.24)
SI5341_IN_SEL0: length 2.9
  TOP w0.149: U17.3 43.87,28.74 42.55,30.05 R245.1
SI5341_IN_SEL1: length 2.7
  TOP w0.149: U17.4 43.6,28.24 42.68,29.16 R244.1
SI5341_OUT0N: length 2.1
  TOP w0.102: U17.23 48.02,21.15 48.16,21.01 48.16,20.62 48.04,20.49 48.04,20.09 C316.1
SI5341_OUT0P: length 2.1
  TOP w0.102: C315.1 48.27,20.09 48.27,20.4 48.39,20.52 48.39,21.03 48.53,21.17 U17.24
SI5341_OUT1N: length 2.1
  TOP w0.102: U17.27 50.02,21.15 50.16,21.01 50.16,20.71 50.07,20.62 50.07,20.09 R250.2
SI5341_OUT1P: length 2.1
  TOP w0.102: U17.28 50.53,21.17 50.39,21.03 50.39,20.62 50.3,20.53 50.3,20.09 R249.2
SI5341_OUT2N: length 2.2
  TOP w0.102: R254.2 52.1,20.09 52.1,20.3 51.66,20.75 51.66,21.01 51.53,21.15 U17.30
SI5341_OUT2P: length 2.2
  TOP w0.102: U17.31 52.02,21.17 51.89,21.03 51.89,20.84 52.33,20.4 52.33,20.09 R253.2
SI5341_OUT3N: length 2.2
  TOP w0.102: U17.34 53.23,22.74 53.6,22.74 53.74,22.87 53.98,22.87 54.41,22.44 54.67,22.44 R248.2
SI5341_OUT3P: length 2.2
  TOP w0.102: U17.35 53.58,23.24 53.72,23.1 54.07,23.1 54.5,22.67 54.67,22.67 R246.2
SI5341_OUT4N: length 2.1
  TOP w0.102: U17.37 53.63,24.24 53.76,24.37 54.4,24.37 54.5,24.48 54.67,24.48 R252.2
SI5341_OUT4P: length 2.1
  TOP w0.102: R251.2 54.67,24.7 54.41,24.7 54.3,24.6 53.72,24.6 53.58,24.74 U17.38
SI5341_OUT5N: length 2.1
  TOP w0.102: C318.1 54.67,26.51 54.32,26.51 54.18,26.37 53.73,26.37 53.6,26.24 U17.41
SI5341_OUT5P: length 2.1
  TOP w0.102: U17.42 53.61,26.74 53.75,26.6 54.09,26.6 54.22,26.74 54.67,26.74 C317.1
SI5341_OUT6N: length 2.5
  TOP w0.102: R256.2 54.67,28.54 54.48,28.54 54.34,28.4 54.34,28.18 54.03,27.87 53.76,27.87 53.63,27.74 U17.44
SI5341_OUT6P: length 2.5
  TOP w0.102: R255.2 54.67,28.77 54.38,28.77 54.11,28.49 54.11,28.27 53.94,28.1 53.72,28.1 53.58,28.24 U17.45
SI5341_OUT7N: length 4.5
  TOP w0.102: R258.2 54.67,30.57 54.15,30.57 53.46,31.27 51.99,31.27 51.89,31.17 51.89,31 52.02,30.87 U17.50
SI5341_OUT7P: length 4.8
  TOP w0.102: R257.2 54.67,30.8 54.25,30.8 53.55,31.5 51.9,31.5 51.66,31.26 51.66,31.01 51.53,30.87 U17.51
SI5341_OUT8P: length 6.2
  TOP w0.149: U17.54 50.02,30.87 51.54,32.39 54.88,32.39 R259.2
SI5341_OUT9P: length 7.6
  TOP w0.149: U17.59 47.53,30.83 47.86,31.17 47.86,31.6 47.66,31.8 44.81,31.8 44.08,31.07 R834.2
SI5341_RSTN: length 11.4
  TOP w0.149: U17.6 43.84,27.24 v1(43.31,27.76)
  L05_SIG2 w0.081: v1(36.43,22.02) 37.73,22.02 38.13,22.42 39.53,22.42 43.31,26.21 v1(43.31,27.76)
SI5341_VDD: length 3.5
  TOP w0.255: U17.46 v1(52.33,28.74) ; v1(52.2,22.43) 52.53,22.11 U17.32 ; U17.60 v1(47.02,29.54)
  BOTTOM w0.381: C301.1 52.35,28.72 v1(52.33,28.74)
  vias: v1(46.62,31.32) v1(47.38,31.32)
SI5341_VDDA: length 0.8
  TOP w0.255: U17.13 v1(43.57,23.74)
SI5341_X1: length 2.4
  TOP w0.159: U17.7 42.9,26.74 Y2.2
SI5341_X2: length 5.8
  TOP w0.159: U17.10 43.32,25.24 43.07,24.99 43.07,24.24 42.89,24.05 40.56,24.05 40.37,24.24 Y2.4
SI5341_XA: length 5
  TOP w0.159: U17.8 40.61,26.24 40.37,26.47 Y2.3
SI5341_XB: length 2.7
  TOP w0.159: U17.9 42.35,25.74 42.22,25.61 Y2.1
SI52202_PWRDNB: length 273.6
  TOP w0.149: U18.1 212.9,102.91 v1(212.99,102.82)
  L05_SIG2 w0.081: v1(26.8,61.29) 24.52,63.58 15.76,63.58 6.17,73.17 v1(2.67,73.17)
  L16_SIG6 w0.081: v1(26.8,61.29) 25.29,62.8 25.29,68.26 25.01,68.55 25.01,76.74 25.65,77.37 25.65,79.21 25.93,79.49 25.93,80.87 26.99,81.93 26.99,82.75 27.43,83.18 27.96,83.18 28.68,83.91 28.68,84.32 29.17,84.8 29.4,84.8 30.14,85.53 30.14,85.71 30.63,86.2 31.25,86.2 32.13,87.08 32.54,87.08 32.83,87.37 32.83,87.85 33.26,88.27 33.26,88.47 35.34,90.55 35.34,93.29 36.87,94.83 37.8,94.83 38.53,95.56 39.42,95.56 42.53,98.67 44.26,98.67 47.02,101.42 48.91,101.42 50.27,102.79 51.28,102.79 51.57,103.08 51.57,103.33 51.95,103.71 52.2,103.71 53.98,105.49 55.32,105.49 55.98,106.16 57.01,106.16 58.17,107.32 66.85,107.32 69.17,105 69.17,104.66 69.45,104.39 69.92,104.39 70.07,104.24 70.66,104.24 70.92,104.5 70.92,104.95 71.09,105.12 71.21,105.17 71.7,105.17 73.12,105.76 74.23,106.87 78.29,106.87 78.93,107.51 95.73,107.51 98.55,104.69 102.07,104.69 103.09,105.71 104.47,105.71 106.28,107.52 122.66,107.52 123.65,106.53 124.75,106.53 125.52,105.76 125.52,105.45 125.85,105.12 125.85,104.77 126.95,103.66 130.23,103.66 130.65,104.08 130.98,104.08 131.44,104.55 131.9,104.55 132.19,104.84 132.19,105.69 134.02,107.52 186.14,107.52 188.2,105.46 188.2,103.23 189.75,101.68 189.75,99.54 190.4,98.88 192.29,98.88 194.57,101.17 194.57,102.97 196.22,104.63 201.53,104.63 202.45,103.71 204.97,103.71 205.63,103.05 209.49,103.05 209.97,102.57 211.87,102.57 212.12,102.82 v1(212.99,102.82)
  BOTTOM w0.149: SW2.3 3.45,72.39 v1(2.67,73.17)
SW_U77_FPGA_VCC:
  vias: v1(183.93,74.13) v1(183.93,73.19) v1(183.93,72.22) v1(183.93,69.26) v1(183.93,68.3) v1(183.93,67.36) v1(184.44,74.13) v1(184.44,73.19) v1(184.44,72.22) v1(184.44,69.26) v1(184.44,68.3) v1(184.44,67.36) v2(180.02,70.66) v2(180.02,69.69) v2(180.02,68.75) v2(182,70.74) v2(182,69.77) v2(182,68.83)
SW_U78_FPGA_VCC:
  vias: v1(183.93,58.58) v1(183.93,57.64) v1(183.93,56.68) v1(183.93,53.72) v1(183.93,52.75) v1(183.93,51.81) v1(184.44,58.58) v1(184.44,57.64) v1(184.44,56.68) v1(184.44,53.72) v1(184.44,52.75) v1(184.44,51.81) v2(179.51,56.11) v2(179.51,55.14) v2(179.51,54.2) v2(181.19,56.18) v2(181.19,55.22) v2(181.19,54.28)
SW_U79_FPGA_VCC:
  vias: v1(179.38,39.12) v1(179.71,38.76) v1(180.04,38.38) v1(181.82,38.99) v1(182.25,38.56) v1(184.11,42.67) v1(184.08,41.73) v1(184.21,40.8) v1(184.44,42.17) v1(184.39,41.28) v1(184.41,40.31)
SYNC: length 2.2
  TOP w0.149: U47.14 196.29,59.04 195.28,58.03 v1(195.28,57.74)
TMON0: length 2.6
  TOP w0.149: v1(189.5,80.54) 188.84,79.89 U76.22
  BOTTOM w0.149: C2017.2 189.61,80.55 190.15,80 R5945.1
TMON2: length 1.6
  TOP w0.149: U78.22 v1(189.22,51.7)
  BOTTOM w0.149: C2026.2 189.24,51.68 R5954.1 v1(189.22,51.7)
TMON3: length 2.2
  TOP w0.149: U79.22 189.36,35.52 v1(189.65,35.81)
  BOTTOM w0.149: v1(189.65,35.81) R5961.1 C2028.2
TMON4: length 1.8
  TOP w0.149: U77.22 189.42,67.24 v1(189.45,67.21)
  BOTTOM w0.149: C2020.2 189.47,67.2 v1(189.45,67.21)
TRACECTL: length 0.7
  BOTTOM w0.149: v1(42.93,80.72) 42.87,80.66 R211.2
TSENSE_ALERTN: length 278.5
  TOP w0.254: v1(72,88.47) 72.54,87.93 U32.18
  L03_SIG1 w0.203: v1(72,88.47) 72.45,88.91 74.49,88.91 74.81,89.23 74.81,90.38 74.3,90.89 74.3,96.98 73.35,97.93 73.35,101.24 76.08,103.96 76.08,104.6 75.83,104.85 75.83,105.74 77.6,107.52 83.95,107.52 v1(85.1,106.38)
  L12_SIG4 w0.127: v1(250.95,23.46) 250.58,23.09 250.58,21.64 249.84,20.91 249,20.91 248.67,20.58 248.67,20.4 248.22,19.94 246.76,19.94 246.36,20.34 246.36,24.65 240.3,30.72 240.3,41.5 239.15,42.65 239.15,44.22 235.13,48.24 235.13,52.02 234.07,53.09 234.07,58.55 230.41,62.21 230.41,66.26 226.7,69.97 226.7,78.85 227.26,79.4 227.67,79.4 230.08,81.82 230.08,89.72 227.01,92.79 213.16,92.79 211.74,94.21 202.41,94.21 201.25,95.37 201.25,97.34 199.32,99.27 196.47,99.27 193.91,101.83 186.04,101.83 185.3,102.57 151.04,102.57 150.48,103.13 148.65,103.13 146.44,105.34 144.63,105.34 143.69,106.28 135.12,106.28 132.79,103.94 132.79,103.16 131.86,102.23 127.72,102.23 127.36,101.87 125.23,101.87 124.92,102.18 113.23,102.18 112.41,103 103.54,103 102.47,101.93 101.02,101.93 100.57,101.48 97.54,101.48 96.7,102.31 94.77,102.31 93.53,103.56 86.6,103.56 85.1,105.06 v1(85.1,106.38)
TSNS0: length 59.5
  TOP w0.149: v1(194.62,62.46) 195.64,61.44 U47.8
  L07_SIG3 w0.089: v1(190.55,35.82) 189.14,37.22 189.14,38.48 188.07,39.55 188.07,49.65 v1(190.11,51.69) 190.11,51.7 188.04,53.77 188.04,60.56 191.75,64.26 191.75,65.33 190.34,66.74 v1(190.34,67.21) ; v1(194.62,62.46) 192.82,64.26 192.82,65.33 190.94,67.21 v1(190.34,67.21) ; v1(190.56,80.89) 190.56,80.51 190.21,80.16 arc(190.18,80.12) 190.17,80.07 190.17,68.16 190.33,68 190.33,67.22 v1(190.34,67.21)
UART_EN: length 23.2
  L12_SIG4 w0.089: v1(4.71,73.66) 5.93,73.66 12.2,67.39 22.3,67.39 v1(23.31,66.37)
  BOTTOM w0.149: v1(23.31,66.37) 23.33,66.36 U9.1
UART_RESETN: length 4.2
  BOTTOM w0.149: R175.2 26.11,71.9 25.84,71.63 24.76,71.63 24.58,71.81 R172.2 24.01,72.21 23.86,72.07 U11.18
UART_RSTN: length 81.2
  L07_SIG3 w0.089: v1(31.11,74.07) 28.96,71.92 28.96,68.02 26.93,65.99 25.92,65.99 24.52,64.6 24.52,64 21.98,61.46 21.98,51.89 21.09,51.01 21.09,47.45 20.84,47.2 20.84,37.29 19.69,36.15 19.69,22.61 21.55,20.75 22.61,20.75 23.25,20.12 23.25,17.48 24.77,15.95 29.98,15.95 30.49,16.46 30.49,17.86 31.23,18.6 31.23,21.62 v1(31.63,22.02)
  BOTTOM w0.149: U12.2 30.84,71.96 31.11,72.23 v1(31.11,74.07)
UART_RX: length 141.1
  L03_SIG1 w0.081: v1(89.8,79.93) 89.35,79.93 88.42,80.85 80.14,80.85 77.35,83.64 69.6,83.64 63.73,89.52 60.94,89.52 54.24,96.22 51.19,96.22 49.77,94.8 39.99,94.8 37.73,92.53 37.73,80.34 37.47,80.09 36.2,80.09 32.27,76.15 32.27,73.99 30.48,72.21 30.48,68.84 v1(29.28,67.64)
  L07_SIG3 w0.089: J9.1 20.61,23.42 20.61,28.09 20.16,28.54 20.16,35.98 21.22,37.04 21.22,44.02 21.72,44.53 22.23,44.53 22.61,44.91 22.61,54.05 23.12,54.56 23.12,61.95 25.12,63.95 25.12,64.56 26.04,65.48 27.31,65.48 27.76,65.93 28.52,65.93 28.84,66.25 28.84,67.2 v1(29.28,67.64)
UART_RX_LED: length 1.8
  BOTTOM w0.149: U11.21 24.07,70.57 R178.1
UART_TX: length 168.2
  L05_SIG2 w0.081: v1(16.14,74.75) 16.14,74.12 18.69,71.56 19.36,71.56 22.85,68.07 30.29,68.07 30.75,67.61 31.63,67.61 31.98,67.27 35.27,67.27 35.73,67.73 41.99,67.73 42.59,67.13 42.59,66.61 44.89,64.32 44.89,62.69 47.26,60.32 57.79,60.32 64.05,66.57 76.13,66.57 77.25,67.69 88.62,67.69 88.73,67.8 89.2,67.8 89.43,67.57 90.03,67.57 92.18,68.8 92.56,68.8 93.01,68.34 93.5,68.34 94.01,68.85 94.07,68.85 94.5,69.27 94.5,69.58 94.1,69.98 94.05,69.98 93.76,70.27 93.76,71.58 94.13,71.95 v1(94.13,72.43)
  L07_SIG3 w0.089: v1(16.14,74.75) 16.42,75.03 27.03,75.03 28.58,73.48 28.58,68.53 26.8,66.75 25.03,66.75 21.6,63.32 21.6,52.15 19.18,49.74 19.18,46.05 18.75,45.62 18.75,41.98 18.58,41.81 18.58,41.41 18.75,41.24 18.75,41.09 18.58,40.92 18.58,40.52 18.75,40.35 18.75,29.75 18.55,29.54 18.55,22.94 J9.2
UART_TX_LED: length 2
  BOTTOM w0.149: U11.22 23.55,70.07 R177.1
UBII_M10_VCCA:
  vias: v1(24.26,27) v1(24.9,28.02) v1(24.9,26.11) v1(29.23,26.02) v1(29.23,22.02) v1(34.03,26.82) v1(34.03,26.02) v1(34.03,21.22) v1(37.23,23.62) v1(37.23,21.22)
USB_DISABLEN: length 289.3
  L07_SIG3 w0.089: v1(27.95,54.69) 27.41,54.15 27.41,50.65 27.06,50.3 27.06,47 26.75,46.7 26.75,38.74 26.42,38.41 26.42,28.03 v1(26.83,27.62)
  L16_SIG6 w0.081: v1(223.8,107.87) v1(224.82,107.87) 225.35,107.87 225.51,107.72 225.51,106.78 225.23,106.5 222.1,106.5 220.66,107.95 217.18,107.95 214.92,105.69 212.44,105.69 212.28,105.53 211.15,105.53 209.51,107.16 206.04,107.16 204.92,108.27 197.27,108.27 195.09,106.1 192.03,106.1 188.6,109.53 130.81,109.53 130.26,110.07 126.32,110.07 125.77,109.53 101.86,109.53 101.33,110.06 97.62,110.06 96.73,109.18 73,109.18 72.08,110.1 68.58,110.1 67.58,109.1 50.48,109.1 49.41,108.03 48.65,108.03 46.74,106.12 46.24,106.12 42.93,102.82 42.93,101.81 41.63,100.5 39.34,100.5 37.23,98.39 36.35,98.39 32.79,94.83 32.79,91.21 31.27,89.69 31.15,89.69 29.85,88.39 29.85,87.82 29.54,87.52 28.97,87.52 28.67,87.21 27.79,87.21 27.42,86.84 27.42,86.51 27.04,86.13 26.62,86.13 25.75,85.26 25.32,85.26 24.48,84.42 24.48,82.8 24.17,82.49 24.17,81.65 23.67,81.14 23.67,80.21 22.69,79.24 22.69,76.63 22.44,76.38 22.44,75.47 22.69,75.21 22.69,74.21 21.49,73 21.49,63.5 22.23,62.75 22.23,57.51 23.15,56.59 23.15,54.59 23.64,54.1 27.36,54.1 v1(27.95,54.69)
USB_MAX_JTAGSEL: length 82.3
  L05_SIG2 w0.081: v1(35.63,27.62) 36.03,28.02 37.43,28.02 37.93,28.52 37.93,30.13 38.95,31.14 38.95,36.07 36.65,38.37 36.65,43.58 35.06,45.16 v1(34.04,45.16) 33.41,44.53 21.22,44.53 20.76,44.07 11.34,44.07 5.44,49.96 2.45,49.96 1.02,51.39 1.02,68.6 v1(2.67,70.25)
  BOTTOM w0.149: v1(34.04,45.16) 34.04,44.91 33.35,44.22 U29.15 ; SW2.1 3.77,69.85 3.37,70.25 v1(2.67,70.25)
USB_MAX_TCK: length 19
  L12_SIG4 w0.089: v1(31.63,27.62) 32.03,28.02 32.03,28.69 32.33,28.99 32.33,30.5 31,31.83 31,35.26 35.31,39.58 35.31,42.5 v1(34.93,42.88)
  BOTTOM w0.149: U29.2 34.75,42.7 v1(34.93,42.88)
USB_MAX_TDI: length 18.3
  L12_SIG4 w0.089: v1(32.43,25.22) 32.07,25.58 31.83,25.58 30.43,26.98 30.43,29.09 30.23,29.29 30.23,36.19 32.39,38.35 v1(32.39,40.34)
  BOTTOM w0.149: v1(32.39,40.34) 32.68,40.34 32.95,40.61 U29.7
USB_MAX_TDO: length 21.8
  L12_SIG4 w0.089: v1(32.43,24.42) 31.23,25.62 29.86,25.62 29.63,25.85 29.63,36.06 31.88,38.32 31.88,41.61 v1(31.38,42.12)
  BOTTOM w0.149: v1(31.38,42.12) 31.56,42.3 U29.10
USB_MAX_TMS: length 15.3
  L12_SIG4 w0.089: v1(34.3,40.34) 34.3,39.45 33.73,38.88 33.39,38.88 30.61,36.11 30.61,31.19 31.44,30.37 31.44,29.1 31.63,28.91 v1(31.63,28.42)
  BOTTOM w0.149: v1(34.3,40.34) 34.08,40.34 33.75,40.66 U29.5
USB_T_CLK: length 22.2
  L03_SIG1 w0.081: v4(30.83,24.42) 31.07,24.42 31.47,24.02 31.79,24.02 32.03,23.78 32.03,22.66 31.79,22.42 31.47,22.42 31.23,22.18 31.23,21.86 30.99,21.62 30.67,21.62 30.43,21.38 30.43,21.06 30.19,20.82 29.87,20.82 29.63,20.58 29.63,19.46 29.39,19.22 29.06,19.22 28.83,19 28.83,18.66 28.19,18.02 24.73,18.02 24.39,18.37 21.47,18.37 20.86,18.98 16.67,18.98 v1(16.14,19.51)
USB_UART_5V: length 2.5
  TOP w0.254: U13.6 v1(19.03,103.55)
  BOTTOM w0.254: U11.19 23.63,71.57
  BOTTOM w0.381: v1(24.52,71.07) v1(24.02,71.57) 23.63,71.57
  vias: v1(19.95,104.16) v1(26.8,69.93) v1(26.8,68.91)
USB_UART_CON_5V: length 5.8
  TOP w0.279: v1(19.21,107.65) J10.1 19.21,106.04 19.95,105.31 v1(19.95,105.04)
  BOTTOM w0.381: C256.2 17.98,107.52 19.09,107.52 v1(19.21,107.65) ; v1(19.95,105.04) 19.37,104.47 C257.1
USB_UART_DM: length 38.5
  TOP w0.102: J10.2 18.56,106.52 18.35,106.31 18.35,106.14 v1(18.61,105.88) 18.35,105.63 18.35,105.45 18.49,105.31 U13.1
  L03_SIG1 w0.079: v1(22.22,74.63) 21.93,74.63 21.83,74.73 21.83,75.56 22.12,75.85 22.12,78.8 21.16,79.76 21.16,81.69 22.08,82.6 22.08,100.13 19.48,102.72 18.9,102.72 18.35,103.27 18.35,105.63 v1(18.61,105.88)
  BOTTOM w0.102: U11.15 21.96,73.48 21.83,73.61 21.83,74.23 v1(22.22,74.63)
USB_UART_DP: length 38.5
  TOP w0.102: U13.2 17.99,105.31 18.12,105.45 18.12,105.63 v1(17.87,105.88) 18.12,106.14 18.12,106.29 17.91,106.5 J10.3
  L03_SIG1 w0.079: v1(21.2,74.63) 21.5,74.63 21.6,74.73 21.6,75.65 21.89,75.94 21.89,78.71 20.93,79.67 20.93,81.78 21.85,82.7 21.85,100.04 19.39,102.5 18.81,102.5 18.12,103.18 18.12,105.63 v1(17.87,105.88)
  BOTTOM w0.102: v1(21.2,74.63) 21.6,74.23 21.6,73.61 21.46,73.47 U11.14
VFB0: length 3.1
  TOP w0.149: U47.12 196.19,59.84 195.78,59.43 v1(195.43,59.43)
  BOTTOM w0.149: R5936.1 194.63,59.78 194.99,59.43 v1(195.43,59.43)
VOSNS0_1P8V: length 6.1
  L16_SIG6 w0.081: v1(232.16,55.58) 231.6,55.02 227.64,55.02 v1(227.08,55.58)
  BOTTOM w0.203: v1(227.08,55.58) 227.08,55.61 R5963.2
VOSNS+: length 65.2
  TOP w0.254: U125.B1 v1(209.12,92.66)
  L03_SIG1 w0.203: v1(209.12,92.66) 209.12,93.35 208.58,93.89 201.77,93.89 200.87,92.99 200.87,92.42 201.03,92.26 201.28,92.26 v1(201.56,92.53)
  BOTTOM w0.254: R5784.2 156.65,81.88 156.65,83.34 156.95,83.64 156.95,84.56 157.51,85.12 157.51,89.87 158.4,90.76 198,90.76 199.52,92.28 201.3,92.28 v1(201.56,92.53)
VOSNS-: length 65.8
  TOP w0.254: U125.C2 v1(209.92,93.46)
  L03_SIG1 w0.203: v1(209.92,93.46) 209.45,93.46 209.45,93.49 208.72,94.22 201.64,94.22 200.54,93.13 200.54,92.28 200.9,91.93 201.28,91.93 v1(201.56,91.65)
  BOTTOM w0.254: v1(201.56,91.65) 201.3,91.9 199.68,91.9 198.16,90.38 158.55,90.38 157.89,89.72 157.89,84.97 157.33,84.41 157.33,83.67 157.61,83.39 R5786.2
VREF_B: length 5.6
  TOP w0.381: v1(50.24,99.01) v1(49.35,98.12)
  BOTTOM w0.381: R180.1 v1(49.35,98.12) 48.9,98.12 48.39,97.61 47.51,97.61 47.24,97.88 U14.19
VTT_DDR4_CH01_EN: length 276.7
  L03_SIG1 w0.127: v1(58.3,100.41) 57.28,100.41 56.6,99.72 54.79,99.72 52.2,102.31 50.68,102.31 v1(48.65,104.35)
  L12_SIG4 w0.127: v1(58.3,100.41) 59.06,99.65 62.87,99.65 65.83,102.61 70.35,102.61 71.5,103.75 74.21,103.75 76.08,105.62 83.57,105.62 84.75,106.79 85.5,106.79 86.19,106.1 86.19,104.85 87.13,103.91 93.91,103.91 95.16,102.67 97.04,102.67 97.7,102.01 100.44,102.01 100.69,102.26 102.12,102.26 103.21,103.36 112.27,103.36 112.6,103.69 113.29,103.69 114.44,102.54 125.12,102.54 125.43,102.24 127.26,102.24 127.58,102.56 131.71,102.56 132.51,103.35 132.51,104.06 135,106.56 147.05,106.56 149.99,103.61 156.39,103.61 156.85,103.15 176.44,103.15 176.89,103.61 185.22,103.61 186.72,102.11 194.02,102.11 196.59,99.55 201.37,99.55 202.15,100.33 204.89,100.33 206.44,98.78 207.6,98.78 209.42,96.97 225.84,96.97 232.86,89.95 232.86,88.01 233.92,86.95 237.34,86.95 237.9,86.39 237.9,84.66 239.74,82.83 239.74,79.79 240.06,79.46 240.06,67.9 240.45,67.52 241.95,66.02 241.95,64.87 243.21,63.6 243.21,57.15 243.97,56.39 243.97,52.68 244.51,52.15 244.51,51.46 243.99,50.94 243.99,43.56 244.34,43.21 244.34,42.42 244.11,42.19 244.11,41.28 244.79,40.61 244.79,30.18 246.44,28.53 246.44,26.84 247.21,26.07 v1(247.21,25.61)
VTT_DDR4_CH23_EN: length 49.2
  TOP w0.127: R655.2 209.23,22.68 v1(209.23,22.68)
  L16_SIG6 w0.127: v1(247.11,22.41) 247.11,22.33 246.77,21.99 246.77,18.65 243.77,15.65 219.21,15.65 218.55,14.99 216.42,14.99 215.86,15.55 215.86,15.85 213.72,17.99 210.07,17.99 209.23,18.82 v1(209.23,22.68)
