# Allegro board TS28247BC0_FM61_agilex_PCIe_DEVKIT_ADI_REVB1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N17328275:
  vias: v1(66.17,96.73) v1(66.19,96.03) v1(66.19,92.79) v1(66.17,92.03)
N17329090:
  vias: v1(192.84,97.44)
N22385889: length 6.2
  L12_SIG4 w0.089: v1(31,29.28) 31,28.91 31.23,28.67 31.23,26.67 31.53,26.37 32.09,26.37 v1(33.23,25.22)
  BOTTOM w0.149: R334.1 v1(31,29.28)
N23293405: length 378.5
  L07_SIG3 w0.089: v1(22.94,28.15) 22.94,35.22 23.63,35.9 23.63,35.91 23.63,41.07 26.05,43.5 26.05,50.12 27.06,51.12 27.06,54.82 28.07,55.83 28.58,55.83 v1(29.22,56.47)
  L16_SIG6 w0.081: v1(29.22,56.47) 28.96,56.72 28.96,61.17 28.84,61.29 28.84,62.94 27.95,63.83 27.95,65.48 27.62,65.81 27.62,72.85 27.77,73 27.77,74.98 28.17,75.39 28.17,78.06 29.23,79.12 29.89,79.12 30.36,79.59 30.36,80.88 31.12,81.64 31.99,81.64 33.88,83.54 33.88,84.04 35.39,85.55 35.39,87.34 37.1,89.05 37.1,89.83 39.44,92.16 39.44,92.72 40.2,93.48 40.82,93.48 43.82,96.48 44.97,96.48 47.82,99.33 49.17,99.33 49.68,99.84 53.92,99.84 55.89,101.81 55.89,102.31 58.76,105.18 63.99,105.18 66.02,103.15 67.65,103.15 67.95,103.45 69.54,103.45 69.76,103.23 71.2,103.23 71.66,103.69 75.4,103.69 76.3,104.59 83.71,104.59 84.12,104.99 86.05,104.99 86.39,104.65 92.05,104.65 92.28,104.88 92.86,104.88 93.15,104.59 95.3,104.59 95.6,104.28 96.29,104.28 97.11,103.46 102.77,103.46 102.94,103.62 107.07,103.62 108.24,104.78 108.24,105.41 109.07,106.25 122.1,106.25 123.2,105.16 123.2,104.94 126,102.14 127.2,102.14 127.61,102.55 131.78,102.55 133.91,104.68 133.91,105.21 134.95,106.25 144.27,106.25 145.14,105.38 145.95,105.38 146.31,105.74 182.51,105.74 183.04,105.21 183.04,102.59 184.11,101.53 185.58,101.53 187.33,99.77 187.33,98.5 188.15,97.68 188.15,97.05 188.48,96.73 193.94,96.73 196.04,98.83 203.41,98.83 203.44,98.81 203.81,98.81 203.84,98.84 205.5,98.84 206.01,98.33 216.94,98.33 217.4,98.79 219,98.79 219.56,98.22 234.55,98.22 237.47,101.15 242.7,101.15 243.9,99.95 243.9,99.29 246.6,96.59 247.77,96.59 248.55,95.81 253.63,95.81 254.13,96.32 254.13,96.34 256.65,98.85 261.07,98.85 261.45,98.48 261.47,98.48 270.16,89.8 270.16,69.03 265.23,64.11 265.23,64.09 265.2,64.06 265.2,62.28 264.29,61.37 264.29,49.61 v1(263.91,49.23)
N31006327: length 2.2
  BOTTOM w0.149: v1(4.58,25.11) 5.52,25.11 R327.2
N31014989: length 3.4
  L05_SIG2 w0.081: v1(37.23,26.02) 36.83,25.62 36.83,25.09 36.56,24.82 35.23,24.82 v1(34.83,25.22)
N31015011: length 5.5
  L03_SIG1 w0.081: v4(33.23,23.62) 33.23,23.65 33.6,24.02 38.03,24.02 v1(38.43,23.62)
N31015146: length 6.2
  L03_SIG1 w0.081: v1(38.43,20.42) 37.71,21.14 37.71,21.62 36.9,22.43 35.38,22.43 35.23,22.58 35.23,22.98 34.99,23.22 34.43,23.22 v4(34.03,23.62)
N31015158: length 4.7
  L07_SIG3 w0.089: v1(34.83,26.02) 35.23,26.42 35.23,26.98 35.47,27.22 35.79,27.22 36.03,27.46 36.03,28.63 36.3,28.91 36.79,28.91 v1(37.19,29.31)
N31093028: length 0.9
  BOTTOM w0.149: R358.2 C355.1
N31250983: length 7.4
  TOP w0.149: J7.B11 55.38,3.84 55.38,9.92 R101.1
N31253181: length 7
  TOP w0.149: R104.2 53.66,10.49 J7.B9
N31257069:
  vias: v1(54.24,8.33) v1(54.24,7.44) v1(54.87,8.33) v1(54.87,7.44)
N31314586: length 7.6
  L16_SIG6 w0.081: v1(243.34,55.83) 242.78,56.39 242.2,56.39 240.24,58.35 240.24,59.62 v1(238.67,61.19)
N31314601: length 7.7
  L16_SIG6 w0.081: v1(237.37,61.22) 238.25,60.34 238.83,60.34 239.78,59.39 239.78,58.12 v1(242.07,55.83)
N31314621: length 1.6
  BOTTOM w0.149: C444.2 R433.2 244.67,55.9 v1(244.61,55.83)
N31314744: length 0.8
  BOTTOM w0.149: R435.1 243.1,52.26 v1(243.34,52.02)
N31314754: length 3.2
  TOP w0.149: 242.07,50.75 v1(241.38,50.75)
  BOTTOM w0.149: C448.2 v1(241.38,50.75) 241.79,50.75 242.65,49.89 242.65,49.62 242.85,49.42 242.96,49.42 R434.1
N31314797: length 1.8
  BOTTOM w0.149: R438.1 244,55.59 244.11,55.48 244.11,55.38 R436.1 244.29,54.88 v1(244.61,54.56)
N31314853: length 1.6
  BOTTOM w0.33: v1(242.07,54.56) 241.43,53.93 R437.1
N31314899: length 0.8
  TOP w0.149: v1(241.37,51.67) 241.73,52.02 242.07,52.02
N31314949: length 6
  TOP w0.33: v1(239.62,56.06) 239.35,55.79 239.35,54.05 240.11,53.29 242.07,53.29
  BOTTOM w0.33: v1(239.62,56.06) 240.43,56.06 R440.1
N31314957: length 5.8
  TOP w0.149: U43.B1 243.02,50.43 R443.2 ; R443.2 243.57,49 243.95,48.62 R439.2 C453.1 ; R443.2 243.02,48.15 C455.2
N31352894: length 2.3
  BOTTOM w0.149: SW3.5 13.33,66.3 R295.2
N31352897: length 2
  BOTTOM w0.149: SW3.6 13.22,65.03 13.48,65.29 R297.2
N31352900: length 2.1
  BOTTOM w0.149: SW3.7 12.96,63.76 13.33,63.39 R299.2
N31388806:
  vias: v1(269.82,38.31)
N31388830: length 1.8
  TOP w0.149: R306.1 268.42,34.81 268.74,35.13 D7.A
N31388866: length 14.7
  BOTTOM w0.149: Q5.3 262.47,40.04 263.41,40.97 266.58,40.97 268.49,39.07 270.14,39.07 270.64,38.56 270.64,37.92 271.79,36.78 271.79,35.77 271.24,35.22 v1(271.24,35.13)
N31388880: length 9.1
  BOTTOM w0.149: v1(271.24,38.18) 271.79,38.73 271.79,41.48 271.28,41.99 268.06,41.99 Q7.3
N31388890:
  vias: v1(269.82,39.96)
N31388919: length 10.9
  BOTTOM w0.149: v1(271.24,39.7) 270.35,40.59 267.98,40.59 267.22,41.35 263.02,41.35 262.47,41.9 Q8.3
N31389008:
  vias: v1(269.82,42.62)
N31389082: length 7.6
  BOTTOM w0.149: Q9.3 268.32,46.86 270.52,44.66 270.52,43.47 v1(271.24,42.75)
N31389304: length 1.8
  TOP w0.149: R317.1 268.42,46.12 268.74,45.8 D14.A
N31389320:
  vias: v1(269.82,44.15)
N31389364: length 8.7
  BOTTOM w0.149: v1(271.24,44.27) 271.91,44.95 271.91,50.5 270.98,51.43 Q10.3
N31389378: length 1.7
  BOTTOM w0.149: v1(271.24,45.8) 270.9,45.8 270.14,46.56 Q11.3
N31389867: length 3.3
  BOTTOM w0.149: R321.1 268.04,51.07 269.19,49.92 Q11.1
N31415897: length 1
  TOP w0.149: R409.1 248.22,90.25 Q12.4
N31415950: length 3.1
  TOP w0.149: U37.1 245.84,90.75 246.2,91.11 C426.1 246.65,90.67 246.6,90.62 R409.2
N31416024: length 19.9
  TOP w0.149: U37.5 243.89,86.75 v1(243.87,86.77)
  BOTTOM w0.149: v1(243.87,86.77) 243.44,87.2 240.65,87.2 238.89,85.45 238.89,83.21 239.4,82.71 239.4,80.95 240.6,79.75 Q13.3 242.13,79.75 242.3,79.58 243.01,79.58 244.28,80.85 245.14,80.85 245.51,80.48 R411.2
N31416063: length 3.9
  TOP w0.149: U37.6 244.58,85.03 v1(244.58,86.29)
  BOTTOM w0.149: R416.1 244.6,86.27 v1(244.58,86.29)
N31416065: length 2.7
  BOTTOM w0.149: R415.2 C432.1 R414.1 R412.2
N31416086: length 2.5
  BOTTOM w0.149: R415.1 239.73,83.76 240.36,83.14 Q13.1
N31872869: length 5.5
  L07_SIG3 w0.127: 256.15,32.62 256.15,31.86 v1(256.55,31.46)
  L07_SIG3 w0.254: 256.15,32.62 256.15,35.09 v1(255.66,35.58)
  BOTTOM w0.254: R362.1 v1(255.66,35.58)
N31872899: length 2.5
  BOTTOM w0.254: C384.1 R369.1 256.67,32.84 256.55,32.71 v1(256.55,32.26)
N31873008: length 5.6
  L07_SIG3 w0.127: v1(257.35,31.46) 256.95,31.86 256.95,32.62
  L07_SIG3 w0.254: v1(257.69,35.58) 257.15,35.03 257.15,33.57 256.95,33.37 256.95,32.62
  BOTTOM w0.254: R372.1 v1(257.69,35.58)
N31873022: length 6.5
  L07_SIG3 w0.089: v1(250.95,29.06) 250.55,29.46 250,29.46 249.75,29.71 249.75,30.75 248.55,31.96 248.55,32.97 248.29,33.23 247.97,33.23 v1(247.53,33.67)
N31873048: length 4.5
  L07_SIG3 w0.089: v1(250.15,29.86) 250.15,30.86 248.93,32.08 248.93,33.29 v1(248.55,33.67)
N31873076: length 9.6
  L07_SIG3 w0.254: v1(251.59,35.58) 252.1,35.07 252.1,34.22 252.89,33.43 252.89,31.81 253.6,31.1 253.6,30.41 253.96,30.05 255.14,30.05 v1(255.75,30.66)
  BOTTOM w0.254: R375.1 v1(251.59,35.58)
N31873106: length 4.4
  L07_SIG3 w0.089: v1(250.95,29.86) 250.95,31.33 249.56,32.72 v1(249.56,33.67)
N31873136: length 4.1
  L07_SIG3 w0.089: v1(250.15,29.06) 249.97,29.06 249.59,29.44 248.65,29.44 248.09,30 v1(248.09,31.7)
N31873164: length 9
  L07_SIG3 w0.127: 257.61,31.06 257.12,31.06 256.95,30.88 256.95,30.48 256.73,30.26 256.15,30.26 v1(255.75,29.86)
  L07_SIG3 w0.254: 257.61,31.06 258.16,31.61 258.16,33.19 259.21,34.24 259.21,35.07 v1(259.72,35.58)
  BOTTOM w0.254: R376.1 v1(259.72,35.58)
N31873212: length 1.6
  BOTTOM w0.149: R367.1 248.52,30.69 v1(249.35,29.86)
N31873240: length 2.6
  BOTTOM w0.254: R381.1 C388.1 257.69,32.6 v1(257.35,32.26)
N31873256: length 7.8
  L07_SIG3 w0.089: v1(249.56,35.58) 249.56,35.25 249.97,34.84 249.97,34.6 252.15,32.42 252.15,29.46 v1(252.55,29.06)
N31873294: length 1.5
  BOTTOM w0.149: v1(249.35,29.06) 248.73,29.67 R370.1
N31873322: length 3.2
  TOP w0.254: U30.B1 v1(258.95,33.06)
  BOTTOM w0.254: R383.1 C389.1 259.11,33.06 v1(258.95,33.06)
N31873334: length 1.5
  BOTTOM w0.149: v1(249.35,28.26) 248.73,27.64 R371.1
N31873366: length 3.9
  TOP w0.254: U30.F1 v1(254.15,33.06)
  BOTTOM w0.254: v1(254.15,33.06) 253.22,33.06 R384.1 C390.1
N31873370: length 1.6
  BOTTOM w0.149: v1(249.35,27.46) 248.51,26.62 R373.1
N31873414: length 2.9
  BOTTOM w0.254: v1(255.75,32.26) 255.37,32.63 255.37,32.94 R386.1 C391.1
N31873418: length 5.1
  L07_SIG3 w0.089: v1(248.09,23.57) 248.55,24.03 248.55,26.49 249.11,27.06 249.75,27.06 v1(250.15,27.46)
N31873454: length 1.7
  BOTTOM w0.149: R377.1 249.15,26.66 v1(249.35,26.66)
N31873498: length 10.5
  L07_SIG3 w0.089: v1(248.11,20.4) 248.5,20.4 249,20.91 249.42,20.91 250.53,22.02 250.53,24.03 252.97,26.47 252.97,27.84 252.55,28.26 v1(252.55,28.26)
N31873524: length 5.1
  L07_SIG3 w0.089: v1(250.15,26.66) 249.72,26.23 249.72,25.03 248.93,24.23 248.93,23.73 248.09,22.89 248.09,22.58 v1(248.24,22.43)
N31875898: length 4.7
  L05_SIG2 w0.081: v1(259.79,28.27) 259.35,27.84 257.06,27.84 255.84,29.06 v1(255.75,29.06)
N31875914: length 4.2
  BOTTOM w0.149: R391.1 251.28,32.97 252.61,32.97 253.33,32.26 v1(254.15,32.26)
N31875930: length 7.1
  L07_SIG3 w0.089: v1(254.15,31.46) 253.75,31.85 253.75,33.66 253.02,34.39 253.02,35.03 252.05,35.99 251.06,35.99 250.64,35.58 v1(250.58,35.58)
N31875950: length 7.1
  L07_SIG3 w0.089: v1(259.79,31.32) 260.18,30.93 260.18,30 259.95,29.77 259.54,29.77 259.23,29.46 255.35,29.46 v1(254.95,29.06)
N31875960: length 7.6
  L07_SIG3 w0.089: v1(254.95,28.26) 255.19,28.26 255.58,27.87 256.67,27.87 256.95,27.59 256.95,27.29 257.18,27.06 259.14,27.06 259.49,26.7 260.03,26.7 260.23,26.49 260.23,25.68 259.79,25.24 v1(259.79,25.22)
N31875982: length 6.1
  L07_SIG3 w0.089: v1(259.79,23.19) 258.3,24.68 257.99,24.68 257.03,25.64 257.03,25.94 256.01,26.95 256.01,27.19 v1(255.75,27.46)
N31876004: length 2.6
  L07_SIG3 w0.089: v1(259.79,30.3) 259.26,30.3 259.24,30.28 257.77,30.28 v1(257.35,29.86)
N31876008: length 4.4
  L07_SIG3 w0.089: v1(259.79,27.26) 260.2,27.68 260.2,28.38 259.91,28.68 257.72,28.68 v1(257.35,29.06)
N32052935: length 5.7
  TOP w0.254: U32.23 71.39,84.93 71.33,84.87 70.79,84.87 70.05,84.12 C710.1 R401.1
N32053041: length 4.8
  TOP w0.254: R402.1 C710.2 70.94,84.38 71.04,84.49 71.3,84.49 71.36,84.43 U32.24
N32057804: length 3.5
  TOP w0.149: R444.1 C458.1
  TOP w0.254: U44.3 R448.1 R444.1
N32057806: length 1.1
  TOP w0.254: C466.1 U44.6
N32057886: length 1.8
  TOP w0.254: U44.7 250.86,43 250.63,42.77 R446.2
N32121976: length 3.5
  BOTTOM w0.254: U45.3 25.49,37.97 R449.2 R445.1 C459.1
N32121978: length 1.4
  BOTTOM w0.254: C467.1 24.39,43.58 U45.6
N32122058: length 1.4
  BOTTOM w0.254: U45.7 24.99,43.79 R447.2
N32230321: length 12
  TOP w0.149: v1(243.62,92.51) 243.63,92.5 U34.4
  L12_SIG4 w0.089: v1(243.62,92.51) 243.97,92.87 243.97,96.85 245.09,97.97 245.93,97.97 247.28,99.32 v1(247.28,100.04)
  BOTTOM w0.149: U36.5 246.73,100.59 v1(247.28,100.04)
N32230341: length 2.5
  BOTTOM w0.149: U36.3 246.23,103.83 246.25,103.84 R406.2
  BOTTOM w0.254: R406.2 246.25,105.18 R410.2
N32230392: length 2.7
  BOTTOM w0.149: U36.2 245.73,104.3 R413.1
  BOTTOM w0.254: R413.1 245.36,104.97 244.95,105.37 R410.1
N32230759: length 8.2
  TOP w0.254: v1(257.39,97.92) 257.39,98.91 257.3,98.99 U35.3 ; U33.4 v1(253.11,95.12)
  L12_SIG4 w0.254: v1(257.39,97.92) 255.28,97.92 253.11,95.75 v1(253.11,95.12)
N32232827: length 7.3
  TOP w0.149: U38.4 259.76,77.43 260.74,78.41 v1(261.98,78.41)
  BOTTOM w0.149: v1(261.98,78.41) 263.48,78.41 263.78,78.71 263.78,78.93 263.4,79.31 U40.3
N32233406: length 5.5
  TOP w0.149: v1(253.58,79.05) 253.17,79.05 U39.4
  BOTTOM w0.149: U41.5 249.46,78.99 249.51,79.04 R829.1 253.57,79.04 v1(253.58,79.05)
N32233436: length 2.1
  BOTTOM w0.149: R418.2 248.03,81.74 248.11,81.66 U41.3
  BOTTOM w0.254: R421.2 R418.2
N32233467: length 3.3
  BOTTOM w0.254: U41.8 247.11,78.63 246.57,78.09 246.27,78.09 245.85,78.5 R417.2 R420.1
N32233496: length 3.2
  BOTTOM w0.149: R421.1 246.25,81.74 246.38,81.61 247.35,81.61 247.61,81.35 U41.2
  BOTTOM w0.254: R421.1 R422.1
N32233958: length 3.6
  BOTTOM w0.254: SW5.4 262.81,75.49 R426.1
N32406903: length 3.6
  BOTTOM w0.254: SW5.6 262.81,71.48 R428.1
N32408103: length 2.2
  BOTTOM w0.149: U36.8 245.23,100.55 245.46,100.32 R405.2 R408.1
N32408438: length 3.1
  TOP w0.254: U42.3 258.64,56.4 258.13,56.91 R427.2 258.2,58.05 R425.2
N32408441: length 3.1
  TOP w0.254: R430.1 257.18,58.05 R427.1 257.25,56.91 256.74,56.4 U42.4
N32411757: length 1.3
  BOTTOM w0.149: R385.1 250.15,21.4 v1(250.15,22.66)
N32411786: length 7.5
  L07_SIG3 w0.127: v1(256.55,30.66) 256.15,31.06 255.54,31.06 255.35,31.25 255.35,31.7
  L07_SIG3 w0.203: 255.35,31.7 254.83,32.22 254.83,33.67 254.13,34.37 254.13,35.07 v1(253.63,35.58)
  BOTTOM w0.254: R360.1 v1(253.63,35.58)
N33149453: length 6.1
  L07_SIG3 w0.089: v1(259.79,24.21) 259.79,24.6 259.41,24.98 259.41,26.12 259.11,26.42 258.68,26.42 258.34,26.08 257.37,26.08 256.55,26.9 v1(256.55,27.46)
N33771526: length 6
  BOTTOM w0.149: Q6.3 266.92,38.22 267.34,37.8 269.63,37.8 269.82,37.61 R308.2 270.61,37.29 v1(271.24,36.65)
N33771550:
  vias: v1(269.82,36.4)
N34054433:
  vias: v1(269.82,41.23)
N34315909: length 1
  BOTTOM w0.149: C336.2 265.12,60.02 R322.2
N34315982: length 1
  BOTTOM w0.149: R323.2 264.17,55.13 C337.2
N34474357: length 1.3
  BOTTOM w0.149: U21.2 18.34,48.99 R288.1
N34474360: length 1.5
  BOTTOM w0.149: R289.1 17.85,48.59 U21.3
N34525726:
  vias: v1(24.39,109.92) v1(25.39,109.92) v1(26.39,109.92) v1(27.39,109.92) v1(28.39,109.92) v1(29.39,109.92) v1(30.39,109.92) v1(31.39,109.92) v1(32.39,109.92) v1(33.39,109.92) v1(34.39,109.92) v1(38.39,109.92) v1(39.39,109.92) v1(40.39,109.92) v1(41.39,109.92) v1(42.39,109.92) v1(43.39,109.92) v1(44.39,109.92) v1(45.39,109.92) v1(46.39,109.92) v1(47.39,109.92) v1(48.39,109.92) v1(49.39,109.92) v1(50.39,109.92) v1(51.39,109.92) v1(52.39,109.92) v1(53.39,109.92) v1(54.39,109.92) v1(55.39,109.92) v1(56.39,109.92) v1(57.39,109.92) v1(58.39,109.92) v1(59.39,109.92) v1(60.39,109.92) v1(61.39,109.92) v1(62.39,109.92) v1(63.39,109.92) v1(64.39,109.92) v1(65.39,109.92) v1(66.39,109.92) v1(67.39,109.92) v1(74.39,109.92) v1(75.39,109.92) v1(76.39,109.92) v1(77.39,109.92) v1(78.39,109.92) v1(79.39,109.92) v1(80.39,109.92) v1(81.39,109.92) v1(82.39,109.92) v1(83.39,109.92) v1(84.39,109.92) v1(85.39,109.92) v1(86.39,109.92) v1(87.39,109.92) v1(88.39,109.92) v1(89.39,109.92) v1(90.39,109.92) v1(91.39,109.92) v1(92.39,109.92) v1(93.39,109.92) v1(94.39,109.92) v1(95.39,109.92) v1(96.39,109.92) v1(102.39,109.92) v1(103.39,109.92) v1(104.39,109.92) v1(105.39,109.92) v1(106.39,109.92) v1(107.39,109.92) v1(108.39,109.92) v1(109.39,109.92) v1(110.39,109.92) v1(111.39,109.92) v1(112.39,109.92) v1(113.39,109.92) v1(114.39,109.92) v1(115.39,109.92) v1(116.39,109.92) v1(117.39,109.92) v1(118.39,109.92) v1(119.39,109.92) v1(120.39,109.92) v1(121.39,109.92) v1(122.39,109.92) v1(123.39,109.92) v1(124.39,109.92) v1(125.39,109.92) v1(131.39,109.92) v1(132.39,109.92) v1(133.39,109.92) v1(134.39,109.92) v1(135.39,109.92) v1(136.39,109.92) v1(137.39,109.92) v1(138.39,109.92) v1(139.39,109.92) v1(140.39,109.92) v1(141.39,109.92) v1(142.39,109.92) v1(143.39,109.92) v1(143.39,13.98) v1(144.39,109.92) v1(144.39,13.98) v1(145.39,109.92) v1(145.39,13.98) v1(146.38,109.92) v1(146.38,13.98) v1(147.38,109.92) v1(147.38,13.98) v1(148.38,109.92) v1(148.38,13.98) v1(149.38,109.92) v1(149.38,13.98) v1(150.38,109.92) v1(150.38,13.98) v1(151.38,109.92) v1(151.38,13.98) v1(152.38,109.92) v1(152.38,13.98) v1(153.38,109.92) v1(153.38,13.98) v1(154.38,109.92) v1(154.38,13.98) v1(155.38,109.92) v1(155.38,13.98) v1(156.38,109.92) v1(156.38,13.98) v1(157.38,109.92) v1(157.38,13.98) v1(158.38,109.92) v1(158.38,13.98) v1(159.38,109.92) v1(159.38,13.98) v1(160.38,109.92) v1(160.38,13.98) v1(161.38,109.92) v1(161.38,13.98) v1(162.38,109.92) v1(162.38,13.98) v1(163.38,109.92) v1(163.38,13.98) v1(164.38,109.92) v1(164.38,13.98) v1(165.38,109.92) v1(165.38,13.98) v1(166.38,109.92) v1(166.38,13.98) v1(167.38,109.92) v1(168.38,109.92) v1(169.38,109.92) v1(170.38,109.92) v1(171.38,109.92) v1(172.38,109.92) v1(172.38,13.98) v1(173.38,109.92) v1(173.38,13.98) v1(174.38,109.92) v1(174.38,13.98) v1(175.38,109.92) v1(175.38,13.98) v1(176.38,109.92) v1(176.38,13.98) v1(177.38,109.92) v1(177.38,13.98) v1(178.38,109.92) v1(178.38,13.98) v1(179.38,109.92) v1(179.38,13.98) v1(180.38,109.92) v1(180.38,13.98) v1(181.38,109.92) v1(181.38,13.98) v1(182.38,109.92) v1(182.38,13.98) v1(183.38,109.92) v1(183.38,13.98) v1(184.38,109.92) v1(184.38,13.98) v1(185.38,109.92) v1(185.38,13.98) v1(186.38,109.92) v1(186.38,13.98) v1(187.38,109.92) v1(187.38,13.98) v1(188.38,109.92) v1(188.38,13.98) v1(189.38,109.92) v1(189.38,13.98) v1(190.38,109.92) v1(195.38,13.98) v1(196.38,109.92) v1(196.38,13.98) v1(197.38,109.92) v1(197.38,13.98) v1(198.38,109.92) v1(198.38,13.98) v1(199.38,109.92) v1(199.38,13.98) v1(200.38,109.92) v1(200.38,13.98) v1(201.38,109.92) v1(201.38,13.98) v1(202.38,109.92) v1(202.38,13.98) v1(203.38,109.92) v1(203.38,13.98) v1(204.38,109.92) v1(204.38,13.98) v1(205.38,109.92) v1(205.38,13.98) v1(206.38,109.92) v1(206.38,13.98) v1(207.38,109.92) v1(207.38,13.98) v1(208.38,109.92) v1(208.38,13.98) v1(209.38,109.92) v1(209.38,13.98) v1(210.38,109.92) v1(210.38,13.98) v1(211.38,109.92) v1(216.38,109.92) v1(216.38,13.98) v1(217.38,109.92) v1(217.38,13.98) v1(218.38,109.92) v1(218.38,13.98) v1(219.38,109.92) v1(219.38,13.98) v1(220.38,109.92) v1(220.38,13.98) v1(221.38,109.92) v1(221.38,13.98) v1(222.38,109.92) v1(223.38,109.92) v1(223.38,13.98) v1(224.38,109.92) v1(224.38,13.98) v1(225.38,109.92) v1(225.38,13.98) v1(226.38,109.92) v1(226.38,13.98) v1(227.38,109.92) v1(227.38,13.98) v1(228.38,109.92) v1(228.38,13.98) v1(229.38,109.92) v1(229.38,13.98) v1(230.38,109.92) v1(230.38,13.98) v1(231.38,109.92) v1(231.38,13.98) v1(232.38,109.92) v1(232.38,13.98) v1(233.38,109.92) v1(233.38,13.98) v1(234.38,109.92) v1(234.38,13.98) v1(235.38,109.92) v1(235.38,13.98) v1(236.38,109.92) v1(236.38,13.98) v1(237.38,109.92) v1(237.38,13.98) v1(238.38,109.92) v1(238.38,13.98) v1(239.38,109.92) v1(239.38,13.98) v1(240.38,109.92) v1(240.38,13.98) v1(241.38,109.92) v1(241.38,13.98) v1(242.38,109.92) v1(242.38,13.98) v1(243.38,109.92) v1(243.38,13.98) v1(244.38,109.92) v1(244.38,13.98) v1(245.38,109.92) v1(245.38,13.98) v1(250.38,109.92) v1(250.38,13.98) v1(251.38,109.92) v1(251.38,13.98) v1(252.38,109.92) v1(252.38,13.98) v1(253.38,109.92) v1(253.38,13.98) v1(254.38,109.92) v1(254.38,13.98) v1(255.38,109.92) v1(255.38,13.98) v1(256.38,109.92) v1(256.38,13.98) v1(257.38,109.92) v1(257.38,13.98) v1(258.38,109.92) v1(258.38,13.98) v1(259.38,109.92) v1(259.38,13.98) v1(260.38,109.92) v1(260.38,13.98) v1(261.38,109.92) v1(261.38,13.98) v1(262.38,109.92) v1(262.38,13.98) v1(263.38,109.92) v1(263.38,13.98) v1(264.38,109.92) v1(264.38,13.98) v1(265.38,109.92) v1(265.38,13.98) v1(273.09,102.43) v1(273.09,101.43) v1(273.09,100.43) v1(273.09,99.43) v1(273.09,98.43) v1(273.09,97.43) v1(273.09,96.43) v1(273.09,95.43) v1(273.09,94.43) v1(273.09,93.33) v1(273.09,92.43) v1(273.09,91.43) v1(273.09,90.43) v1(273.09,89.43) v1(273.09,88.43) v1(273.09,87.43) v1(273.09,86.43) v1(273.09,85.33) v1(273.09,84.43) v1(273.09,83.43) v1(273.09,82.43) v1(273.09,81.43) v1(273.09,80.43) v1(273.09,79.43) v1(273.09,78.43) v1(273.09,77.43) v1(273.09,76.43) v1(273.09,75.43) v1(273.09,74.43) v1(273.09,73.43) v1(273.09,72.43) v1(273.09,71.43) v1(273.09,70.43) v1(273.09,69.43) v1(273.09,68.43) v1(273.09,67.43) v1(273.09,66.43) v1(273.09,65.43) v1(273.09,64.43) v1(273.09,63.43) v1(273.09,62.43) v1(273.09,61.43) v1(273.09,60.43) v1(273.09,59.43) v1(273.09,58.43) v1(273.09,57.43) v1(273.09,56.43) v1(273.09,55.43) v1(273.09,54.43) v1(273.09,53.43) v1(273.09,52.43) v1(273.09,51.43) v1(273.09,50.43) v1(273.09,49.43) v1(273.09,48.43) v1(273.09,47.43) v1(273.09,46.43) v1(273.09,45.43) v1(273.09,44.43) v1(273.09,43.43) v1(273.09,42.43) v1(273.09,41.43) v1(273.09,40.43) v1(273.09,39.43) v1(273.09,38.43) v1(273.09,37.43) v1(273.09,36.43) v1(273.09,35.43) v1(273.09,34.43) v1(273.09,33.43) v1(273.09,32.43) v1(273.09,31.43) v1(273.09,30.43) v1(273.09,29.43) v1(273.09,28.43) v1(273.09,27.43) v1(273.09,26.43) v1(273.09,25.43) v1(273.09,24.43) v1(273.09,23.43) v1(273.09,22.43) v1(273.09,21.43) v1(273.09,20.43) v2(222.23,14.03)
N34626400: length 2.7
  TOP w0.149: R332.2 16.14,20.91 17.11,21.88 U28.13
N34824147:
  vias: v1(0.89,17.43) v1(0.89,16.43) v1(0.89,15.43) v1(0.89,14.43) v1(1.39,13.98) v1(2.39,13.98) v1(3.39,13.98) v1(4.39,13.98) v1(5.39,13.98) v1(9.39,13.98) v1(10.39,13.98) v1(11.39,13.98) v1(12.39,13.98) v1(13.39,13.98) v1(14.39,13.98) v1(15.39,13.98) v1(16.39,13.98) v1(17.39,13.98) v1(22.39,13.98) v1(23.39,13.98) v1(24.39,13.98) v1(25.39,13.98) v1(26.39,13.98) v1(27.39,13.98) v1(28.39,13.98) v1(29.39,13.98) v1(30.39,13.98) v1(31.39,13.98) v1(32.39,13.98) v1(33.39,13.98) v1(34.39,13.98) v1(35.39,13.98) v1(36.39,13.98) v1(37.39,13.98) v1(38.39,13.98)
N35351327:
  vias: v1(192.84,31.07) v1(192.84,27.83) v1(192.84,27) v1(193.68,31.07)
N35351465:
  vias: v1(66.19,26.42)
N35410578:
  vias: v1(192.84,23.45) v1(192.84,20.14) v1(193.68,23.45)
N35410716:
  vias: v1(66.19,18.8)
N35659314: length 2.8
  BOTTOM w0.149: R114.2 134.15,51.98 134.6,52.43 v1(135.7,52.43)
N35660053: length 78.9
  L14_SIG5 w0.254: v1(142.63,51.43) 143.13,51.93 143.86,51.93 144.14,52.21 144.14,52.64 144.41,52.91 158.12,52.91 158.41,53.2 161.35,53.2 165.32,49.23 165.32,49.16 166.59,47.9 166.87,47.9 167.14,47.63 167.39,47.63 168.04,46.06 168.88,45.21 171.36,45.21 171.75,44.82 171.75,44.01 173.89,41.87 178.38,41.87 181.14,39.11 181.14,38.07 186.34,32.87 192.52,32.87 194.44,30.95 194.44,28.53 196.48,26.49 199.91,26.49 201.3,27.89 202.06,27.89 v1(202.32,27.64)
  BOTTOM w0.381: U52.1 204.83,26.75 R116.2 C209.1 v1(202.32,27.64)
N35951410: length 7.2
  L03_SIG1 w0.508: J8.14 2.64,88.31 v1(2.48,88.47)
  BOTTOM w0.381: R126.2 v1(2.48,88.47)
N35951471: length 3.2
  BOTTOM w0.149: R128.1 31.64,83.45 U7.24
N35951814: length 8.1
  L03_SIG1 w0.508: v1(2.48,91.14) 2.48,92.47 5.18,95.17 J8.16
  BOTTOM w0.381: R134.2 v1(2.48,91.14)
N35952167: length 2
  BOTTOM w0.149: L1.1 16.26,99.01 15.18,100.09 Q1.3
N35952169: length 16.6
  L03_SIG1 w0.081: v1(8.02,91.73) 9.15,92.86 9.15,98.66 v1(13.09,102.6)
  BOTTOM w0.149: Q1.1 v1(13.09,102.6)
  BOTTOM w0.203: R140.2 8.37,91.73 v1(8.02,91.73)
N35952204: length 2.3
  BOTTOM w0.149: L2.1 18.03,99.52 18.29,99.52 18.99,100.22 Q3.3
N35952206: length 23.6
  L16_SIG6 w0.081: v1(8.02,87.92) 9.85,89.74 13.06,89.74 15.67,92.35 15.67,94.81 18,97.14 18,99.69 v1(17.41,100.28)
  BOTTOM w0.149: Q3.1 18.04,100.92 v1(17.41,100.28)
  BOTTOM w0.203: v1(8.02,87.92) 8.53,87.92 R143.2
N35952591: length 3.9
  BOTTOM w0.149: Y1.1 40.48,85.63 41.41,86.57 R160.2
N35952937: length 3.6
  BOTTOM w0.254: U8.3 50.81,94.82 50.36,95.27 R166.2 R164.2 C225.1
N35952961: length 1.8
  BOTTOM w0.254: U8.7 56.34,95.32 R163.1
N35952969: length 2.9
  TOP w0.203: v1(51.06,95.32) 50.23,96.15 v1(49.28,96.15)
  BOTTOM w0.203: U8.4 v1(51.06,95.32)
N35953003: length 1.7
  BOTTOM w0.254: C235.2 56.42,95.92 U8.6
N35980126: length 1.5
  BOTTOM w0.149: U9.4 26.93,67.64 R169.2
N35980394: length 2.4
  L05_SIG2 w0.081: v1(16.26,105.04) 16.26,105.62 17.26,106.62 v1(17.26,107.03)
N35980546: length 1.5
  BOTTOM w0.149: R175.1 27.25,71.01 27.55,71.31 U12.4
N35980606: length 39.2
  TOP w0.254: D2.C 15.84,101.72 v1(16.26,101.3)
  L03_SIG1 w0.081: v1(16.26,101.3) 16.75,100.82 16.75,97.59 16.31,97.16 16.31,83.92 18.36,81.87 18.36,76.6 19.08,75.87 19.08,73.74 19.95,72.88 19.95,72.14 20.78,71.3 22.5,71.3 23.71,70.1 24.41,70.1 v1(25.47,69.04)
N35980632: length 38.7
  TOP w0.254: D3.C 19.95,101.77 v1(19.95,101.3)
  L03_SIG1 w0.081: v1(19.95,101.3) 17.91,99.27 17.91,97.11 16.92,96.12 16.92,84.08 18.94,82.06 18.94,76.91 19.62,76.23 19.62,74.54 21.23,72.93 21.23,72.2 21.77,71.66 22.87,71.66 23.83,70.69 24.84,70.69 v1(25.47,70.06)
N35984757:
  vias: v1(52.46,80.72)
N35984782: length 1.1
  TOP w0.149: v1(51.82,80.14) J12.8
N35984815:
  vias: v1(51.19,81.61)
N35984874:
  vias: v1(49.92,88.72)
N35984876: length 1.6
  TOP w0.149: J12.14 49.92,80.34 49.71,80.14 v1(49.28,80.14)
N36075384: length 5.3
  BOTTOM w0.149: R346.1 223.8,106.53 223.15,105.87 J14.2
N36077918: length 4.4
  TOP w0.149: U18.2 213.58,103.31 C319.1 213.81,103.2 215.91,103.2 216.1,103.01 Y3.3
N36077948: length 2.8
  TOP w0.149: U18.3 213.43,103.71 C324.1 213.85,103.93 Y3.1
N36078275: length 2.6
  TOP w0.149: U18.14 208.9,103.31 208.16,102.57 R267.1 R268.1
N36078278: length 1.9
  TOP w0.149: v1(209.81,101.42) 210.03,101.64 U18.16
  BOTTOM w0.149: v1(209.81,101.42) 209.75,101.36 R269.1
N36078643: length 4.6
  TOP w0.149: R260.1 R265.1 207.97,106.25 210.32,106.25 210.83,105.74 U18.8
N36079166: length 1.1
  BOTTOM w0.254: R271.2 FB24.2
N36079197: length 2.9
  BOTTOM w0.149: R270.1 35.06,38.43 35.44,38.81 36.41,38.81 U19.4
N36079218: length 6.1
  BOTTOM w0.149: U19.2 42.04,41.86 42.3,42.12 42.3,46.37 R271.1
N36079220: length 3.9
  BOTTOM w0.149: U19.5 36.15,41.1 35.69,41.1 34.93,40.34 34.93,39.89 R272.1
N36112579: length 1.6
  BOTTOM w0.149: SW1.6 212.87,35.9 213.3,36.34 R112.2
N36112582: length 1.4
  BOTTOM w0.149: SW1.7 214.14,36.98 R111.2
N36112585: length 1.6
  BOTTOM w0.149: R110.2 215.97,36.49 215.41,35.93 SW1.8
N36194618:
  vias: v1(126.17,52.93) v1(126.17,51.93)
N36226098: length 1
  BOTTOM w0.149: R324.2 264.17,51.07 C338.2
N36227679:
  vias: v1(106.25,66.43)
N36227711:
  vias: v1(126.17,56.93)
N36227759:
  vias: v1(131.37,58.93)
N36228605: length 5.6
  L07_SIG3 w0.089: v1(38.43,21.62) 37.63,20.82 34.67,20.82 34.42,20.58 34.42,20.02 v1(34.03,19.62)
N36270051: length 2
  BOTTOM w0.149: R304.1 89.45,102.73 U23.13
N36270054: length 2.2
  BOTTOM w0.149: U23.12 88.8,102.24 R305.1
N36270110: length 1.3
  BOTTOM w0.149: U22.2 24.31,48.99 R296.1
N36270125: length 1.5
  BOTTOM w0.149: U22.3 23.82,48.59 R298.1
N36270340: length 2
  BOTTOM w0.149: R300.2 12.44,62.37 SW3.8
N36272215: length 1.7
  BOTTOM w0.149: v1(264.42,64.98) 265.79,64.98 U24.3
N36273391: length 1.9
  BOTTOM w0.149: R354.2 36.47,17.98 v1(35.63,18.82)
N36273529: length 3.8
  TOP w0.149: U18.6 211.63,105.65 v1(211.97,106)
  BOTTOM w0.149: R263.2 210.32,107.65 v1(211.97,106)
N36273532: length 2.5
  TOP w0.149: v1(211.23,106) U18.7
  BOTTOM w0.149: R261.2 210.47,106.76 v1(211.23,106)
N36316045: length 3.2
  BOTTOM w0.254: U59.7 48.69,103.47 R649.1 R648.2 R650.2
N36316148: length 4.5
  BOTTOM w0.254: R651.1 C660.1 R652.1 53.41,105.08 53.3,104.96 U59.1
N36316465: length 3.9
  TOP w0.254: R654.2 209.87,19.36 R656.2 209.87,20.81 v1(209.99,20.94) 209.74,21.2 R655.1
  BOTTOM w0.254: U60.7 v1(209.99,20.94)
N36316589: length 4.5
  BOTTOM w0.254: C673.1 R657.1 R658.1 205.74,19.33 205.85,19.44 U60.1
N36344563: length 2.4
  BOTTOM w0.149: SW2.5 12.95,73.66 R274.2
N36344586: length 2.2
  BOTTOM w0.149: R275.2 13.58,72.39 SW2.6
N36344607: length 1.9
  BOTTOM w0.149: R276.2 12.34,71.14 SW2.7
N36344628: length 1.9
  BOTTOM w0.149: R277.2 12.34,69.87 SW2.8
N36347895: length 10.2
  L07_SIG3 w0.089: v1(248.14,21.37) 247.65,21.85 247.65,26.49 249.02,27.86 251.35,27.86 v1(251.75,28.26)
N36348634: length 4
  BOTTOM w0.254: U63.5 34.04,70.08 34.34,70.37 R830.1 35.5,70.37 36.08,69.8 36.46,69.8 36.75,69.51 U62.4
N36348657: length 1.7
  BOTTOM w0.254: U63.4 34.02,72.07 34.36,72.41 R668.2
N36348739: length 3
  BOTTOM w0.254: U63.8 32.02,68.99 R669.1 R670.1 R671.2
N36349829: length 4.9
  L07_SIG3 w0.089: v1(250.15,25.86) 250.15,24.79 249.77,24.42 249.77,21.94 v1(249.18,21.35)
N36396769: length 4.1
  BOTTOM w0.149: V1.1 22.74,88.09 23.87,86.96 24.7,86.96 U7.43
N36398138: length 3.5
  BOTTOM w0.254: U64.3 17.23,37.97 R682.2 R680.1 C683.1
N36398140: length 1.4
  BOTTOM w0.254: U64.6 16.13,43.58 C687.1
N36398214: length 1.4
  BOTTOM w0.254: U64.7 16.73,43.79 R681.2
N36447575: length 10.3
  L07_SIG3 w0.089: v1(248.55,35.58) 248.93,35.19 248.93,34.37 249.18,34.11 249.69,34.11 250.58,33.23 250.58,32.34 251.35,31.57 251.35,28.82 251.51,28.66 251.94,28.66 252.12,28.47 252.12,27.88 v1(252.55,27.46)
N36541668: length 1.4
  BOTTOM w0.149: R704.1 v1(2.45,56.55)
N36541743: length 1.9
  BOTTOM w0.149: v1(6.87,54.95) 6.97,54.86 R705.1
N36541790: length 1.9
  BOTTOM w0.149: v1(6.04,54.95) 6.08,54.91 R706.1
N36541991: length 2.7
  BOTTOM w0.149: R707.1 10.58,56.67 v1(10.45,56.55)
N36542034: length 2.3
  BOTTOM w0.149: v1(14.87,54.95) 15.96,53.86 R708.1
N36542055: length 2.3
  BOTTOM w0.149: v1(14.04,54.95) 15.07,53.92 R709.1
N36542312: length 20.4
  L12_SIG4 w0.089: v1(2.45,54.85) 2.45,54.53 3.94,53.04 7.25,53.04 10.04,55.83 10.04,57.1 13.34,60.4 15.59,60.4 v1(17.41,62.22)
N36542538: length 20.5
  L12_SIG4 w0.089: v1(6.87,56.44) 6.87,56.46 5.6,57.74 5.6,59.39 8.9,62.69 20.62,62.69 v1(21.09,62.22)
N36542543: length 24.9
  L12_SIG4 w0.089: v1(6.04,56.44) 6,56.44 5.21,57.23 5.21,59.64 8.64,63.07 23.93,63.07 v1(24.77,62.22)
N36542635: length 21.5
  L12_SIG4 w0.089: v1(22.61,55.32) 21.34,54.05 12.71,54.05 11.92,54.85 v1(10.45,54.85)
  BOTTOM w0.149: Q27.3 29.47,57.54 29.07,57.14 23.67,57.14 22.61,56.09 v1(22.61,55.32)
N36542846: length 16
  L12_SIG4 w0.089: v1(14.87,56.44) 17.38,56.44 18.36,57.42 20.9,57.42 24.26,60.78 27.02,60.78 v1(28.46,62.22)
N36542851: length 21.1
  L12_SIG4 w0.089: v1(32.27,62.22) 31.46,61.42 28.46,61.42 27.31,60.28 24.39,60.28 21.09,56.97 18.8,56.97 17.66,55.83 14.64,55.83 v1(14.04,56.44)
N36800975: length 1
  TOP w0.149: U32.14 74.54,88.08 v1(74.94,88.47)
N36803165: length 3.4
  TOP w0.254: R730.1 C711.1 71.95,81.93 72.22,82.2 72.22,82.56 72.6,82.94 72.6,83.21 72.54,83.27 U32.1
N36803169: length 3.4
  TOP w0.254: R731.1 C711.2 72.84,81.99 72.63,82.21 72.63,82.43 72.98,82.78 72.98,83.19 73.04,83.25 U32.2
N36803267: length 3.5
  TOP w0.254: R732.1 C395.2 73.86,81.8 74.07,82.02 74.07,82.35 73.6,82.82 73.6,83.19 73.54,83.25 U32.3
N36803284: length 3.5
  TOP w0.254: R733.1 C395.1 74.75,81.99 74.45,82.29 74.45,82.51 73.98,82.98 73.98,83.21 74.04,83.27 U32.4
N36803301: length 4.4
  TOP w0.254: U32.5 74.54,83.15 74.81,82.88 75.83,82.88 76,82.71 76,82.35 75.76,82.11 C709.2 R734.1
N36803305: length 4.3
  TOP w0.254: U32.7 75.79,83.56 76.41,82.93 76.41,82.24 76.65,81.99 C709.1 R735.1
N37269586: length 5.1
  TOP w0.149: C555.1 212.88,52.83 213.38,52.83 FB33.2 213.75,52.26 U50.10 U50.9
N37269687: length 3.4
  TOP w0.149: U50.3 208,51.16 207.82,51.35 R548.1 206.18,51.35 R546.1 C557.1
N37269689: length 1.1
  TOP w0.149: C561.1 211.52,49.18 U50.6
N37651435: length 1
  TOP w0.149: C1472.2 R773.2
N37651438: length 0.9
  BOTTOM w0.149: C1473.2 R774.2
N37651441: length 1
  TOP w0.149: R775.2 C1474.2
N37651444: length 1
  BOTTOM w0.149: C1475.2 R776.2
N37651447: length 0.9
  BOTTOM w0.149: R777.2 C1476.2
N37651450: length 1
  TOP w0.149: C1477.2 R778.2
N37651453: length 1
  BOTTOM w0.149: C1478.2 R779.2
N37651456: length 1
  TOP w0.149: C1479.2 R780.2
N37651459: length 1
  TOP w0.149: C1480.2 R781.2
N37651462: length 1
  TOP w0.149: C1481.2 R782.2
N37651465: length 0.9
  TOP w0.149: R783.2 C1482.2
N37761290: length 4.7
  BOTTOM w0.149: U72.9 201.08,101.81 200.29,101.02 200.29,100.22 R802.1
N37761293: length 1.7
  TOP w0.149: v1(201.3,103.84) 202,103.84 R803.1
  BOTTOM w0.149: U72.12 201.58,103.31 201.3,103.58 v1(201.3,103.84)
N37761614: length 2.2
  TOP w0.381: FB40.2 C1520.1 C1518.1 204.13,99.71 v1(204.09,99.75)
  BOTTOM w0.254: U72.3 v1(204.09,99.75)
N37761618: length 3.2
  TOP w0.381: FB42.2 203.73,98.53 203.73,99.07 v1(203.63,99.18) 203.21,99.6 C1523.1 C1521.1
  BOTTOM w0.254: v1(203.63,99.18) 203.59,99.21 U72.4
N37761695: length 3
  TOP w0.381: v1(204.48,104.85) 204.73,104.6 C1522.1
  BOTTOM w0.254: v1(204.48,104.85) 204.09,104.47 U72.16
  BOTTOM w0.381: FB41.2 204.6,104.98 v1(204.48,104.85)
N37762935: length 4.3
  BOTTOM w0.149: R804.1 R801.1 200.67,100.87 201.11,101.31 U72.8
N37763666: length 139.4
  TOP w0.149: R809.1 205.87,101.56 v1(206.13,101.31) ; SW7.1 265.31,40.85 v1(266.33,41.86)
  L05_SIG2 w0.081: v1(266.33,41.86) 266.33,49.18 267.6,50.45 267.6,52.4 266.48,53.52 266.48,56.44 264.55,58.37 264.55,61.67 265.18,62.31 265.18,78.11 269.93,82.86 269.93,101.35 262.21,109.07 249.79,109.07 248.8,110.06 247.15,110.06 245.55,108.46 220.91,108.46 v1(218.96,106.5)
  L16_SIG6 w0.081: v1(218.96,106.5) 218.34,105.89 218.34,105.28 216.11,103.05 213.82,103.05 213.25,102.47 213.25,101.96 212.87,101.58 212.31,101.58 211.9,101.99 209.71,101.99 208.72,101 206.8,101 206.5,101.31 v1(206.13,101.31)
  BOTTOM w0.149: U72.23 v1(206.13,101.31)
N37820590: length 3.2
  TOP w0.149: R816.1 R815.2 241.3,63.89 U73.3
N37820593: length 3.1
  TOP w0.149: U73.2 241.04,64.54 R817.2 R818.1
N37820596: length 3.3
  TOP w0.149: U73.1 241.61,65.19 R820.1 R819.2
N37820939: length 3.6
  TOP w0.149: U73.7 248.84,64.54 R821.2 249.76,64.07 249.81,64.02 R822.2
N37847663: length 1.1
  BOTTOM w0.149: R823.2 253.84,29.67 C1524.2
N37925832: length 1
  BOTTOM w0.149: R828.2 247.28,98.66 247.25,98.63 C420.2
N37926031: length 0.8
  BOTTOM w0.149: R829.2 251.15,78.16 C434.2
N37926941: length 1.1
  BOTTOM w0.149: C1525.1 R831.2
N38179462:
  vias: v1(212.35,23.51) v1(214.89,20.84) v1(216.03,23.51) v1(218.19,18.24) v1(219.02,25.99) v1(219.21,18.24)
N38301581:
  vias: v1(105.39,64.93)
N38301586:
  vias: v1(103.66,65.93)
N39014223: length 1.3
  TOP w0.149: U6.A4 v1(209.01,28.99)
  BOTTOM w0.149: R5772.1 v1(209.01,28.99)
N39025445: length 26.8
  BOTTOM w0.149: v1(139.16,51.43) 138.82,51.77 138.82,52.05 138.46,52.4 138.07,52.4 137.65,51.98 137.32,51.98 136.81,51.47 136.45,51.47 135.92,50.94 135.6,50.94 135.03,50.37 134.58,50.37 134.11,49.9 133.78,49.9 133.23,49.35 132.93,49.35 132.51,48.94 132.05,48.94 131.58,48.47 131.33,48.47 130.94,48.08 130.94,42.24 130.79,42.09 130.79,41.76 130.99,41.56 130.99,39.4 131.45,38.94 134.25,38.94 134.88,38.31 134.88,37.54 135.44,36.99 136.52,36.99 R5773.1
N39028460: length 1.6
  TOP w0.305: U125.E2 v1(211.52,93.46)
  BOTTOM w0.254: v1(211.52,93.46) 212.24,94.18 C1654.1
N39028581: length 1.2
  BOTTOM w0.254: R5776.2 207.95,94.66 v1(208.72,94.66)
N39028605: length 3.3
  TOP w0.305: TP19.1 210.32,99.77 208.72,98.17 U125.B7
N39028640:
  vias: v1(207.92,97.06)
N39028644: length 2.5
  TOP w0.305: U125.D1 v1(210.72,92.66)
  BOTTOM w0.254: C1656.2 R5780.1 210.72,92.29 v1(210.72,92.66)
N39028777: length 1.4
  TOP w0.305: U125.F1 v1(212.32,92.66)
  BOTTOM w0.254: v1(212.32,92.66) 212.32,92.29 R5780.2
N39029145: length 2.5
  TOP w0.305: U125.C1 v1(209.92,92.66)
  BOTTOM w0.254: v1(209.92,92.66) R5787.2 R5785.1 C1665.1
N39047511: length 8.4
  L12_SIG4 w0.089: v1(208.72,95.46) 209.13,95.05 213.09,95.05 214.36,93.78 215.87,93.78 v1(216.28,93.37)
N39047662: length 8.6
  L16_SIG6 w0.081: v1(247.53,35.58) 247.53,35.33 247.96,34.9 247.96,33.71 248.39,33.28 248.93,33.28 249.87,32.34 249.87,31.74 251.36,30.24 251.36,29.44 v1(251.75,29.06)
N39053590: length 1.6
  TOP w0.305: U125.E1 v1(211.52,92.66)
  BOTTOM w0.254: v1(211.52,92.66) 212.16,93.3 R978.1
N40859486: length 9.1
  BOTTOM w0.149: R5932.1 194.01,64.69 193.85,64.54 193.3,64.54 193.29,64.52 C2007.2 ; R5932.1 194.11,65.71 194.47,66.07 v1(195.47,66.07) 196.45,66.07 196.53,66.14 v1(197.17,66.14) 197.29,66.14 197.77,66.63 198.51,66.63 198.64,66.5 R6105.2 ; R5932.1 194.1,64.68 R5928.1
N40859780: length 2.2
  TOP w0.149: C1818.2 203.18,60.2 202.42,59.44 U47.31
N40859787: length 1.2
  TOP w0.149: U47.30 202.26,59.04 v1(202.6,58.7)
N40859815: length 1.7
  TOP w0.149: U47.28 202.04,58.24 202.29,57.99 202.29,57.76 202.65,57.41 C1819.1
N40859909: length 1.5
  TOP w0.149: U47.21 198.74,56.54 199.07,56.21 R6100.2
N40859911: length 2.1
  TOP w0.149: R5939.2 200.13,55.6 199.14,56.59 U47.22
N40859913: length 2.5
  TOP w0.149: U47.23 199.54,56.68 200.32,55.91 200.86,55.91 R5940.2
N40859915: length 3.1
  TOP w0.149: R5941.2 201.59,56.24 200.41,56.24 199.94,56.71 U47.24
N40859917: length 4.2
  TOP w0.149: R5942.2 203,55.52 203,55.66 202.37,56.29 202.16,56.29 201.9,56.54 200.54,56.54 200.34,56.74 U47.25
N40865174: length 1.4
  TOP w0.149: v1(189.72,85.85) 189.58,85.85 189.05,86.39 U76.35
N40865834: length 1.2
  TOP w0.149: v1(189.67,73.84) 189.26,73.84 189.17,73.74 U77.35
N40873145: length 1.8
  TOP w0.149: v1(189.64,59.02) 189.64,58.55 189.29,58.2 U78.35
N40873851: length 1.2
  TOP w0.149: v1(189.54,42.46) 189.1,42.02 U79.35
N40878568: length 1.3
  BOTTOM w0.305: v1(233.43,50.5) v1(234.7,50.5)
N40878578: length 1.6
  BOTTOM w0.305: v1(232.16,54.31) 232.35,54.5 232.35,54.89 R5964.1 231.87,54.94 231.71,54.78 R6104.2
N40878702: length 0.7
  BOTTOM w0.305: R5964.2 233.26,54.91 233.26,54.48 v1(233.43,54.31)
N40878910: length 1.6
  BOTTOM w0.305: v1(229.62,58.12) 229.99,57.75 R5967.2 R5965.2
N40878945:
  vias: v1(229.62,55.58) v1(230.89,55.58)
N40878955: length 13.9
  TOP w0.149: TP29.1 233.03,45.16 v1(233.31,45.44)
  L16_SIG6 w0.081: v1(233.43,53.04) 232.9,52.5 231.76,52.5 231.71,52.56 231.4,52.56 231.27,52.43 229.75,52.43 229.19,51.87 229.19,50.4 233.31,46.28 v1(233.31,45.44)
N40879078: length 0.9
  BOTTOM w0.305: v1(228.35,53.04) 228.77,53.46 R5968.1
N40879082: length 1
  BOTTOM w0.305: R5970.1 232.25,53.04 v1(232.16,53.04)
N40879084: length 0.8
  BOTTOM w0.305: v1(229.62,49.23) 229.99,48.86 R5971.1
N40879086: length 2
  BOTTOM w0.305: R5974.1 R5969.1 227.78,51.01 228.05,51.01 228.35,50.7 v1(228.35,50.5)
N40879090: length 5.6
  TOP w0.149: D25.2 226.83,45.27 v1(226.4,45.7)
  L16_SIG6 w0.081: v1(228.35,49.23) 227.82,49.23 226.4,47.81 v1(226.4,45.7)
N40879092:
  vias: v1(229.62,51.77) v1(229.62,50.5)
N40879148: length 1.3
  BOTTOM w0.305: v1(225.81,50.5) v1(227.08,50.5)
N40879172: length 0.7
  BOTTOM w0.305: v1(234.7,51.77) 234.89,51.58 R5975.2
N40879270:
  vias: v1(228.35,55.58)
N40879274: length 0.7
  BOTTOM w0.305: v1(230.89,49.23) 230.8,49.14 R5980.1
N40879310: length 2
  BOTTOM w0.305: R5981.2 233.5,48.94 233.2,49.23 v1(232.16,49.23)
N40879329: length 2.6
  TOP w0.305: v1(230.89,51.77) v1(230.89,50.5)
  BOTTOM w0.305: v1(230.89,50.5) 231.53,51.13 R5982.2
N40879333: length 2
  TOP w0.305: v1(232.16,50.5) v1(232.16,51.77)
  BOTTOM w0.305: v1(232.16,50.5) 231.97,50.31 R5983.2
N40882065: length 3.5
  TOP w0.149: TP30.1 206.97,62.87 208.01,61.83 U51.B5
N40882112: length 3.5
  TOP w0.149: TP31.1 205.7,63.38 206.74,62.33 U51.A5
N40882148: length 7.8
  L16_SIG6 w0.081: v1(209.91,60.21) 209.16,60.21 208.67,59.72 208.67,58.35 207.37,57.05 v1(207.37,56.25)
  BOTTOM w0.149: v1(209.91,60.21) 210.84,60.21 211.07,60.44 R6096.2 211.45,60.44 211.74,60.15 R5985.2
N40882229: length 8.9
  L16_SIG6 w0.081: v1(212.92,60.15) 211.82,60.15 207.35,55.68 v1(206.74,55.68)
  BOTTOM w0.149: C1902.2 v1(206.74,55.68)
N40882256: length 0.7
  BOTTOM w0.149: R5986.1 207.82,57.14 v1(208.01,56.95)
N40882276: length 0.7
  BOTTOM w0.149: v1(209.28,59.49) 209.44,59.32 R5987.1
N40882304: length 3.3
  BOTTOM w0.149: v1(206.74,59.49) 206.18,60.05 206.18,61.42 206.56,61.8 R5988.2
N40882322: length 0.6
  BOTTOM w0.149: C1904.2 v1(206.74,56.95)
N40882328: length 2.7
  BOTTOM w0.149: R5990.1 R5989.1 R5991.2 206.42,57.9 v1(206.74,58.22)
N40882423: length 1.7
  BOTTOM w0.149: v1(208.01,55.68) 207.77,55.44 R5992.2 207.79,54.94 C2032.1
N40882447: length 1
  BOTTOM w0.149: R5992.1 206.46,54.92 206.28,54.74 R5993.2
N40885340: length 2.3
  BOTTOM w0.149: R5995.2 R5997.2 64.14,72.66 R5998.1
  vias: v1(63.33,73.43)
N40885465: length 1.4
  BOTTOM w0.149: v1(70.93,72.19) 70.93,71.98 71.36,71.55 C1909.2
N40885526: length 4.7
  TOP w0.203: TP32.1 66.28,66.5 66.28,67.74 U65.B3
N40885555: length 10.3
  TOP w0.149: TP33.1 65.79,78.51 62.08,74.81 62.08,73.33 62.62,72.8 63.72,72.8 U65.F2
N40885593: length 0.8
  BOTTOM w0.149: R5999.2 68.07,68.06 v1(68.39,68.38)
N40894339: length 1
  BOTTOM w0.254: R6002.1 232.38,76.28 v1(232.35,76.31) 232.29,76.26 C1914.2
N40894341: length 1
  BOTTOM w0.254: R6003.1 232.38,75.01 v1(232.35,75.04) 232.29,75.1 C1914.1
N40894343: length 6.1
  TOP w0.149: U55.D12 218.18,68.69 216.44,66.96 216.44,64.54 TP41.1
N40894345: length 24
  L16_SIG6 w0.081: v1(205.7,62.64) 208.87,65.81 208.87,67.54 211.44,70.11 215.37,70.11 216.13,70.86 222.56,70.86 v1(223.46,69.96)
  BOTTOM w0.149: TP42.1 v1(205.7,62.64)
N40894542: length 1.6
  BOTTOM w0.254: R6006.2 220.06,74.42 R6004.2 219.46,73.96 v1(219.65,73.77)
N40894561: length 0.7
  BOTTOM w0.203: v1(218.38,71.23) 218.38,70.79 R6005.2
N40894590:
  vias: v1(232.35,68.69)
N40895169: length 7.6
  L07_SIG3 w0.089: v1(219.65,75.04) 219.65,75.01 219.03,74.4 219.03,73.75 219.91,72.87 220.41,72.87 220.42,72.88 221.98,72.88 222.79,73.69 222.79,74.38 v1(223.46,75.04)
N40895207: length 3.2
  L12_SIG4 w0.089: v1(218.38,72.5) v1(219.65,71.23)
  BOTTOM w0.305: v1(219.65,71.23) 219.52,71.11 R6014.2 ; R6011.1 218.53,72.35 v1(218.38,72.5)
N40895215: length 7.7
  L12_SIG4 w0.089: v1(223.46,68.69) 223.49,68.69 223.83,69.04 223.83,71.6 221.81,73.62 221.81,74.15 v1(220.92,75.04)
N40895254: length 2.1
  L07_SIG3 w0.089: v1(218.38,69.96) v1(219.65,69.96)
  BOTTOM w0.203: v1(219.65,69.96) 220.03,70.35 R6013.1
N40895294: length 6.9
  L12_SIG4 w0.089: v1(218.38,67.42) 218.38,67.38 218.9,66.86 220.89,66.86 221.37,67.34 221.37,69.51 v1(220.92,69.96)
  BOTTOM w0.254: R6015.2 218.51,67.55 v1(218.38,67.42)
N40895381:
  vias: v1(223.46,71.23)
N40895450:
  vias: v1(222.19,69.96)
N40895467: length 15.4
  L12_SIG4 w0.089: v1(222.19,75.04) 222.22,75.04 222.79,75.62 222.79,76.48 222.41,76.86 219.56,76.86 219.26,76.56 219.26,74.81 221.55,72.52 221.55,70.37 221.51,70.34 220.76,70.34 220.54,70.12 220.54,69.81 220.95,69.4 220.95,69.26 220.92,69.23 v1(220.92,68.69)
N40895475: length 0.7
  BOTTOM w0.203: R6018.2 219.8,72.35 v1(219.65,72.5)
N40895479: length 1.3
  BOTTOM w0.254: R6019.2 217.63,74.09 217.95,73.77 v1(218.38,73.77)
N40895481:
  vias: v1(219.65,68.69)
N40895483:
  vias: v1(218.38,76.31)
N40895485: length 18.6
  L12_SIG4 w0.089: v1(222.19,73.77) 222.19,73.77 223.04,74.63 223.04,76.66 222.49,77.21 219.53,77.21 218.93,76.61 218.93,73.87 220.07,72.72 220.07,69.83 219.89,69.65 219.89,69.01 220.92,67.99 v1(220.92,67.42)
  BOTTOM w0.254: v1(222.19,73.77) 222.09,73.68 C1940.1
N40895537: length 0.6
  BOTTOM w0.254: v1(219.65,67.42) 219.75,67.53 R6023.1
N40899627: length 3.1
  BOTTOM w0.149: R6097.2 64.52,58.74 R6027.2 63.7,59.16 63.56,59.16 63.28,59.44 v1(63.28,59.64) 63.88,59.64 R6028.1
N40899752: length 1.3
  BOTTOM w0.149: v1(70.9,58.37) 71.5,58.37 71.67,58.19 C1943.2
N40899813: length 9.2
  TOP w0.149: U56.B3 64.76,54.56 64.14,55.17 62.62,55.17 62.24,54.79 62.24,50.09 TP34.1
N40899850: length 6
  TOP w0.149: U56.F2 63.71,60.28 62.11,60.28 61.5,60.89 TP35.1
N40899884: length 0.8
  BOTTOM w0.149: R6029.2 68.07,54.27 v1(68.36,54.56)
N40903465: length 11.2
  L12_SIG4 w0.089: v1(210.95,87.71) 210.55,88.12 208.82,88.12 v1(208.41,87.71) 208.01,88.12 205.01,88.12 v1(204.6,87.71) 204.2,88.12 201.2,88.12 v1(200.79,87.71)
N40903501: length 12.7
  L12_SIG4 w0.089: v1(202.06,87.71) 203.89,87.71 204.27,87.33 205.5,87.33 v1(205.87,87.71) 206.26,87.33 209.3,87.33 v1(209.68,87.71) 210.07,87.33 211.13,87.33 211.94,88.14 213.06,88.14 v1(213.49,87.71)
N40903513: length 3.1
  L07_SIG3 w0.089: v1(203.33,83.9) 203.33,83.95 202.7,84.58 202.7,85.8 v1(202.06,86.44)
N40903517: length 12.9
  L12_SIG4 w0.089: v1(200.79,86.44) 200.84,86.44 201.38,85.91 204.07,85.91 v1(204.6,86.44) 205.19,85.85 207.83,85.85 v1(208.41,86.44) 209.05,85.8 211.59,85.8 v1(212.22,86.44)
N40903590: length 3.1
  L07_SIG3 w0.089: v1(205.87,86.44) 206.51,85.8 206.51,84.53 v1(207.14,83.9)
N40903670: length 3.1
  L07_SIG3 w0.089: v1(209.68,86.44) 210.37,85.75 210.37,84.48 v1(210.95,83.9)
N40903761: length 1.8
  L07_SIG3 w0.089: v1(212.22,85.17) v1(213.49,86.44)
N40903799: length 1
  BOTTOM w0.149: R6035.1 201.68,88.66 R6036.1
N40903928: length 9.9
  L07_SIG3 w0.089: v1(207.14,82.63) 206.59,82.07 203.21,82.07 199.69,85.59 v1(199.69,86.31)
N40907421: length 12.5
  L12_SIG4 w0.089: v1(199.14,45.04) 199.57,44.61 202.52,44.61 v1(202.95,45.04) 203.38,44.61 206.33,44.61 v1(206.76,45.04) 207.19,44.61 208.87,44.61 v1(209.3,45.04)
  BOTTOM w0.203: R6042.2 207.31,45.59 v1(206.76,45.04)
N40907472: length 12.5
  L12_SIG4 w0.089: v1(200.41,45.04) 200.44,45.04 200.9,45.49 203.77,45.49 v1(204.22,45.04) 204.22,45.06 204.63,45.47 207.6,45.47 v1(208.03,45.04) 208.06,45.04 208.49,45.47 211.41,45.47 v1(211.84,45.04)
N40907476: length 3.1
  L07_SIG3 w0.089: v1(201.68,41.23) 201.02,41.89 201.02,43.16 v1(200.41,43.77)
N40907480: length 13.2
  L12_SIG4 w0.089: v1(199.14,43.77) 199.14,43.72 199.73,43.13 202.32,43.13 v1(202.95,43.77) 202.95,43.72 203.59,43.08 206.08,43.08 v1(206.76,43.77) 206.89,43.77 207.58,43.08 209.89,43.08 v1(210.57,43.77)
N40907555: length 3.1
  L07_SIG3 w0.089: v1(205.49,41.23) 204.73,41.99 204.73,43.26 v1(204.22,43.77)
N40907635: length 3.1
  L07_SIG3 w0.089: v1(208.03,43.77) 208.41,43.39 208.41,42.12 v1(209.3,41.23)
N40907725: length 1.8
  L12_SIG4 w0.089: v1(211.84,43.77) v1(210.57,42.5)
N40907761: length 0.9
  BOTTOM w0.149: R6042.1 R6043.1
N40907881: length 6.5
  BOTTOM w0.149: v1(205.49,39.96) 205.49,40.64 204.86,41.28 204.86,45.34 204.59,45.61 R6044.1
N40909775: length 1.2
  TOP w0.149: v1(213.85,71.86) 213.85,72.75 TP38.1
N40909802: length 1.4
  TOP w0.149: v1(215.12,71.86) 215.15,71.88 TP39.1
N40909854: length 14.1
  TOP w0.149: R6093.2 210.18,72.58 209.63,72.04 209.63,69.19 209.86,68.96 211,68.96 212.9,67.07 R6057.2 213.35,67.19 213.86,67.19 R6056.2 214.07,67.5 214.36,67.8 214.36,68.3 213.8,68.86 212.3,68.86 211.94,69.23 R6058.2
N40909931: length 1.8
  TOP w0.149: R6056.1 214.95,66.94 v1(215.12,66.78) 215.2,66.7 C1978.2
N40909962: length 0.6
  TOP w0.149: R6057.1 213.76,67.96 v1(213.85,68.05)
N40909984:
  vias: v1(212.58,70.59)
N40910010:
  vias: v1(215.12,70.59)
N40910028: length 0.7
  TOP w0.149: C1979.2 215.34,67.83 v1(215.12,68.05)
N40910038: length 1.6
  TOP w0.149: R6060.1 215.86,70.27 215.83,70.25 R6061.1 215.39,69.59 v1(215.12,69.32)
N40910129: length 3
  TOP w0.149: v1(213.85,66.78) 213.88,66.75 R6063.2 213.35,65.67 213.21,65.53 213.21,64.98 213.07,64.84 C2033.1
N40968297: length 7.5
  TOP w0.149: v1(63.86,43.26) 63.86,40.69 64.32,40.24 66.37,40.24 v1(66.67,39.94)
  BOTTOM w0.149: v1(63.86,43.26) 63.86,43.31 63.75,43.42 C2034.2
  BOTTOM w0.254: v1(66.67,39.94) 65.88,39.15 R6074.2
N40969501: length 12
  L03_SIG1 w0.081: v1(73.23,38.53) 73.23,39 72.57,39.65 72.3,39.65 71.64,40.31 70.24,40.31 v1(69.87,39.94) 69.49,40.31 68.64,40.31 v1(68.27,39.94) 67.85,39.52 67.85,38.75 v1(68.27,38.34) 68.64,37.96 69.5,37.96 v1(69.87,38.34)
  L16_SIG6 w0.081: v1(73.23,38.53) v1(73.23,37.68) v1(73.23,36.78)
N40980036: length 3.1
  TOP w0.149: C2036.2 58.62,56.1 v1(58.05,56.67)
  BOTTOM w0.149: R6067.2 58.05,56.67 v1(58.05,56.67) 57.64,56.67 57.64,56.67 U66.C1
N40980113: length 15.3
  TOP w0.149: R6083.1 58.06,53.99 v1(58.12,54.05)
  L03_SIG1 w0.081: v1(53.73,56.67) 54.29,56.11 54.78,56.11 v1(55.33,56.67)
  L05_SIG2 w0.081: v1(55.33,56.67) 55.33,57.53 55.07,57.79 54.31,57.79 54.1,57.58 54.1,56.29 v1(55.33,55.07) 54.95,54.68 54.95,53.94 55.14,53.74 57.44,53.74 57.75,54.05 v1(58.12,54.05) ; v1(53.73,55.07) 53.39,55.41 53.39,56.32 v1(53.73,56.67)
  BOTTOM w0.149: v1(58.12,54.05) 58.12,54.6 R6084.1
N40987662: length 10.6
  TOP w0.149: TP28.1 203.72,52.56 203.28,52.12 201.45,52.12 v1(200.79,52.78)
  L16_SIG6 w0.081: v1(200.79,52.78) 200.34,52.33 198.71,52.33 v1(198.25,52.78)
  BOTTOM w0.149: v1(200.79,52.78) 200.18,53.39 198.86,53.39 v1(198.25,52.78)
N40987771: length 5.5
  L16_SIG6 w0.081: v1(202.06,54.05) 201.56,53.55 197.49,53.55 v1(196.98,54.05)
N40987783: length 5.5
  L16_SIG6 w0.081: v1(196.98,52.78) 197.49,53.29 201.56,53.29 v1(202.06,52.78)
N40989537: length 2.9
  L16_SIG6 w0.081: v1(200.79,50.24) 200.39,50.65 198.66,50.65 v1(198.25,50.24)
N40990671:
  vias: v1(199.52,52.78)
N40992497: length 5.6
  L16_SIG6 w0.081: v1(202.06,51.51) 201.51,52.07 197.52,52.07 196.98,51.54 v1(196.98,51.51)
N40993869: length 1.3
  TOP w0.149: R5956.2 199.8,53.44 199.52,53.72 v1(199.52,54.05)
N41030357: length 2.9
  TOP w0.149: R6086.2 202.94,56.59 202.28,56.59 201.56,57.31 U47.27
N41037858: length 1.6
  TOP w0.149: U47.19 197.94,56.64 197.24,55.93 R6090.2
N41038344: length 1
  BOTTOM w0.149: R6092.1 69.41,59.01 R6026.1
N41419088: length 2.1
  BOTTOM w0.305: R6103.2 227.74,53.7 v1(228.35,54.31) 227.72,54.94 R5976.1
N41419100: length 0.8
  BOTTOM w0.149: v1(227.08,54.31) 226.69,54.7 R5976.2
N41577579: length 0.7
  TOP w0.149: U76.36 188.5,87.39 v1(188.65,87.54)
N41579874: length 1.4
  TOP w0.149: v1(189.66,74.7) 189.19,74.24 U77.36
N41584176: length 0.7
  TOP w0.149: v1(188.63,59.31) 188.63,59.29 188.5,59.16 U78.36
N41584715: length 0.6
  TOP w0.149: v1(188.45,43.08) 188.45,43.11 188.45,42.9 188.5,42.86 U79.36
N41681478: length 1.1
  BOTTOM w0.305: C2004.1 R6098.2
N41873307: length 1.2
  BOTTOM w0.149: R6091.1 69.29,72.53 69.63,72.19 R5996.1
N41930528: length 4.6
  TOP w0.149: TP45.1 231.71,81.03 231.71,78.21 U55.L2
N41930530: length 4.4
  TOP w0.149: TP46.1 230.54,62.05 230.54,63.88 230.89,64.24 231.7,64.24 U55.A1
N42039861: length 2.5
  TOP w0.149: v1(189.62,40.41) 189.21,40.41 189.11,40.52 U79.32
  BOTTOM w0.149: R6106.1 190.45,40.26 190.29,40.41 v1(189.62,40.41)
N42039972: length 1.3
  TOP w0.149: v1(189.58,56.29) 189.17,56.7 U78.32
N42040021: length 2.1
  TOP w0.149: v1(189.68,84.25) 189.47,84.25 188.84,84.89 U76.32
  BOTTOM w0.203: v1(189.68,84.25) 189.68,84.04 189.67,84.03 189.67,83.71 R6108.1
N42040083: length 1.6
  TOP w0.149: U77.32 188.97,72.24 189.43,71.78 189.43,71.69 v1(189.72,71.4)
N42040125: length 1.3
  TOP w0.149: U77.34 189.4,73.24 v1(189.67,72.98)
N42040156: length 1.6
  TOP w0.149: U76.34 189.05,85.89 189.43,85.5 189.43,85.4 v1(189.72,85.11)
N42040187: length 1.1
  TOP w0.149: v1(189.55,57.74) 188.98,57.74 188.94,57.7 U78.34
