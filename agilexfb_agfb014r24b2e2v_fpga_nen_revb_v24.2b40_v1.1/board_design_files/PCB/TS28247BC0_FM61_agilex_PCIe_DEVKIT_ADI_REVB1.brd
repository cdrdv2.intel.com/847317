# Allegro board TS28247BC0_FM61_agilex_PCIe_DEVKIT_ADI_REVB1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_DIMM_CH0_DQ8: length 58.7
  L12_SIG4 w0.089: v1(78.94,91.44) 78.94,91.01 80.58,89.37 84.17,89.37 86.74,86.8 86.88,86.8 87.11,87.02 87.25,87.02 87.35,86.92 87.35,86.78 87.13,86.56 87.13,86.42 87.51,86.03 88.91,86.03 89.01,85.93 89.01,85.79 88.91,85.7 87.27,85.7 87.17,85.6 87.17,85.46 87.27,85.36 89.55,85.36 89.64,85.27 89.64,85.11 89.55,85.03 88,85.03 87.9,84.93 87.9,84.79 88,84.69 91.83,84.69 91.93,84.59 91.93,84.45 91.83,84.36 88.72,84.36 88.62,84.26 88.62,84.12 88.72,84.02 92.46,84.02 93.28,83.2 94.47,83.2 94.71,82.95 103.3,82.95 103.52,83.17 105.33,83.17 106.09,83.92 115.01,83.92 116.03,82.91 116.7,82.91 117.12,82.49 117.12,82.32 v1(117.51,81.93)
DDR4_DIMM_CH0_DQ9: length 58.5
  L12_SIG4 w0.089: v1(79.79,97.44) 79.4,97.05 78.45,97.05 77.57,96.17 77.57,96.03 77.67,95.93 77.81,95.93 78.53,96.65 78.67,96.65 78.77,96.56 78.77,96.42 78.32,95.97 78.32,95.83 78.42,95.73 78.56,95.73 79.1,96.28 79.24,96.28 79.34,96.18 79.34,96.04 77.8,94.5 77.8,93.14 78.5,92.44 78.5,90.93 80.41,89.02 83.9,89.02 86.65,86.27 86.65,85.13 88.19,83.59 92.32,83.59 93.09,82.83 94.4,82.83 94.82,82.41 95.24,82.41 95.68,81.96 96.05,81.96 96.45,82.36 97,82.36 97.36,82 97.86,82 98.22,82.36 103.84,82.36 104.31,82.82 105.53,82.82 106.2,83.49 114.9,83.49 115.83,82.57 115.97,82.57 116.49,82.05 116.85,82.05 117.51,81.39 v1(117.51,80.93)
DDR4_DIMM_CH0_DQ10: length 57.6
  L12_SIG4 w0.089: v1(118.38,82.43) 118.38,83.29 116.68,84.98 116.26,84.98 115.42,85.82 109.35,85.82 109.16,85.64 105.71,85.64 104.89,84.81 94.55,84.81 93.5,85.87 93.5,87.09 93.4,87.19 93.26,87.19 93.16,87.09 93.16,85.98 93.07,85.88 92.93,85.88 92.83,85.98 92.83,87.86 90.71,89.98 90.57,89.98 90.48,89.88 90.48,89.74 91.3,88.91 91.3,88.77 91.21,88.68 91.07,88.68 89.81,89.93 89.67,89.93 89.58,89.83 89.58,89.69 90.83,88.44 90.83,88.3 90.73,88.2 90.59,88.2 89.45,89.35 89.31,89.35 89.21,89.25 89.21,89.11 90.36,87.96 90.36,87.83 90.26,87.73 90.12,87.73 88.88,88.96 88.61,88.96 88.32,89.25 88.32,90.46 87.88,90.9 87.88,92.91 87.64,93.14 86.41,93.14 86.16,92.89 86.16,91.27 85.77,90.88 85.45,90.88 v1(84.89,91.44)
DDR4_DIMM_CH0_DQ11: length 57.5
  L12_SIG4 w0.089: v1(118.38,81.43) 118.38,81.18 119.02,80.53 119.53,80.53 119.92,80.93 120.2,80.93 120.65,81.38 121.08,81.38 121.46,81.76 121.46,81.97 120.5,82.93 120.5,85.69 120.22,85.98 119.75,85.98 119.57,86.16 119.57,86.55 119.09,87.02 117.6,87.02 117.02,87.6 116.38,87.6 115.16,88.82 111.92,88.82 111.77,88.67 111.77,88.3 111.66,88.2 111.51,88.2 111.41,88.3 111.41,88.74 111.31,88.84 111.18,88.84 111.08,88.74 111.08,88.27 110.98,88.17 110.84,88.17 110.75,88.26 110.75,88.75 110.65,88.85 110.51,88.85 110.41,88.75 110.41,88.28 110.31,88.17 110.17,88.17 110.08,88.26 110.08,88.75 109.98,88.85 109.84,88.85 109.74,88.75 109.74,88.28 109.64,88.17 109.5,88.17 109.41,88.26 109.41,88.75 109.31,88.85 109.17,88.85 109.07,88.75 109.07,88.28 108.97,88.17 108.83,88.17 108.74,88.26 108.74,88.75 108.64,88.85 108.5,88.85 108.4,88.75 108.4,88.28 108.3,88.17 108.16,88.17 108.06,88.27 108.06,88.73 107.97,88.82 107.36,88.82 106.01,87.47 105.02,87.47 104.69,87.15 97.65,87.15 97.38,87.42 97.38,87.64 96.1,88.92 95.73,88.92 95.33,89.32 95.33,90.04 94.75,90.61 93.52,90.61 92.96,91.17 92.96,92.42 89.29,96.09 87.09,96.09 v1(85.74,97.44)
DDR4_DIMM_CH0_DQ12: length 55.9
  L12_SIG4 w0.089: v1(120.98,80.93) 120.68,80.63 120.68,80.34 120.36,80.02 120,80.02 119.51,79.53 118.96,79.53 118.47,80.02 118.14,80.02 117.79,80.37 117.48,80.37 117.13,80.72 117.13,81.48 116.79,81.82 116.42,81.82 115.92,82.32 115.57,82.32 114.76,83.14 106.37,83.14 105.58,82.35 105.13,82.35 104.68,81.9 99.29,81.9 98.84,81.45 98.37,81.45 97.9,80.98 97.31,80.98 96.9,81.39 96.57,81.39 96.12,80.94 95.71,80.94 95.24,81.41 94.83,81.41 94.28,81.96 93.92,81.96 93.57,82.31 93.1,82.31 92.21,83.19 87.94,83.19 86.08,85.04 86.08,86.26 83.7,88.65 80.03,88.65 77.68,91 77.68,92.48 77.34,92.82 77.11,92.82 76.92,92.63 76.92,91.76 v1(77.24,91.44)
DDR4_DIMM_CH0_DQ13: length 54.4
  L12_SIG4 w0.089: v1(121.84,82.43) 121.84,82.54 121.37,83.01 121.37,86.58 119.93,88.02 119.32,88.02 118.55,88.79 118.36,88.87 116.24,88.87 115.47,89.64 108.47,89.64 107.83,90.27 106.74,90.27 106.03,89.56 106.03,89.31 105.55,88.82 102.4,88.82 101.94,88.37 98.09,88.37 89.42,97.04 89,97.04 88.7,97.34 88.7,97.61 88.43,97.88 87.29,98.35 83.63,98.35 78.96,97.89 v1(78.09,97.44)
DDR4_DIMM_CH0_DQ14: length 55.8
  L12_SIG4 w0.089: v1(120.98,81.93) 120.56,82.34 120.56,82.55 120.05,83.06 120.05,83.82 119.73,84.13 119.73,85.02 118.73,86.02 118.1,86.02 116.9,87.21 116.27,87.21 115.68,87.81 114.63,87.81 114.53,87.91 114.53,88.37 114.43,88.47 114.3,88.47 114.2,88.37 114.2,87.91 114.1,87.81 113.96,87.81 113.86,87.91 113.86,88.38 113.76,88.48 113.63,88.48 113.53,88.38 113.53,87.91 113.43,87.81 113.12,87.81 112.88,88.05 112.54,88.05 112.3,87.81 107,87.81 106.32,87.13 105.17,87.13 104.84,86.8 96.83,86.8 96.45,87.18 96.45,87.75 96.17,88.03 95.54,88.03 95.27,88.3 95.27,88.78 94.82,89.24 94.82,89.79 94.45,90.15 93.16,90.15 92.13,91.18 92.13,92.75 89.26,95.61 86.44,95.61 85.31,96.75 84.18,96.75 82.96,95.52 82.96,94.87 82.04,93.96 82.04,93.5 83.19,92.35 v1(83.19,91.44)
DDR4_DIMM_CH0_DQ15: length 54.3
  L12_SIG4 w0.089: v1(121.84,81.43) 121.84,81.9 121.46,82.28 121.46,82.54 120.91,83.09 120.91,86.44 120.35,87 119.67,87 118.76,87.92 118.29,87.92 118.21,87.99 116.51,87.99 115.29,89.21 108.2,89.21 107.58,89.83 107.09,89.83 106.44,89.18 106.44,89.05 106.68,88.81 106.68,88.67 106.59,88.57 106.45,88.57 106.21,88.81 106.07,88.81 105.99,88.73 105.99,88.25 105.65,87.91 105.2,87.91 105.11,88.01 105.11,88.36 105.01,88.45 104.87,88.45 104.77,88.36 104.77,88.01 104.67,87.91 104.53,87.91 104.44,88.01 104.44,88.36 104.34,88.45 104.2,88.45 104.1,88.36 104.1,88.01 104,87.91 103.86,87.91 103.77,88.01 103.77,88.36 103.67,88.45 103.53,88.45 103.43,88.36 103.43,88.01 103.33,87.91 98.02,87.91 94.92,91.01 94.08,91.01 93.84,91.25 93.84,92.09 89.4,96.53 87.79,96.53 87.02,97.3 87.02,97.57 86.64,97.96 83.68,97.96 83.58,97.86 83.58,97.54 83.68,97.44 v1(84.04,97.44)
DDR4_DIMM_CH0_DQ16: length 60.1
  L16_SIG6 w0.081: v1(123.57,82.43) 123.12,82.43 123.02,82.52 122.58,82.52 122.07,83.04 121.7,83.04 121.5,83.23 121.13,83.23 120.33,84.03 119.64,84.03 118.62,85.05 117.45,85.05 117.35,84.95 117.35,84.81 117.45,84.72 117.9,84.72 118,84.62 118,84.48 117.9,84.38 117.11,84.38 117.02,84.48 117.02,84.95 116.92,85.05 116.6,85.05 115.57,84.02 107.24,84.02 106.43,84.83 105.8,84.83 105.32,85.31 104.09,85.31 103.99,85.41 103.99,85.55 104.09,85.65 104.65,85.65 104.74,85.75 104.74,85.89 104.65,85.98 102.49,85.98 102.12,86.36 101.98,86.36 101.64,86.02 101.5,86.02 101.41,86.12 101.41,86.26 101.74,86.59 101.74,86.73 101.34,87.14 100.77,87.14 100.54,87.37 100.4,87.37 100.26,87.23 100.12,87.23 100.02,87.32 100.02,87.46 100.17,87.6 100.17,87.74 100.01,87.9 96.33,87.9 96.24,88 96.24,88.14 96.33,88.24 99.78,88.24 99.87,88.34 99.87,88.48 99.78,88.57 96.51,88.57 96.41,88.67 96.41,88.81 96.51,88.91 98.96,88.91 99.06,89.01 99.06,89.15 98.96,89.24 96.25,89.24 95.82,88.81 95.49,88.81 95.39,88.91 95.39,89.16 95.29,89.26 95.15,89.26 95.05,89.16 95.05,88.97 94.95,88.87 94.81,88.87 94.72,88.97 94.72,89.1 94.62,89.2 94.48,89.2 94.38,89.1 94.38,88.91 94.28,88.81 93.88,88.81 93.47,89.22 90.16,89.22 88.29,91.09 v1(88.29,91.44)
DDR4_DIMM_CH0_DQ17: length 60.3
  L16_SIG6 w0.081: v1(89.14,97.44) 88.31,96.61 88.31,95.8 88.21,95.7 88.07,95.7 87.97,95.8 87.97,96.98 87.88,97.07 87.74,97.07 87.64,96.98 87.64,94.44 87.74,94.34 87.88,94.34 87.97,94.44 87.97,95.16 88.07,95.26 88.21,95.26 88.31,95.16 88.31,94.19 88.03,93.91 88.03,93.42 87.84,93.23 87.84,90.99 89.99,88.84 93.33,88.84 93.43,88.74 93.43,88.6 93.33,88.5 91.76,88.5 91.67,88.4 91.67,88.26 91.76,88.17 93.5,88.17 93.75,87.92 94.17,87.92 94.74,88.49 95.38,88.49 95.48,88.39 95.48,88.25 95.38,88.15 94.9,88.15 94.8,88.05 94.8,87.91 94.9,87.82 95.37,87.82 95.47,87.72 95.47,87.58 95.37,87.48 94.6,87.48 94.51,87.38 94.51,87.24 94.6,87.14 99.7,87.14 101.33,85.51 103.38,85.51 104.08,84.81 105.19,84.81 105.97,84.03 106.71,84.03 107.11,83.63 115.76,83.63 116.17,84.03 119.13,84.03 119.67,83.49 120.39,83.49 120.96,82.92 121.33,82.92 121.44,82.81 122,82.81 122.49,82.31 122.86,82.31 123.2,81.98 123.2,81.8 v1(123.57,81.43)
DDR4_DIMM_CH0_DQ18: length 60.5
  L16_SIG6 w0.081: v1(94.24,91.44) 93.56,92.12 93.28,92.12 92.76,92.63 92.76,93.29 93.1,93.63 94.04,93.63 95.68,95.27 95.68,95.8 95.85,95.97 98.38,95.97 98.76,95.59 101.59,95.59 101.87,95.31 101.87,92.09 101.48,91.7 101.48,91.24 101.69,91.04 102.36,91.04 103.54,89.85 104.42,89.85 105.3,88.97 105.91,88.97 107.54,87.35 107.54,87.15 107.72,86.96 108.21,86.96 108.43,87.18 108.43,87.49 108.62,87.68 110.93,87.68 111.03,87.58 111.03,87.45 110.93,87.35 108.92,87.35 108.82,87.25 108.82,87.11 108.92,87.01 111.77,87.01 112.05,87.29 112.31,87.29 112.41,87.19 112.41,86.94 112.51,86.84 112.65,86.84 112.74,86.94 112.74,87.19 112.84,87.29 112.98,87.29 113.08,87.19 113.08,86.94 113.18,86.84 113.32,86.84 113.41,86.94 113.41,87.19 113.51,87.29 113.65,87.29 113.75,87.19 113.75,86.94 113.85,86.84 113.99,86.84 114.08,86.94 114.08,87.19 114.18,87.29 114.32,87.29 114.42,87.19 114.42,86.94 114.52,86.84 114.66,86.84 114.76,86.94 114.76,87.19 114.85,87.29 115.64,87.29 116.28,87.92 120.23,87.92 121.28,86.87 121.28,86.44 121.71,86.02 122.26,86.02 123.44,84.83 124.15,84.83 125.07,83.91 125.37,83.91 126.27,83.01 126.27,82.43 126.65,82.05 126.65,80.74 126.35,80.44 125.94,80.44 125.48,80.9 125.18,80.9 124.44,81.64 v1(124.44,81.93)
DDR4_DIMM_CH0_DQ19: length 60.8
  L16_SIG6 w0.081: v1(124.44,80.93) 124.91,80.46 124.91,80.29 125.17,80.04 125.38,80.04 125.87,79.55 126.47,79.55 126.8,79.89 127.03,79.89 127.41,80.27 127.41,81.97 127.8,82.36 127.8,84.36 127.31,84.85 126.88,84.85 125.5,86.23 125.04,86.23 123.17,88.1 123.03,88.1 122.93,88 122.93,87.86 123.33,87.47 123.33,87.33 123.23,87.23 123.09,87.23 122.41,87.91 122.41,88.47 121.91,88.97 121.08,88.97 120.52,89.53 114.88,89.53 114.18,88.83 108.53,88.83 107.23,90.12 106.37,90.12 106.01,90.48 105.42,90.48 104.91,90.99 104.32,90.99 104.03,91.28 104.03,91.76 104.3,92.03 104.3,94.41 104.4,94.51 104.53,94.51 104.63,94.41 104.63,93.75 104.73,93.65 104.87,93.65 104.97,93.75 104.97,95.11 104.79,95.29 104.79,96.96 104.69,97.05 104.55,97.05 104.45,96.96 104.45,95.77 104.35,95.67 104.21,95.67 104.12,95.77 104.12,96.87 103.95,97.04 102.44,97.04 102.29,97.19 102.29,97.51 102.13,97.66 101.65,97.66 101.49,97.51 101.49,97.2 101.26,96.98 99.89,96.98 99.78,97.08 99.78,97.48 99.64,97.62 99.05,97.62 98.91,97.48 98.91,97.13 98.76,96.97 94.76,96.97 94.63,97.1 94.63,97.32 94.76,97.44 v1(95.09,97.44)
DDR4_DIMM_CH0_DQ20: length 57.2
  L16_SIG6 w0.081: v1(127.9,80.93) 127.9,80.46 127.52,80.07 127.52,79.38 127.18,79.05 126.78,79.05 126.52,79.3 125.86,79.3 125.61,79.05 125.15,79.05 124.87,79.33 124.87,80.03 124.51,80.39 124.29,80.39 123.81,80.88 123.58,80.88 123.02,81.44 122.66,81.44 122.05,82.04 121.7,82.04 121.15,82.59 120.81,82.59 120.25,83.15 119.5,83.15 119,83.65 116.27,83.65 115.89,83.27 106.98,83.27 106.62,83.63 105.44,83.63 104.3,84.1 103.23,85.17 101.19,85.17 99.57,86.8 98.76,86.8 98.66,86.7 98.66,86.46 98.56,86.37 98.42,86.37 98.32,86.46 98.32,86.7 98.22,86.8 97.63,86.8 97.53,86.7 97.53,86.63 97.43,86.53 97.29,86.53 97.19,86.63 97.19,86.7 97.1,86.8 95.58,86.8 95.48,86.7 95.48,86.59 95.38,86.5 95.24,86.5 95.14,86.59 95.14,86.7 95.05,86.8 94.91,86.8 94.81,86.7 94.81,86.59 94.71,86.5 94.57,86.5 94.47,86.59 94.47,86.7 94.38,86.8 93.17,86.8 93.07,86.9 93.07,87.04 93.17,87.14 93.63,87.14 93.73,87.23 93.73,87.37 93.63,87.47 92.99,87.47 92.64,87.82 91.54,87.82 90.95,88.41 89.56,88.41 89.03,88.94 88.52,88.94 88.32,89.15 88.32,89.71 88.05,89.98 87.55,89.98 87.03,90.5 87.03,90.86 87.39,91.22 87.39,91.47 87.02,91.84 87.02,92.25 87.42,92.65 87.42,93.15 87.31,93.25 86.69,93.25 86.59,93.15 v1(86.59,91.44)
DDR4_DIMM_CH0_DQ21: length 57.6
  L16_SIG6 w0.081: v1(87.44,97.44) 86.16,94.35 86.16,91.45 86.52,90.57 87.37,89.31 87.75,88.93 87.86,88.93 88.28,88.51 88.28,88.37 88.56,88.09 88.99,87.92 90.56,87.92 91.07,87.71 91.66,87.31 92.43,86.99 92.92,86.5 94.32,85.92 99.84,85.92 100.93,84.84 103.03,84.84 104.02,83.86 105.6,83.2 106.57,83.2 106.88,82.88 115.98,82.88 116.36,83.26 118.9,83.26 119.36,82.81 120.3,82.81 120.77,82.34 121.1,82.34 121.62,81.82 121.98,81.82 122.27,81.53 122.27,80.66 122.49,80.44 122.85,80.44 123.37,79.91 123.73,79.91 124.15,79.49 124.42,79.49 125.07,78.84 125.52,78.84 125.9,78.46 126.5,78.46 126.85,78.82 127.25,78.82 127.77,79.33 128.06,79.33 128.33,79.6 128.33,81.5 v1(127.9,81.93)
DDR4_DIMM_CH0_DQ22: length 57.3
  L16_SIG6 w0.081: v1(92.54,91.43) 92.54,92.2 91.86,92.87 91.86,93.44 92.49,94.07 93.62,94.07 94.21,94.65 94.21,95.08 94.4,95.27 94.4,95.65 95.06,96.3 98.52,96.3 98.9,95.92 101.95,95.92 102.22,95.65 102.22,95.13 102.94,94.4 102.94,92.61 102.84,92.51 102.7,92.51 102.61,92.61 102.61,94.09 102.51,94.19 102.37,94.19 102.27,94.09 102.27,91.6 103.65,90.22 104.57,90.22 104.99,89.81 105.73,89.81 106.8,88.74 106.8,88.56 107.34,88.02 111.45,88.02 111.85,87.62 114.43,87.62 114.53,87.72 114.53,87.93 114.63,88.03 114.77,88.03 114.87,87.93 114.87,87.72 114.96,87.62 115.23,87.62 115.38,87.78 115.38,88.75 115.49,88.85 115.67,88.85 115.77,88.75 115.77,88.27 115.87,88.17 116.01,88.17 116.1,88.27 116.1,88.75 116.2,88.85 117.51,88.85 117.61,88.75 117.61,88.38 117.71,88.28 117.84,88.28 117.94,88.38 117.94,88.75 118.04,88.85 119.2,88.85 119.3,88.75 119.3,88.43 119.4,88.33 119.53,88.33 119.63,88.43 119.63,88.75 119.73,88.85 120.22,88.85 123.07,86 123.59,86 124.69,84.89 125.4,84.89 125.8,84.49 125.8,84.35 125.7,84.25 125.7,84.11 125.8,84.01 125.94,84.01 126.04,84.11 126.18,84.11 126.62,83.66 126.62,82.84 v1(127.04,82.43)
DDR4_DIMM_CH0_DQ23: length 57.5
  L16_SIG6 w0.081: v1(93.39,97.44) 93.39,96.96 94.06,96.29 94.49,96.29 94.84,96.64 98.65,96.64 98.94,96.35 101.96,96.35 102.31,96.7 103.6,96.7 103.7,96.6 103.7,96.46 103.6,96.37 102.67,96.37 102.57,96.27 102.57,96.13 102.67,96.03 103.59,96.03 103.68,95.93 103.68,95.79 103.59,95.7 102.67,95.7 102.57,95.6 102.57,95.46 102.67,95.36 103.38,95.36 103.65,95.09 103.65,94.78 103.28,94.4 103.28,92.78 103.37,92.68 103.51,92.68 103.61,92.78 103.61,94.19 103.71,94.28 103.85,94.28 103.95,94.19 103.95,92.45 103.14,91.65 103.14,91.2 103.74,90.6 104.66,90.6 105.12,90.14 105.87,90.14 107.21,88.81 107.86,88.81 108.2,88.47 111.47,88.47 111.96,87.98 113.81,87.98 115.02,89.19 120.35,89.19 122.73,86.81 123.92,86.81 124.1,86.62 124.1,86.48 123.93,86.31 123.93,86.17 124.03,86.07 124.18,86.07 124.36,86.24 124.5,86.24 124.59,86.15 124.59,86.01 124.43,85.84 124.43,85.65 124.53,85.54 124.74,85.54 125.06,85.87 125.39,85.87 125.75,85.51 125.75,85.11 126.94,83.92 127.22,83.92 127.45,83.68 127.45,82.31 127.04,81.9 v1(127.04,81.43)
DDR4_DIMM_CH0_DQ24: length 55
  L12_SIG4 w0.089: v1(123.57,79.43) 123.57,79.89 123.96,80.28 123.96,80.58 123.8,80.73 123.8,81.12 124,81.32 124,81.53 123.82,81.71 123.82,82.14 124.18,82.5 124.18,82.87 124.04,83.02 123.63,83.02 123.39,82.78 123.15,82.78 122.99,82.93 122.99,83.65 123.22,83.88 123.8,83.88 124.06,84.14 124.06,84.86 123.95,84.97 123.25,84.97 122.98,85.23 122.98,85.68 123.23,85.93 123.9,85.93 124.06,86.09 124.06,86.71 123.65,87.12 123.51,87.12 123.22,86.83 123.09,86.83 122.99,86.93 122.99,87.07 123.28,87.36 123.28,87.5 123.18,87.6 123.04,87.6 122.89,87.44 122.75,87.44 122.65,87.54 122.65,87.68 122.8,87.83 122.8,87.97 122.36,88.42 122.36,88.62 122,88.98 121.25,88.98 120.25,89.98 120.25,90.12 120.34,90.22 120.48,90.22 121.19,89.51 121.33,89.51 121.43,89.61 121.43,89.75 120.53,90.64 117.79,90.64 117.62,90.47 116.99,90.47 116.5,90.97 109.95,90.97 109.85,91.07 109.85,91.22 109.95,91.32 110.71,91.32 110.82,91.42 110.82,91.74 110.71,91.84 109.89,91.84 109.8,91.94 109.8,92.26 109.7,92.36 109.56,92.36 109.46,92.26 109.46,91.94 109.36,91.84 109.22,91.84 109.13,91.94 109.13,92.26 109.03,92.36 108.89,92.36 108.79,92.26 108.79,91.94 108.69,91.84 108.42,91.84 108.32,91.94 108.32,92.94 108.12,93.14 107.83,93.14 107.1,92.41 105.67,92.41 104.9,91.64 104.9,91.24 104.24,90.58 102.12,90.58 101.85,90.31 98.13,90.31 97.17,91.26 97.17,92.38 97.27,92.48 97.54,92.48 97.64,92.38 v1(97.64,91.44)
DDR4_DIMM_CH0_DQ25: length 55
  L12_SIG4 w0.089: v1(123.57,78.43) 123.1,78.9 123.1,82.12 122.62,82.61 122.62,87.09 119.74,89.97 116.91,89.97 116.28,90.6 109.2,90.6 108.75,91.05 108.5,91.05 107.95,91.61 107.54,91.61 107.32,91.83 105.97,91.83 105.73,91.58 105.73,91.18 104.76,90.22 102.32,90.22 102.03,89.93 98,89.93 96.05,91.88 96.05,94.37 97.25,95.58 97.25,96.98 97.35,97.07 97.49,97.07 97.59,96.98 97.59,95.01 97.68,94.91 97.82,94.91 97.92,95.01 97.92,96.96 98.02,97.06 98.16,97.06 98.26,96.96 98.26,95.01 98.35,94.91 98.49,94.91 98.59,95.01 98.59,97.34 v1(98.49,97.44)
DDR4_DIMM_CH0_DQ26: length 54.1
  L12_SIG4 w0.089: v1(124.44,79.93) 124.89,80.38 124.89,87.07 123.93,88.03 123.93,88.17 124.03,88.27 124.17,88.27 124.57,87.86 124.71,87.86 124.81,87.96 124.81,88.1 124.09,88.82 123.59,88.82 121.05,91.37 121.05,91.64 121.15,91.75 121.32,91.75 121.42,91.85 121.42,92.19 121.32,92.29 120.38,92.29 120.28,92.19 120.28,91.66 120.18,91.56 120.02,91.56 119.92,91.66 119.92,91.88 119.82,91.99 119.68,91.99 119.57,91.88 119.57,91.49 119.47,91.39 119.37,91.39 119.27,91.49 119.27,91.82 119.13,91.95 116.94,91.95 116.51,92.39 116.05,92.39 115.75,92.08 115.23,92.08 115.08,92.23 114.82,92.23 114.72,92.34 114.72,92.88 114.63,92.97 114.38,92.97 114.29,92.88 114.29,92.34 114.19,92.23 112.76,92.23 112.28,91.76 111.93,91.76 111.69,92.01 111.69,92.79 111.41,93.07 109.21,93.07 108.36,93.91 107.54,93.91 106.9,93.28 105.42,93.28 104.44,92.29 104.3,92.29 104.2,92.39 104.2,92.53 105.1,93.43 105.1,93.57 105.01,93.67 104.87,93.67 103.34,92.14 103.2,92.14 103.1,92.24 103.1,92.38 104.15,93.42 104.15,93.56 104.05,93.66 103.91,93.66 102.72,92.47 102.58,92.47 102.48,92.57 102.48,92.71 103.21,93.44 103.21,93.56 103.12,93.65 103,93.65 101.44,92.1 101.44,91.95 101.57,91.82 101.72,91.82 101.98,92.08 102.18,92.08 102.96,91.3 103.45,91.3 v1(103.59,91.44)
DDR4_DIMM_CH0_DQ27: length 54.1
  L12_SIG4 w0.089: v1(104.44,97.44) 104.06,97.83 102.12,97.83 99.98,95.69 99.84,95.69 99.75,95.78 99.75,95.92 100.35,96.52 100.35,96.66 100.25,96.76 100.11,96.76 99.24,95.89 99.24,94.95 98.08,93.78 98.08,91.64 99.02,90.7 101.67,90.7 101.91,90.94 103.79,90.94 104.04,91.19 104.04,91.67 104.2,91.83 104.47,91.83 105.47,92.83 106.98,92.83 107.69,93.54 108.22,93.54 109.03,92.72 111.08,92.72 111.3,92.51 111.3,91.9 111.84,91.36 112.37,91.36 112.85,91.84 114.87,91.84 115.04,91.66 115.89,91.66 116.15,91.92 116.44,91.92 117,91.36 117.31,91.36 117.65,91.03 120.85,91.03 123.17,88.71 123.17,88.16 124.49,86.84 124.49,82.51 124.05,82.07 124.05,81.78 124.26,81.58 124.26,81.28 124.06,81.08 124.06,80.77 124.24,80.59 124.24,80.26 124.03,80.05 124.03,79.81 124.44,79.4 v1(124.44,78.93)
DDR4_DIMM_CH0_DQ28: length 51.7
  L12_SIG4 w0.089: v1(95.94,91.44) 98.39,88.99 101.65,88.99 102.53,89.87 105.22,89.87 106.3,90.96 108,90.96 108.71,90.25 115.71,90.25 116.48,89.48 119.65,89.48 122.27,86.86 122.27,80.18 121.96,79.87 121.65,79.87 121.24,79.46 120.94,79.46 120.42,78.93 120.03,78.93 119.48,78.38 118.97,78.38 118.73,78.13 118.73,77.7 119.01,77.42 119.45,77.42 119.93,77.9 120.27,77.9 120.77,78.4 121.12,78.4 121.62,78.9 122.09,78.9 122.56,78.43 122.86,78.43 123.31,77.99 123.8,77.99 124.19,78.38 124.6,78.38 125.05,77.93 125.45,77.93 125.84,77.55 126.33,77.55 126.6,77.82 126.6,77.99 v1(127.04,78.43)
DDR4_DIMM_CH0_DQ29: length 49.7
  L12_SIG4 w0.089: v1(127.9,78.93) 128.82,78.93 129.17,79.27 129.17,90.26 128.47,91.93 123.43,96.98 118.7,96.98 118.2,97.19 116.36,97.19 115.97,97.03 114.48,97.03 114.19,97.32 114.19,97.65 113.69,98.15 112.51,98.64 111.9,99.25 111.25,99.51 103.56,99.51 103.11,99.33 102.27,99.33 101.83,99.51 100.99,99.51 98.12,98.32 v1(96.79,97.44)
DDR4_DIMM_CH0_DQ30: length 51.8
  L12_SIG4 w0.089: v1(101.89,91.44) 101.5,91.05 99.17,91.05 98.95,91.28 98.95,92.35 98.43,92.87 98.43,93.55 101.33,96.45 102.25,96.45 102.96,95.74 103.11,95.74 103.21,95.84 103.21,95.99 102.75,96.44 102.75,96.57 102.85,96.67 102.98,96.67 103.79,95.85 106.11,95.85 106.6,95.36 108.99,95.36 109.45,94.9 112.28,94.9 112.61,94.57 115.07,94.57 115.68,93.96 123.24,93.96 124.45,92.75 124.45,92.32 125.19,91.59 125.19,90.47 126.65,89.01 126.65,87.04 126.74,86.95 126.95,86.95 127.04,86.86 127.04,86.7 126.95,86.61 126.74,86.61 126.65,86.51 126.65,86.37 126.74,86.28 126.96,86.28 127.05,86.19 127.05,86.03 126.96,85.94 126.74,85.94 126.65,85.84 126.65,79.82 v1(127.04,79.43)
DDR4_DIMM_CH0_DQ31: length 49.6
  L12_SIG4 w0.089: v1(127.9,79.93) 127.41,80.42 127.41,88.79 125.62,90.59 125.62,92.42 125.07,92.97 124.77,92.97 123.16,94.57 115.74,94.57 115.33,94.97 112.83,94.97 112.54,95.26 110.37,95.26 109.75,95.88 109.18,95.88 109,95.7 106.87,95.7 106.77,95.8 106.77,95.94 106.87,96.04 108.57,96.04 108.67,96.14 108.67,96.28 108.57,96.37 105.94,96.37 105.84,96.47 105.84,96.61 105.94,96.71 107.8,96.71 107.9,96.81 107.9,96.95 107.8,97.04 104.41,97.04 104.31,96.95 104.31,96.81 104.41,96.71 105.27,96.71 105.37,96.61 105.37,96.47 105.27,96.37 103.81,96.37 v1(102.74,97.44)
DDR4_DIMM_CH0_DQ32: length 46.7
  L03_SIG1 w0.081: v4(130.5,79.43) 130.61,79.54 130.61,80 130.9,80.29 130.9,84.96 131.93,85.98 131.93,86.12 131.83,86.22 131.69,86.22 131.05,85.58 130.91,85.58 130.81,85.68 130.81,85.82 131.85,86.85 132.52,86.85 133.67,88.01 134.43,88.01 135.4,88.98 136.09,88.98 136.23,89.12 136.23,89.26 136.33,89.36 136.67,89.36 136.77,89.26 136.77,89.08 136.87,88.98 137.9,88.98 138.28,89.36 138.28,89.92 138.83,90.47 138.83,90.66 139.21,91.04 140.95,91.04 141.16,91.26 141.16,92.13 141.3,92.27 141.57,92.27 141.89,91.94 142.1,91.94 142.26,92.11 142.26,92.36 142.1,92.52 142.1,92.72 142.35,92.97 142.97,92.97 143.07,93.06 143.07,93.34 143.17,93.43 143.31,93.43 143.4,93.34 143.4,92.86 143.5,92.76 143.64,92.76 143.74,92.86 143.74,93.34 143.84,93.43 143.98,93.43 144.08,93.34 144.08,92.85 144.17,92.75 144.31,92.75 144.41,92.85 144.41,93.34 144.51,93.43 144.65,93.43 144.75,93.34 144.75,93.06 144.84,92.97 145.49,92.97 146.23,93.71 146.76,93.71 147.51,92.95 148.04,92.95 148.2,93.12 148.2,93.94 148.44,94.17 148.68,94.17 148.91,93.94 148.91,93.22 149.1,93.03 149.98,93.03 150.26,93.31 151.02,93.31 152.09,94.38 153.84,94.38 154.07,94.14 154.07,93.76 152.89,92.58 v4(152.89,91.44)
DDR4_DIMM_CH0_DQ33: length 46.5
  L03_SIG1 w0.081: v4(129.64,79.93) 129.24,80.32 129.24,82.63 128.92,82.96 128.58,82.96 128.29,83.25 128.29,86.54 128.78,87.03 129.05,87.03 129.77,87.74 130.69,87.74 131.87,88.91 132.42,88.91 135.42,91.91 135.56,91.91 135.66,91.81 135.66,91.67 135.05,91.06 135.05,90.92 135.15,90.82 135.28,90.82 136.32,91.86 136.32,92.13 137.11,92.93 137.25,92.93 137.35,92.83 137.35,92.69 136.96,92.3 136.96,92.16 137.06,92.06 137.19,92.06 138.17,93.04 139.48,93.04 139.97,93.53 140.2,93.53 140.64,93.98 141.26,93.98 142.16,94.88 144.73,94.88 145.76,95.91 148.88,95.91 149.51,96.54 150.84,96.54 151.47,95.91 153.64,95.91 153.74,96.01 153.74,96.15 153.64,96.25 151.83,96.25 151.74,96.35 151.74,96.49 151.83,96.58 153.48,96.58 153.74,96.85 v4(153.74,97.44)
DDR4_DIMM_CH0_DQ34: length 46.8
  L03_SIG1 w0.081: v4(130.5,78.43) 131.55,78.43 131.92,78.05 132.39,78.05 132.7,78.36 132.7,79.12 133.03,79.45 133.23,79.45 133.53,79.76 133.53,83.67 133.89,84.03 134.15,84.03 134.63,84.51 135.81,84.51 137.34,86.04 137.79,86.04 138.66,86.91 140.4,86.91 140.94,87.45 142.62,87.45 143.41,88.25 146.22,88.25 146.4,88.42 146.4,89.79 146.98,90.37 151.78,90.37 152.03,90.12 154.9,90.12 156.62,91.85 157.71,91.85 157.81,91.94 157.81,92.08 157.71,92.18 156.88,92.18 156.78,92.28 156.78,92.42 156.88,92.52 157.64,92.52 157.73,92.62 157.73,92.75 157.64,92.85 156.88,92.85 156.78,92.95 156.78,93.09 156.88,93.19 157.49,93.19 157.59,93.29 157.59,93.42 157.49,93.52 156.88,93.52 156.78,93.62 156.78,93.76 156.88,93.86 158.05,93.86 158.84,93.06 v4(158.84,91.44)
DDR4_DIMM_CH0_DQ35: length 46.2
  L03_SIG1 w0.081: v4(129.64,78.93) 129.28,79.28 129.28,79.57 128.98,79.87 128.55,79.87 128.32,80.1 128.32,82.33 127.93,82.73 127.93,86.72 128.58,87.37 128.81,87.37 130.28,88.84 131.11,88.84 132.13,89.86 132.84,89.86 135.27,92.29 135.72,92.29 136.78,93.35 137.72,93.35 138.21,93.83 138.37,93.9 140.02,93.9 140.51,94.4 141.04,94.4 142.55,95.9 142.83,95.9 143.32,96.39 143.78,96.39 144.26,95.9 145,95.9 145.83,96.73 148.16,96.73 148.47,97.04 150.78,97.04 150.93,97.19 151.45,97.19 151.62,97.02 152.17,97.02 152.51,97.36 152.51,97.67 152.89,98.05 159.09,98.05 v4(159.69,97.44)
DDR4_DIMM_CH0_DQ36: length 42.8
  L03_SIG1 w0.081: v4(133.1,79.93) 132.72,80.3 132.72,83.9 133.72,84.9 135.73,84.9 136.3,85.47 136.3,86.72 136.53,86.95 138.04,86.95 138.9,87.81 142.49,87.81 143.38,88.7 143.38,90.92 143.48,91.02 143.62,91.02 143.72,90.92 143.72,88.8 143.81,88.7 143.95,88.7 144.05,88.8 144.05,90.27 144.15,90.37 144.29,90.37 144.39,90.27 144.39,88.8 144.48,88.7 144.62,88.7 144.72,88.8 144.72,90.16 144.82,90.26 144.96,90.26 145.06,90.16 145.06,88.8 145.15,88.7 145.29,88.7 145.39,88.8 145.39,91.14 145.49,91.24 145.63,91.24 145.73,91.14 145.73,88.8 145.83,88.7 145.96,88.7 146.06,88.8 146.06,89.93 146.51,90.38 146.51,90.74 146.77,91 148.42,91 148.57,91.15 148.93,91.15 149.07,91.01 150.76,91.01 v4(151.19,91.44)
DDR4_DIMM_CH0_DQ37: length 43.7
  L03_SIG1 w0.081: v4(133.1,78.93) 133.1,78.47 132.43,77.8 131.95,77.8 131.62,77.48 131.13,77.48 130.68,77.93 130.36,77.93 129.9,78.4 129.49,78.4 128.96,78.93 128.61,78.93 128.09,79.46 127.8,79.46 127.53,79.73 127.53,86.85 128.53,87.86 128.79,87.86 130.15,89.21 131,89.21 131.99,90.19 132.7,90.19 135.13,92.62 135.58,92.62 136.78,93.82 137.7,93.82 137.98,94.1 138.4,94.28 139.89,94.28 140.53,94.91 140.65,94.91 142.81,97.07 147.99,97.07 148.74,97.82 151.66,97.82 v4(152.04,97.44)
DDR4_DIMM_CH0_DQ38: length 42.5
  L03_SIG1 w0.081: v4(157.14,91.44) 156.7,91.44 155.02,89.77 147.08,89.77 146.98,89.67 146.98,89.53 147.08,89.43 147.8,89.43 147.9,89.33 147.9,89.19 147.8,89.1 146.88,89.1 146.73,88.95 146.73,88.22 146.4,87.89 145.55,87.89 145.45,87.79 145.45,87.65 145.55,87.55 145.93,87.55 146.03,87.45 146.03,87.31 145.93,87.21 145.14,87.21 145.04,87.31 145.04,87.79 144.94,87.89 143.53,87.89 142.73,87.09 142.38,87.09 140.77,85.48 140.63,85.48 140.53,85.58 140.53,85.72 141.67,86.86 141.67,87 141.57,87.09 141.43,87.09 140.38,86.04 138.35,86.04 138.25,85.94 138.25,85.81 138.35,85.71 140,85.71 140.1,85.61 140.1,85.47 140,85.37 137.98,85.37 137.44,84.83 136.67,84.83 136.01,84.18 134.98,84.18 134.42,83.62 134.42,79.89 v4(133.97,79.43)
DDR4_DIMM_CH0_DQ39: length 43
  L03_SIG1 w0.081: v4(157.99,97.44) 158.54,96.89 158.54,94.52 158.64,94.42 158.78,94.42 158.88,94.52 158.88,95.88 158.98,95.98 159.12,95.98 159.21,95.88 159.21,91.2 158.98,90.97 156.83,90.97 155.23,89.36 148.67,89.36 146.13,86.82 143.47,86.82 143.11,86.46 142.25,86.46 140.81,85.03 138.11,85.03 137.53,84.44 136.75,84.44 136.15,83.84 135.47,83.84 135.24,83.61 135.24,79.71 134.91,79.38 134.63,79.38 134.32,79.07 134.32,78.79 v4(133.97,78.43)
DDR4_DIMM_CH0_DQ40: length 52.9
  L16_SIG6 w0.081: v1(162.24,91.44) 162.24,93.95 162.14,94.04 162,94.04 161.91,93.95 161.91,92.03 161.81,91.93 161.67,91.93 161.57,92.03 161.57,93.96 161.47,94.06 161.33,94.06 161.24,93.96 161.24,92.03 161.14,91.93 161,91.93 160.9,92.03 160.9,93.88 160.72,94.06 154.87,94.06 154.77,93.97 154.77,93.83 154.87,93.73 155.92,93.73 156.02,93.63 156.02,93.49 155.92,93.39 152.63,93.39 152.53,93.49 152.53,93.63 152.63,93.73 154.04,93.73 154.14,93.83 154.14,93.97 154.04,94.06 147.21,94.06 147.06,93.91 145.74,93.91 145.59,94.06 145.09,94.06 143.14,92.11 143.14,90.71 141.49,89.06 140.09,89.06 139.66,88.62 139.66,84.28 137.87,82.5 137.87,81.95 136.56,80.64 v1(136.56,79.93)
DDR4_DIMM_CH0_DQ41: length 54.2
  L16_SIG6 w0.081: v1(163.09,97.44) 163.61,97.44 163.78,97.27 164.15,97.27 164.64,96.78 165.72,96.78 166.78,97.84 168.36,97.84 168.62,97.58 168.62,91.01 167.8,90.18 167.8,89.39 164.17,85.76 158.2,85.76 152.37,79.93 146.46,79.93 144.88,78.35 143.21,78.35 142.92,78.05 142.4,78.05 142.15,78.31 141.36,78.31 141.09,78.03 140.63,78.03 140.35,78.31 139.87,78.31 139.38,77.82 138.81,77.82 138.55,77.56 138.09,77.56 137.58,77.05 137.28,77.05 136.78,77.55 136.41,77.55 136.07,77.89 136.07,79.05 v1(135.7,79.43)
DDR4_DIMM_CH0_DQ42: length 52.9
  L16_SIG6 w0.081: v1(136.56,78.93) 136.56,78.45 137.19,77.83 137.67,77.83 138.15,78.31 138.71,78.31 138.96,78.06 139.32,78.06 139.82,78.55 140.28,78.55 140.54,78.81 144.85,78.81 144.94,78.91 144.94,79.04 144.85,79.14 143.7,79.14 143.6,79.24 143.6,79.38 143.7,79.48 145.32,79.48 145.42,79.58 145.42,79.72 145.32,79.81 144.39,79.81 144.29,79.91 144.29,80.05 144.39,80.15 146.13,80.15 146.31,80.33 152.24,80.33 157.77,85.85 157.77,86.39 158.18,86.8 160.67,86.8 160.77,86.71 160.77,86.57 160.67,86.47 158.43,86.47 158.34,86.37 158.34,86.23 158.43,86.13 162.68,86.13 162.78,86.23 162.78,86.37 162.68,86.47 161.45,86.47 161.35,86.57 161.35,86.71 161.45,86.8 164.46,86.8 167.04,89.39 167.04,90.29 v1(168.19,91.44)
DDR4_DIMM_CH0_DQ43: length 54.1
  L16_SIG6 w0.081: v1(169.04,97.44) 169.04,95.45 169.14,95.35 169.28,95.35 169.38,95.45 169.38,96.05 169.48,96.15 169.61,96.15 169.71,96.05 169.71,93.71 169.61,93.61 169.48,93.61 169.38,93.71 169.38,94.63 169.28,94.73 169.14,94.73 169.04,94.63 169.04,92.35 169.44,91.95 169.44,90.68 168.36,89.59 168.36,89.44 164.25,85.33 159.05,85.33 156.34,82.63 156.34,81.77 155.63,81.05 154.26,81.05 153.14,79.93 153.14,78.29 152.65,77.8 142.39,77.8 142.13,77.54 141.49,77.54 141.23,77.81 140.52,77.81 140.05,77.34 139.68,77.34 139.33,76.99 138.89,76.99 138.57,77.3 138.14,77.3 137.67,76.83 137.19,76.83 136.68,77.34 136.31,77.34 135.7,77.95 v1(135.7,78.43)
DDR4_DIMM_CH0_DQ44: length 51.8
  L16_SIG6 w0.081: v1(139.16,78.43) 139.05,78.54 138.07,78.54 137.58,78.06 137.26,78.06 137.04,78.28 137.04,80.56 138.2,81.73 138.2,82.36 140.57,84.72 140.57,87.62 143.96,91 143.96,91.8 145.19,93.03 146.08,93.03 146.37,93.32 147.1,93.32 147.39,93.03 156.91,93.03 157.19,92.75 157.19,91.97 157.29,91.87 157.43,91.87 157.52,91.97 157.52,93.41 157.62,93.51 157.76,93.51 157.86,93.41 157.86,91.97 157.96,91.87 158.1,91.87 158.2,91.97 158.2,93.44 158.29,93.54 158.43,93.54 158.53,93.44 158.53,91.97 158.63,91.87 158.77,91.87 158.87,91.97 158.87,93.44 158.96,93.54 159.1,93.54 159.2,93.44 159.2,91.97 159.3,91.87 159.44,91.87 159.54,91.97 159.54,93.49 159.63,93.59 159.77,93.59 159.87,93.49 159.87,91.97 159.97,91.87 160.11,91.87 160.21,91.97 160.21,92.73 160.3,92.83 160.44,92.83 160.54,92.73 v1(160.54,91.44)
DDR4_DIMM_CH0_DQ45: length 51.4
  L16_SIG6 w0.081: v1(161.39,97.44) 162.68,96.15 165.23,96.15 165.34,96.05 165.34,92.74 165.41,92.66 165.66,92.66 165.76,92.76 165.76,95.98 165.86,96.08 166,96.08 166.12,95.96 166.12,91.25 165.46,90.59 165.46,89.39 164.85,88.78 164.04,88.78 163.67,89.15 163.19,89.15 162.83,88.79 156.72,88.79 156.18,89.33 148.81,89.33 146.16,86.68 146.16,82.48 145.27,81.59 143.67,81.59 142.98,80.9 142.4,80.9 142.02,80.52 141.59,80.52 141.12,80.05 140.6,80.05 140.48,79.93 v1(140.03,79.93)
DDR4_DIMM_CH0_DQ46: length 51.9
  L16_SIG6 w0.081: v1(139.16,79.43) 140.32,79.43 140.7,79.81 141.39,79.81 141.63,80.05 142.78,80.05 143.93,81.2 145.45,81.2 146.58,82.32 146.58,86.54 148.97,88.93 154.9,88.93 155,88.83 155,88.69 154.9,88.59 153.01,88.59 152.91,88.49 152.91,88.36 153.01,88.26 155.24,88.26 155.34,88.16 155.34,88.02 155.24,87.92 153.75,87.92 153.65,87.82 153.65,87.69 153.75,87.59 155.34,87.59 155.43,87.49 155.43,87.35 155.34,87.25 154.32,87.25 154.23,87.15 154.23,87.01 154.32,86.92 155.85,86.92 155.95,86.82 155.95,86.68 155.85,86.58 154.64,86.58 154.54,86.48 154.54,86.34 154.64,86.25 156.14,86.25 156.66,87.5 156.66,88 157.11,88.45 164.99,88.45 165.87,89.33 165.87,90.37 166.49,91 v1(166.49,91.44)
DDR4_DIMM_CH0_DQ47: length 50.8
  L16_SIG6 w0.081: v1(167.34,97.44) 167.34,95.57 167.44,95.47 167.58,95.47 167.68,95.57 167.68,95.98 167.78,96.08 167.91,96.08 168.01,95.98 168.01,92.34 167.91,92.24 167.78,92.24 167.68,92.34 167.68,94.54 167.58,94.64 167.44,94.64 167.34,94.54 167.34,92.79 167.24,92.69 167.1,92.69 167.01,92.79 167.01,94.44 166.91,94.54 166.77,94.54 166.67,94.44 166.67,92.12 166.91,91.88 166.91,90.83 166.48,90.4 166.48,89.46 164.95,87.93 158.53,87.93 155.98,85.38 155.48,85.38 154.82,84.73 154.82,83.52 152.03,80.73 144.12,80.73 143.21,79.81 141.95,79.81 141.18,79.04 140.14,79.04 v1(140.03,78.93)
DDR4_DIMM_CH0_DQ48: length 61.6
  L03_SIG1 w0.081: v4(171.59,91.44) 170.75,92.29 168.42,92.29 168.33,92.38 168.33,92.52 168.42,92.62 171.46,92.62 171.56,92.72 171.56,92.86 171.46,92.96 168.56,92.96 167.89,93.62 163.02,93.62 162.21,92.81 162.21,92.25 162.77,91.7 162.77,91.06 162.45,90.74 160.65,90.74 160.55,90.64 160.55,90.5 160.65,90.41 161.82,90.41 161.91,90.31 161.91,90.17 161.82,90.07 159.88,90.07 159.73,89.92 159.73,89.53 160.24,89.02 160.24,88.6 159.52,87.88 159.38,87.88 159.28,87.98 159.28,88.12 159.77,88.6 159.77,88.74 159.67,88.84 159.53,88.84 157.3,86.62 157.07,86.62 155.95,85.49 155.95,85.35 156.05,85.26 156.19,85.26 156.46,85.52 156.59,85.52 156.67,85.44 156.67,85.27 152.39,80.99 148.13,80.99 146.24,82.88 146.24,83.77 145.12,84.89 142.53,84.89 141.73,84.09 138.75,84.09 137.72,83.06 136.99,83.06 136.56,82.63 v4(136.56,81.93)
DDR4_DIMM_CH0_DQ49: length 61.1
  L03_SIG1 w0.081: v4(135.7,82.43) 137.09,83.82 137.84,83.82 138.45,84.43 141.08,84.43 142.5,85.85 146,85.85 148.84,88.7 157.44,88.7 159.14,90.4 159.51,90.4 160.1,91 160.1,91.62 164.16,95.68 166.25,95.68 166.35,95.58 166.35,95.44 166.25,95.34 164.64,95.34 164.54,95.24 164.54,95.1 164.64,95.01 166.25,95.01 166.35,94.91 166.35,94.77 166.25,94.67 164.64,94.67 164.54,94.57 164.54,94.43 164.64,94.34 168.48,94.34 168.57,94.43 168.57,94.57 168.48,94.67 167.05,94.67 166.95,94.77 166.95,94.91 167.05,95.01 168.48,95.01 168.57,95.1 168.57,95.24 168.48,95.34 167.06,95.34 166.96,95.44 166.96,95.58 167.06,95.68 169.72,95.68 169.81,95.78 169.81,95.91 169.72,96.01 168.83,96.01 168.74,96.11 168.74,96.25 168.83,96.35 171.35,96.35 v4(172.44,97.44)
DDR4_DIMM_CH0_DQ50: length 61.9
  L03_SIG1 w0.081: v4(177.54,91.44) 177.54,89.77 177.22,89.45 177.22,87.71 174.58,85.07 172.63,85.07 171.2,83.64 170.44,83.64 169.93,83.14 168.79,83.14 166.72,81.07 166.54,81.07 166.39,81.22 166.39,81.39 167.8,82.8 167.8,82.98 167.65,83.13 167.47,83.13 165.45,81.1 163.96,81.1 163.17,80.31 163.17,80.13 163.65,79.66 163.65,79.48 162.74,78.57 162.56,78.57 162.41,78.72 162.41,78.9 162.99,79.48 162.99,79.66 162.85,79.81 162.67,79.81 161.68,78.82 161.68,78.44 160.74,77.5 158.97,77.5 155.44,76.04 154.87,75.46 153.65,74.96 146.49,74.96 146.13,75.31 146.13,75.47 145.73,75.87 145.5,75.87 145.14,76.23 145.14,76.53 144.74,76.94 144.53,76.94 142.92,78.55 141.59,78.55 141.36,78.79 141.36,79.58 141.1,79.83 140.85,79.83 140.37,80.32 139.81,80.32 139.4,79.91 138.97,79.91 138.61,79.55 137.94,79.55 137.58,79.91 137.32,79.91 136.96,80.27 136.96,80.53 v4(136.56,80.93)
DDR4_DIMM_CH0_DQ51: length 61.7
  L03_SIG1 w0.081: v4(135.7,81.43) 136.1,80.45 136.1,79.87 136.56,79.4 136.84,79.4 137.19,79.05 137.83,79.05 138.08,79.3 138.59,79.3 138.84,79.05 139.43,79.05 139.71,79.33 140.3,79.33 140.72,78.91 140.94,78.91 141.54,78.3 142.64,78.3 144.15,76.79 144.15,76.28 144.49,75.94 144.69,75.94 145.08,75.55 145.08,75.35 145.52,74.91 145.74,74.91 146.08,74.57 146.08,74.32 146.46,73.94 153.57,73.94 155.83,74.88 156.09,75.14 156.09,75.47 156.69,76.07 159.1,77.07 160.99,77.07 165.43,79.44 167.97,80.21 170.79,83.03 171.26,83.14 172.38,83.14 172.75,83.51 176.32,85.44 177.94,87.18 178.56,88.68 178.79,89.86 178.79,95.42 v4(178.39,97.44)
DDR4_DIMM_CH0_DQ52: length 59
  L03_SIG1 w0.081: v4(140.03,80.93) 139.07,80.93 138.69,80.55 137.9,80.55 137.56,80.89 137.34,80.89 136.96,81.26 136.96,82.53 137.24,82.8 137.94,82.8 138.78,83.65 142.25,83.65 142.4,83.8 144.84,83.8 148,80.64 152.57,80.64 158.35,86.41 158.71,86.41 163.3,91.01 163.3,91.43 163.73,91.86 165.01,91.86 165.1,91.96 165.1,92.09 165.01,92.19 163.83,92.19 163.73,92.29 163.73,92.43 163.83,92.53 165.31,92.53 165.41,92.63 165.41,92.76 165.31,92.86 163.98,92.86 163.88,92.96 163.88,93.1 163.98,93.2 167.74,93.2 167.83,93.1 167.83,92.96 167.74,92.86 166.24,92.86 166.14,92.76 166.14,92.63 166.24,92.53 167.74,92.53 167.83,92.43 167.83,92.29 167.74,92.19 166.24,92.19 166.14,92.09 166.14,91.96 166.24,91.86 169.48,91.86 v4(169.89,91.44)
DDR4_DIMM_CH0_DQ53: length 58.9
  L03_SIG1 w0.081: v4(139.16,81.43) 140.22,81.43 140.69,80.95 141.15,80.95 141.6,80.51 142.08,80.51 142.42,80.85 143.82,80.85 144.3,80.37 144.3,79.91 146.31,77.9 154.79,77.9 156.47,79.58 157.61,79.58 158.07,80.04 158.07,80.65 158.57,81.15 159.76,81.15 160.3,81.69 161.43,81.69 161.82,82.07 161.82,82.62 163.67,84.47 167.33,84.47 169.68,86.82 171.33,86.82 173.2,88.69 174.29,88.69 174.81,89.21 174.81,91.25 176.31,92.75 176.31,97.14 176.15,97.31 176.15,98.36 175.84,98.67 172.67,98.67 171.98,97.99 171.29,97.99 v4(170.74,97.44)
DDR4_DIMM_CH0_DQ54: length 56.9
  L03_SIG1 w0.081: v4(175.84,91.44) 176.09,91.19 176.09,90.17 175.99,90.07 175.85,90.07 175.75,90.17 175.75,90.91 175.66,91.01 175.52,91.01 175.42,90.91 175.42,88.91 175.25,88.74 174.9,88.74 174.8,88.64 174.8,88.5 174.9,88.4 176.12,88.4 176.21,88.3 176.21,88.16 176.12,88.06 173.71,88.06 173.62,87.97 173.62,87.83 173.71,87.73 175.54,87.73 175.64,87.63 175.64,87.49 175.54,87.39 173.7,87.39 173.61,87.3 173.61,87.16 173.7,87.06 174.98,87.06 175.07,86.96 175.07,86.82 174.98,86.72 174.26,86.72 174.14,86.6 174.14,86.03 174,85.9 173.79,85.9 173.66,86.03 173.66,86.61 173.55,86.72 172.99,86.72 172.17,85.91 169.4,85.91 167.52,84.03 164.56,84.03 161.7,81.16 160.64,81.16 160.01,80.53 160.01,79.97 159.78,79.75 158.36,79.75 157.79,79.17 156.83,79.17 154.62,76.96 146.46,76.96 146.13,77.29 146.13,77.52 143.73,79.93 v4(141.76,79.93)
DDR4_DIMM_CH0_DQ55: length 56.6
  L03_SIG1 w0.081: v4(141.76,78.93) 143.99,78.93 145.07,77.85 145.07,77.24 145.42,76.89 145.8,76.89 146.13,76.56 146.13,76.28 146.51,75.9 154.72,75.9 155.23,76.41 155.23,76.89 156.29,77.96 157.74,77.96 158.17,78.39 158.17,78.62 158.69,79.14 160.9,79.14 163.37,81.61 164.73,81.61 166.63,83.52 169.55,83.52 170.19,84.15 170.19,84.74 170.95,85.5 174.33,85.5 176.79,87.96 176.79,90.18 177.12,90.51 177.12,93.35 177.21,93.45 177.35,93.45 177.45,93.35 177.45,92.7 177.55,92.6 177.69,92.6 177.79,92.7 177.79,94.98 177.69,95.08 177.55,95.08 177.45,94.98 177.45,94.36 177.35,94.26 177.21,94.26 177.12,94.36 177.12,97.02 v4(176.69,97.44)
DDR4_DIMM_CH0_DQ56: length 67.7
  L07_SIG3 w0.089: v1(180.94,91.44) 180.69,91.44 179.93,90.68 178.17,90.68 178.08,90.58 178.08,90.44 178.17,90.35 179.6,90.35 179.7,90.25 179.7,90.11 179.6,90.01 177.67,90.01 175.61,87.95 167.71,87.95 167.62,87.85 167.62,87.72 167.71,87.62 168.79,87.62 168.89,87.52 168.89,87.38 168.79,87.28 167.71,87.28 167.62,87.18 167.62,87.05 167.71,86.95 167.9,86.95 168,86.85 168,86.71 167.9,86.61 166.23,86.61 166.13,86.51 166.13,86.37 166.23,86.28 166.95,86.28 167.05,86.18 167.05,86.04 166.95,85.94 162.91,85.94 161.73,84.76 161.73,84.41 159.87,82.55 159.87,82.2 159.07,81.39 158.89,81.39 158.73,81.55 158.59,81.55 158.4,81.36 158.4,81.22 158.56,81.06 158.56,80.88 157.43,79.75 156.2,79.75 155.15,78.71 155.15,78.34 154.74,77.93 146.23,77.93 146.13,78.03 146.13,78.41 146.03,78.51 145.89,78.51 145.79,78.41 145.79,78.03 145.7,77.93 145.56,77.93 145.46,78.03 145.46,78.41 145.36,78.51 145.22,78.51 145.12,78.41 145.12,78.03 145.03,77.93 144.89,77.93 144.79,78.03 144.79,78.41 144.69,78.51 144.55,78.51 144.45,78.41 144.45,78.03 144.36,77.93 144.22,77.93 144.12,78.03 144.12,78.41 144.02,78.51 143.88,78.51 143.78,78.41 143.78,78.03 143.68,77.93 143.55,77.93 143.45,78.03 143.45,78.41 143.35,78.51 143.21,78.51 143.11,78.41 143.11,78.03 143.01,77.93 142.45,77.93 141.97,77.45 141.61,77.45 141.13,77.93 140.77,77.93 140.29,77.45 139.86,77.45 139.38,76.96 139.05,76.96 138.52,76.44 138.14,76.44 137.62,75.92 137.39,75.92 137.01,75.55 137.01,74.81 136.56,74.35 v1(136.56,73.93)
DDR4_DIMM_CH0_DQ57: length 67.5
  L07_SIG3 w0.089: v1(181.79,97.44) 181.32,97.91 180.86,97.91 180.47,97.52 180.47,97.11 180.6,96.98 181.24,96.98 181.34,96.88 181.34,96.75 181.24,96.65 180.55,96.65 180.45,96.55 180.45,96.41 180.55,96.31 181.22,96.31 181.32,96.21 181.32,96.08 181.22,95.98 180.63,95.98 180.47,95.82 180.47,93.91 181.03,93.35 181.03,92.11 180.93,92.01 180.79,92.01 180.69,92.11 180.69,93.04 180.59,93.14 180.46,93.14 180.36,93.04 180.36,92.11 180.26,92.01 180.12,92.01 180.02,92.11 180.02,92.52 179.92,92.62 179.78,92.62 179.69,92.52 179.69,91.22 179.5,91.03 177.94,91.03 177.07,90.17 175.82,90.17 175.41,89.75 175.41,88.7 175.05,88.34 167.13,88.34 165.17,86.38 162.73,86.38 161.56,85.22 160.61,85.22 156.12,80.72 155.68,80.72 155.24,80.28 155.24,79.49 154.67,78.92 142.48,78.92 141.97,78.41 141.52,78.41 141.1,78.83 140.65,78.83 140.28,78.46 139.86,78.46 139.33,77.93 139,77.93 138.48,77.41 138.12,77.41 137.62,76.91 137.34,76.91 137,76.57 137,75.83 136.56,75.4 v1(136.56,74.93)
DDR4_DIMM_CH0_DQ58: length 69.1
  L07_SIG3 w0.089: v1(186.89,91.44) 185.5,90.05 185.5,88.29 182.74,85.53 179.42,84.15 177.57,82.31 174.29,80.95 171.92,78.58 171.92,78.07 171.49,77.64 168.36,77.64 166.93,76.21 166.75,76.21 166.6,76.36 166.6,76.54 167.94,77.88 167.94,78.06 167.79,78.21 167.61,78.21 165.69,76.3 163.73,76.3 161.36,73.93 158.85,73.93 157.87,72.95 156.81,72.95 156.69,72.82 156.69,72.36 156.56,72.23 156.34,72.23 156.22,72.36 156.22,72.82 156.09,72.95 155.87,72.95 155.75,72.82 155.75,72.36 155.62,72.23 155.4,72.23 155.28,72.36 155.28,72.82 155.15,72.95 154.95,72.95 153.93,71.94 152.57,71.94 151.29,72.47 149.49,72.47 148.95,71.94 144.48,71.94 144.13,72.29 144.13,72.52 143.84,72.81 142.41,72.81 141.92,73.3 141.35,73.3 141.1,73.05 140.57,73.05 140.24,73.38 139.68,73.38 139.35,73.05 138.87,73.05 138.62,73.3 138.14,73.3 137.67,72.84 137.01,72.84 136.73,72.55 136.41,72.55 135.92,73.04 135.92,73.2 v1(135.7,73.43)
DDR4_DIMM_CH0_DQ59: length 69.2
  L07_SIG3 w0.089: v1(135.7,74.43) 135.34,74.43 135.24,74.33 135.24,73.09 135.45,72.88 135.78,72.88 136.35,72.3 136.8,72.3 137.1,72.61 137.99,72.61 138.05,72.55 138.67,72.55 138.92,72.8 139.58,72.8 139.91,72.48 140.36,72.48 140.68,72.8 141.16,72.8 141.64,72.32 142.12,72.32 142.45,71.99 143.67,71.99 144.08,71.58 149.11,71.58 149.45,71.92 150.26,71.92 151.08,71.58 154.39,71.58 155.13,71.88 157.32,71.88 157.92,72.13 158.84,73.05 159.39,73.28 160.81,73.28 162.08,73.81 163.17,74.9 165.34,75.8 167.16,75.8 167.93,76.57 169.16,77.07 171.11,77.07 172.84,77.79 175.5,80.45 176.02,80.86 178.65,82.43 181.67,84.05 182.04,84.32 182.13,84.41 182.15,84.41 182.37,84.63 182.37,84.65 184.34,86.62 184.34,86.65 186.19,88.5 186.91,89.57 187.31,91.56 187.35,91.97 v1(187.74,97.44)
DDR4_DIMM_CH0_DQ60: length 66.4
  L07_SIG3 w0.089: v1(139.16,73.43) 139.04,73.55 138.09,73.55 137.58,73.05 137.15,73.05 136.72,73.48 136.42,73.48 136.15,73.75 136.15,77.17 136.41,77.42 136.79,77.42 137.29,77.93 137.62,77.93 138.08,78.39 138.49,78.39 139.05,78.95 139.33,78.95 139.81,79.43 140.16,79.43 140.65,79.91 141.56,79.91 141.66,79.81 141.66,79.11 141.76,79.01 141.9,79.01 142,79.11 142,79.81 142.1,79.91 143.04,79.91 143.14,79.81 143.14,79.43 143.24,79.33 143.38,79.33 143.48,79.43 143.48,79.81 143.57,79.91 143.71,79.91 143.81,79.81 143.81,79.43 143.91,79.33 144.05,79.33 144.15,79.43 144.15,79.81 144.25,79.91 144.38,79.91 144.48,79.81 144.48,79.43 144.58,79.33 144.72,79.33 144.82,79.43 144.82,79.81 144.92,79.91 145.05,79.91 145.15,79.81 145.15,79.43 145.25,79.33 145.39,79.33 145.49,79.43 145.49,79.81 145.59,79.91 145.73,79.91 145.82,79.81 145.82,79.43 145.92,79.33 146.06,79.33 146.16,79.43 146.16,79.81 146.26,79.91 153.5,79.91 154.46,80.88 154.72,80.88 155.07,81.23 155.07,81.49 155.76,82.17 156.09,82.17 156.22,82.05 156.36,82.05 156.46,82.14 156.46,82.28 156.23,82.51 156.23,82.65 157.21,83.62 157.35,83.62 157.7,83.27 157.84,83.27 157.93,83.37 157.93,83.51 157.59,83.86 157.59,84 157.68,84.1 157.82,84.1 158.17,83.75 158.31,83.75 158.41,83.84 158.41,83.98 158.06,84.33 158.06,84.47 159.35,85.76 161.42,85.76 162.49,86.83 164.82,86.83 166.73,88.75 174.65,88.75 174.97,89.07 174.97,90.12 175.52,90.66 176.77,90.66 178.01,91.9 178.78,91.9 v1(179.24,91.44)
DDR4_DIMM_CH0_DQ61: length 64
  L07_SIG3 w0.089: v1(180.09,97.44) 180.09,97.77 180.47,98.15 180.83,98.3 182.73,98.67 184.07,98.67 184.74,98 184.74,96.98 184.66,96.78 184.66,95.41 184.45,94.89 184.45,94.34 184.77,93.56 184.77,91.42 184.46,90.67 183.69,89.9 183.53,89.53 183.53,88.82 183.29,88.24 181.01,85.95 178.86,85.07 172.99,85.07 172.37,84.81 171.41,83.86 171.23,83.78 169.11,83.08 166.76,80.72 165.76,79.53 164.81,78.58 163.22,77.92 161.51,76.21 160.5,75.8 159.12,75.8 158.19,75.41 157.89,75.12 157.44,74.93 142.86,74.93 141.95,74.55 141.68,74.55 140.77,74.93 v1(140.03,74.93)
DDR4_DIMM_CH0_DQ62: length 65.9
  L07_SIG3 w0.089: v1(185.19,91.44) 185.19,90.83 184.73,90.37 184.73,89.17 181.23,85.67 176.58,83.75 175.74,83.75 175.62,83.62 175.62,83.26 175.51,83.16 175.25,83.16 175.15,83.26 175.15,83.62 175.02,83.75 174.8,83.75 174.68,83.62 174.68,83.09 174.55,82.96 174.33,82.96 174.21,83.09 174.21,84.04 174.08,84.16 173.86,84.16 173.74,84.04 173.74,82.75 173.61,82.62 173.39,82.62 173.27,82.75 173.27,83.62 173.14,83.75 172.92,83.75 172.8,83.62 172.8,83.21 172.69,83.11 170.75,83.11 170.14,82.5 170.14,81.85 170.4,81.6 171.6,81.6 171.7,81.49 171.7,81.16 171.6,81.06 168.84,81.06 165.23,77.45 163.31,77.45 161.27,75.42 159.19,75.42 158.35,75.07 158.01,74.73 157.11,74.35 154.34,74.35 153.91,73.92 147.66,73.92 147.53,74.04 147.53,74.42 147.4,74.55 147.19,74.55 147.06,74.42 147.06,74.04 146.93,73.92 144.55,73.92 144.42,74.04 144.42,74.4 144.29,74.53 144.08,74.53 143.95,74.4 143.95,74.04 143.82,73.92 143.61,73.92 143.48,74.04 143.48,74.4 143.35,74.53 143.14,74.53 143.01,74.4 143.01,74.04 142.88,73.92 142.45,73.92 142.06,74.3 141.59,74.3 141.34,74.05 140.5,74.05 140.12,74.43 v1(139.16,74.43)
DDR4_DIMM_CH0_DQ63: length 64.2
  L07_SIG3 w0.089: v1(186.04,97.44) 186.04,96.98 185.8,96.74 185.8,94.74 185.9,94.64 186.04,94.64 186.14,94.74 186.14,96.11 186.24,96.21 186.38,96.21 186.47,96.11 186.47,92.65 185.61,91.79 185.61,90.71 185.08,90.19 185.08,88.99 181.49,85.4 176.16,83.19 175.1,82.13 173.9,81.64 172.84,81.64 171.9,80.7 171.9,80.31 170.84,79.25 167.52,79.25 165.17,76.9 163.57,76.9 161.73,75.06 159.23,75.06 158.63,74.81 158.25,74.43 156.96,73.89 154.87,73.89 154.03,73.05 142.48,73.05 141.97,73.55 141.42,73.55 141.17,73.8 140.15,73.8 v1(140.03,73.93)
DDR4_DIMM_CH0_DQ64: length 45.8
  L16_SIG6 w0.081: v1(130.5,82.43) 130.27,82.43 129.82,82.88 129.82,85.39 129.14,86.07 129.14,87.11 129.04,87.21 128.32,87.21 127.47,88.06 127.47,88.56 127.2,88.84 126.51,88.84 124.34,91.01 123.88,91.01 123.54,91.35 123.54,91.9 123.34,92.11 122.98,92.11 122.62,91.75 121.49,91.75 121.41,91.83 120.4,91.83 120.24,91.66 119.32,91.66 119.15,91.83 116.1,91.83 115.99,91.71 114.98,91.71 114.87,91.83 112.84,91.83 112.06,91.05 110.8,91.05 110.43,90.68 108.45,90.68 107.41,91.72 107.41,92.26 107.96,92.81 107.96,96.16 107.87,96.26 107.73,96.26 107.63,96.16 107.63,94.44 107.53,94.34 107.39,94.34 107.29,94.44 107.29,96.36 107.2,96.46 107.06,96.46 106.96,96.36 106.96,94.04 107.18,93.82 107.18,92.62 106.99,92.44 v1(106.99,91.44)
DDR4_DIMM_CH0_DQ65: length 46.4
  L16_SIG6 w0.081: v1(129.64,81.93) 129.15,82.42 129.15,84.67 128.85,84.97 128.53,84.97 126.62,86.88 126.62,87.68 126.52,87.78 126.38,87.78 126.28,87.68 126.28,87.22 126.18,87.13 126.04,87.13 125.95,87.22 125.95,87.73 125.64,88.04 125.14,88.04 124.14,89.04 123.4,89.04 123.18,89.27 123.18,89.96 122.81,90.34 121.1,90.34 120.97,90.47 114.52,90.47 113.8,89.75 110.46,89.75 110.36,89.85 110.36,90.22 110.27,90.32 110.13,90.32 110.03,90.22 110.03,89.85 109.93,89.75 109.79,89.75 109.69,89.85 109.69,90.22 109.59,90.32 109.46,90.32 109.36,90.22 109.36,89.85 109.26,89.75 108.91,89.75 107.59,91.07 106.81,91.07 106.55,91.33 106.55,92.93 106.45,93.03 106.31,93.03 106.22,92.93 106.22,92.67 106.12,92.57 105.98,92.57 105.88,92.67 105.88,93.14 106.32,93.58 106.32,93.85 106.58,94.11 106.58,95.16 106.48,95.26 106.34,95.26 106.25,95.16 106.25,94.52 106.15,94.42 106.01,94.42 105.91,94.52 105.91,96.93 106.01,97.03 106.15,97.03 106.25,96.93 106.25,95.87 106.34,95.77 106.48,95.77 106.58,95.87 106.58,96.75 106.75,96.92 107.32,96.92 v1(107.84,97.44)
DDR4_DIMM_CH0_DQ66: length 45.8
  L16_SIG6 w0.081: v1(130.5,81.43) 130.09,81.84 130.09,82.06 129.48,82.66 129.48,85.25 128.83,85.91 128.07,85.91 127.12,86.85 127.12,86.99 127.24,87.1 127.37,87.1 128.14,86.34 128.28,86.34 128.39,86.45 128.39,86.67 127.13,87.93 126.87,87.93 124.17,90.63 124.03,90.63 123.93,90.53 123.93,90.39 125.28,89.04 125.28,88.9 125.18,88.8 124.94,88.8 123,90.74 121.29,90.74 121.19,90.84 121.19,90.98 121.29,91.08 122.98,91.08 123.08,91.18 123.08,91.32 122.98,91.41 121.11,91.41 120.52,90.83 120.34,90.83 120.24,90.93 120.24,91.23 120.14,91.33 120,91.33 119.9,91.23 119.9,90.92 119.8,90.82 119.66,90.82 119.57,90.92 119.57,91.23 119.47,91.33 119.33,91.33 119.23,91.23 119.23,90.93 119.13,90.83 118.1,90.83 117.44,91.49 117.01,91.49 116.39,90.87 116.09,90.87 115.99,90.97 115.99,91.27 115.9,91.37 115.76,91.37 115.66,91.27 115.66,90.97 115.56,90.87 115.42,90.87 115.32,90.97 115.32,91.27 115.23,91.37 115.09,91.37 114.99,91.27 114.99,90.97 114.89,90.87 114.44,90.87 113.66,90.09 110.88,90.09 110.74,90.23 110.74,90.41 110.88,90.55 113.46,90.55 113.6,90.7 113.6,90.93 113.51,91.02 113.13,91.02 112.99,91.16 v1(112.99,91.44)
DDR4_DIMM_CH0_DQ67: length 46.4
  L16_SIG6 w0.081: v1(129.64,80.93) 129.97,80.6 129.97,80.38 130.91,79.44 132.6,79.44 133.69,80.53 133.69,81.16 133.54,81.31 133.54,81.55 133.89,81.89 133.96,81.89 135.23,83.15 135.23,89.52 132.37,92.38 131.48,92.38 131.24,92.62 131.24,92.92 130.92,93.23 129.27,93.23 126.54,95.96 125.5,95.96 125.37,96.09 123.97,96.09 123.04,97.02 121.49,97.02 121.39,96.93 121.39,96.79 121.49,96.69 122.57,96.69 122.67,96.59 122.67,96.45 122.57,96.35 121.26,96.35 120.58,97.02 118.68,97.02 118.52,97.19 115.77,97.19 115.53,96.96 115.53,96.28 115.44,96.18 115.3,96.18 115.2,96.28 115.2,96.96 115.1,97.05 114.96,97.05 114.86,96.96 114.86,96.28 114.77,96.18 114.63,96.18 114.53,96.28 114.53,96.96 114.43,97.05 114.18,97.05 v1(113.79,97.44)
