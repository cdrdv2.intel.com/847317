# Allegro board TS28247BC0_FM61_agilex_PCIe_DEVKIT_ADI_REVB1.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
FDMC8878_VER2
  rect 0.406x0.914 smd: 1(-0.975,-1.643) 2(-0.325,-1.643) 3(0.325,-1.643) 4(0.975,-1.643)
  custom 0.589x0.589 smd: 5(0,0.85)
HDR2X1_100MIL
  rect 1.6x1.6 hole 1.092: 1(0,0)
  round 1.6 hole 1.092: 2(2.54,0)
IFSC1008ABER1R0M01
  rect 1.372x2.261 smd: 1(-1.086,0) 2(1.086,0)
IND_0603
  rect 1.016x1.016 smd: 1(-0.762,0) 2(0.762,0)
IND_FP1008R-CUS
  rect 3.56x3 smd: 1(-3.81,0) 2(3.81,0)
IND_XGL5030
  rect 1.18x4.7 smd: 1(-1.655,0) 2(1.655,0)
LED0603_4PIN_APHB1608
  rect 0.787x0.406 smd: 1(0.744,-0.353) 2(-0.744,-0.353) 3(0.744,0.353) 4(-0.744,0.353)
LED_0603
  rect 1.092x0.991 smd: A(-0.851,0) C(0.851,0)
LGA25
  round 0.559 smd: A1(-2.54,2.54) A2(-1.27,2.54) A3(0,2.54) A4(1.27,2.54) A5(2.54,2.54) B1(-2.54,1.27) B2(-1.27,1.27) B3(0,1.27) B4(1.27,1.27) B5(2.54,1.27) C1(-2.54,0) C2(-1.27,0) C3(0,0) C4(1.27,0) C5(2.54,0) D1(-2.54,-1.27) D2(-1.27,-1.27) D3(0,-1.27) D4(1.27,-1.27) D5(2.54,-1.27) E1(-2.54,-2.54) E2(-1.27,-2.54) E3(0,-2.54) E4(1.27,-2.54) E5(2.54,-2.54)
LGA25C127P5X5_625X625X192N
  round 0.73 smd: A1(-2.54,2.54) A2(-1.27,2.54) A3(0,2.54) A4(1.27,2.54) A5(2.54,2.54) B1(-2.54,1.27) B2(-1.27,1.27) B3(0,1.27) B4(1.27,1.27) B5(2.54,1.27) C1(-2.54,0) C2(-1.27,0) C3(0,0) C4(1.27,0) C5(2.54,0) D1(-2.54,-1.27) D2(-1.27,-1.27) D3(0,-1.27) D4(1.27,-1.27) D5(2.54,-1.27) E1(-2.54,-2.54) E2(-1.27,-2.54) E3(0,-2.54) E4(1.27,-2.54) E5(2.54,-2.54)
LGA68S127P7X11_900X1500X292
  rect 0.73x0.73 smd: A1(-3.81,6.35) A2(-3.81,5.08) A3(-3.81,3.81) A4(-3.81,2.54) A5(-3.81,1.27) A6(-3.81,0) A7(-3.81,-1.27) A8(-3.81,-2.54) A9(-3.81,-3.81) A10(-3.81,-5.08) A11(-3.81,-6.35) B1(-2.54,6.35) B3(-2.54,3.81) B4(-2.54,2.54) B5(-2.54,1.27) B7(-2.54,-1.27) B8(-2.54,-2.54) B9(-2.54,-3.81) B10(-2.54,-5.08) B11(-2.54,-6.35) C1(-1.27,6.35) C3(-1.27,3.81) C4(-1.27,2.54) C5(-1.27,1.27) C7(-1.27,-1.27) C8(-1.27,-2.54) C9(-1.27,-3.81) C10(-1.27,-5.08) C11(-1.27,-6.35) D1(0,6.35) D3(0,3.81) D4(0,2.54) D5(0,1.27) D7(0,-1.27) D8(0,-2.54) D9(0,-3.81) D10(0,-5.08) D11(0,-6.35) E1(1.27,6.35) E3(1.27,3.81) E5(1.27,1.27) E7(1.27,-1.27) E8(1.27,-2.54) E9(1.27,-3.81) E10(1.27,-5.08) E11(1.27,-6.35) F1(2.54,6.35) F2(2.54,5.08) F3(2.54,3.81) F4(2.54,2.54) F5(2.54,1.27) F6(2.54,0) F7(2.54,-1.27) F8(2.54,-2.54) F9(2.54,-3.81) F10(2.54,-5.08) F11(2.54,-6.35) G1(3.81,6.35) G2(3.81,5.08) G3(3.81,3.81) G4(3.81,2.54) G5(3.81,1.27) G6(3.81,0) G7(3.81,-1.27) G8(3.81,-2.54) G9(3.81,-3.81) G10(3.81,-5.08) G11(3.81,-6.35)
LGA108C127P9X12_1190X1600X192N
  round 0.63 smd: A1(-5.08,6.985) A2(-3.81,6.985) A3(-2.54,6.985) A4(-1.27,6.985) A5(0,6.985) A6(1.27,6.985) A7(2.54,6.985) A8(3.81,6.985) A9(5.08,6.985) B1(-5.08,5.715) B2(-3.81,5.715) B3(-2.54,5.715) B4(-1.27,5.715) B5(0,5.715) B6(1.27,5.715) B7(2.54,5.715) B8(3.81,5.715) B9(5.08,5.715) C1(-5.08,4.445) C2(-3.81,4.445) C3(-2.54,4.445) C4(-1.27,4.445) C5(0,4.445) C6(1.27,4.445) C7(2.54,4.445) C8(3.81,4.445) C9(5.08,4.445) D1(-5.08,3.175) D2(-3.81,3.175) D3(-2.54,3.175) D4(-1.27,3.175) D5(0,3.175) D6(1.27,3.175) D7(2.54,3.175) D8(3.81,3.175) D9(5.08,3.175) E1(-5.08,1.905) E2(-3.81,1.905) E3(-2.54,1.905) E4(-1.27,1.905) E5(0,1.905) E6(1.27,1.905) E7(2.54,1.905) E8(3.81,1.905) E9(5.08,1.905) F1(-5.08,0.635) F2(-3.81,0.635) F3(-2.54,0.635) F4(-1.27,0.635) F5(0,0.635) F6(1.27,0.635) F7(2.54,0.635) F8(3.81,0.635) F9(5.08,0.635) G1(-5.08,-0.635) G2(-3.81,-0.635) G3(-2.54,-0.635) G4(-1.27,-0.635) G5(0,-0.635) G6(1.27,-0.635) G7(2.54,-0.635) G8(3.81,-0.635) G9(5.08,-0.635) H1(-5.08,-1.905) H2(-3.81,-1.905) H3(-2.54,-1.905) H4(-1.27,-1.905) H5(0,-1.905) H6(1.27,-1.905) H7(2.54,-1.905) H8(3.81,-1.905) H9(5.08,-1.905) J1(-5.08,-3.175) J2(-3.81,-3.175) J3(-2.54,-3.175) J4(-1.27,-3.175) J5(0,-3.175) J6(1.27,-3.175) J7(2.54,-3.175) J8(3.81,-3.175) J9(5.08,-3.175) K1(-5.08,-4.445) K2(-3.81,-4.445) K3(-2.54,-4.445) K4(-1.27,-4.445) K5(0,-4.445) K6(1.27,-4.445) K7(2.54,-4.445) K8(3.81,-4.445) K9(5.08,-4.445) L1(-5.08,-5.715) L2(-3.81,-5.715) L3(-2.54,-5.715) L4(-1.27,-5.715) L5(0,-5.715) L6(1.27,-5.715) L7(2.54,-5.715) L8(3.81,-5.715) L9(5.08,-5.715) M1(-5.08,-6.985) M2(-3.81,-6.985) M3(-2.54,-6.985) M4(-1.27,-6.985) M5(0,-6.985) M6(1.27,-6.985) M7(2.54,-6.985) M8(3.81,-6.985) M9(5.08,-6.985)
LIGHTPIPE_P-U90-1101-T00A-BP
  round 1.549 hole 1.549 unplated: (0,0) (0,-4) (2.1,-8)
LQFN_28_5MMX4MM
  rect 0.375x0.375 smd: (-1.812,2.312) (-1.812,-2.312) (1.812,2.312) (1.812,-2.312)
  oval 0.787x0.279 smd: 1(-1.994,1.75) 2(-1.994,1.25) 3(-1.994,0.75) 4(-1.994,0.25) 5(-1.994,-0.25) 6(-1.994,-0.75) 7(-1.994,-1.25) 8(-1.994,-1.75) 15(1.994,-1.75) 16(1.994,-1.25) 17(1.994,-0.75) 18(1.994,-0.25) 19(1.994,0.25) 20(1.994,0.75) 21(1.994,1.25) 22(1.994,1.75)
  oval 0.279x0.787 smd: 9(-1.25,-2.494) 10(-0.75,-2.494) 11(-0.25,-2.494) 12(0.25,-2.494) 13(0.75,-2.494) 14(1.25,-2.494) 23(1.25,2.494) 24(0.75,2.494) 25(0.25,2.494) 26(-0.25,2.494) 27(-0.75,2.494) 28(-1.25,2.494)
  rect 1.092x1.575 smd: 29(0.673,0.927) 30(-0.673,0.927) 31(-0.673,-0.927) 32(0.673,-0.927)
LTC-BGA-49-1518
  round 0.406 smd: A1(-2.4,2.4) A2(-1.6,2.4) A3(-0.8,2.4) A4(0,2.4) A5(0.8,2.4) A6(1.6,2.4) A7(2.4,2.4) B1(-2.4,1.6) B2(-1.6,1.6) B3(-0.8,1.6) B4(0,1.6) B5(0.8,1.6) B6(1.6,1.6) B7(2.4,1.6) C1(-2.4,0.8) C2(-1.6,0.8) C3(-0.8,0.8) C4(0,0.8) C5(0.8,0.8) C6(1.6,0.8) C7(2.4,0.8) D1(-2.4,0) D2(-1.6,0) D3(-0.8,0) D4(0,0) D5(0.8,0) D6(1.6,0) D7(2.4,0) E1(-2.4,-0.8) E2(-1.6,-0.8) E3(-0.8,-0.8) E4(0,-0.8) E5(0.8,-0.8) E6(1.6,-0.8) E7(2.4,-0.8) F1(-2.4,-1.6) F2(-1.6,-1.6) F3(-0.8,-1.6) F4(0,-1.6) F5(0.8,-1.6) F6(1.6,-1.6) F7(2.4,-1.6) G1(-2.4,-2.4) G2(-1.6,-2.4) G3(-0.8,-2.4) G4(0,-2.4) G5(0.8,-2.4) G6(1.6,-2.4) G7(2.4,-2.4)
MH_D125C175T_TB315
  round 8.001 hole 3.175: 1(0,0)
MLX_SD-5569_8POS_RA
  round 2.997 hole 2.997 unplated: (0,7.29) (12.573,7.29)
  rect 2.286x2.286 hole 1.803: 1(0,0)
  round 2.286 hole 1.803: 2(4.191,0) 3(8.382,0) 4(12.573,0) 5(0,-4.202) 6(4.191,-4.202) 7(8.382,-4.202) 8(12.573,-4.202)
MOLEX-MICRO-USB-47589-001
  rect 1.8x1.9 smd: (-1.15,0) (1.15,0)
  rect 0.406x1.346 smd: 1(1.3,-2.673) 2(0.65,-2.673) 3(0,-2.673) 4(-0.65,-2.673) 5(-1.3,-2.673)
  oval 1.05x1.25 hole 0.65x0.85: 6(-2.225,-3) 7(2.225,-3)
  rect 2.075x1.9 hole 1.3x0.6: 8(-4.175,0) 9(4.175,0)
MOLEX_0470533000
  round 1.245 hole 1.245 unplated: (-5.08,-2.16)
  rect 1.524x1.524 hole 1.016: 1(0,0)
  round 1.524 hole 1.016: 2(-2.54,0) 3(-5.08,0) 4(-7.62,0)
MOLEX_0702461004
  rect 1.648x1.648 hole 1.14: 1(0,0)
  round 1.648 hole 1.14: 2(0,2.54) 3(2.54,0) 4(2.54,2.54) 5(5.08,0) 6(5.08,2.54) 7(7.62,0) 8(7.62,2.54) 9(10.16,0) 10(10.16,2.54)
MOLEX_QSFPDD_CAGE
  rect 2.007x4.013 hole 1.05: 1(0,0) 2(0,10.7) 3(0,19.7) 4(0,28.7) 5(0,37.7) 6(-19,-4.5) 7(-19,6.2) 8(-19,15.2) 9(-19,24.2) 10(-19,33.2)
  round 1.575 hole 1.05: 11(-4.5,-20) 12(-11.7,-20)
MSOP8
  rect 0.406x1.651 smd: 1(-0.975,-2.225) 2(-0.325,-2.225) 3(0.325,-2.225) 4(0.975,-2.225) 5(0.975,2.225) 6(0.325,2.225) 7(-0.325,2.225) 8(-0.975,2.225)
MSOP-8
  rect 0.406x1.778 smd: 1(-0.975,-2.271) 2(-0.325,-2.271) 3(0.325,-2.271) 4(0.975,-2.271) 5(0.975,2.271) 6(0.325,2.271) 7(-0.325,2.271) 8(-0.975,2.271)
MT_HOLE
  round 3.048 hole 2.032: 1(0,0)
NFET_PSMN1R0-30YLD
  rect 0.635x1.6 smd: 1(-1.905,-2.8) 2(-0.635,-2.8) 3(0.635,-2.8) 4(1.905,-2.8)
  rect 4.674x4.775 smd: 5(0,1.213)
OSC7050
  rect 1.676x1.753 smd: 1(-2.54,-2.076) 2(2.54,-2.076) 3(2.54,2.076) 4(-2.54,2.076)
PADSTYLE1
  round 0.762 smd: 1(0,0)
PCIX-16PORT
  rect 0.711x3.2 smd: A1(0,0.432) B17(18,0.432) B31(32,0.432) B48(49,0.432) B81(82,0.432)
  rect 0.711x4.064 smd: A2(1,0) A3(2,0) A4(3,0) A5(4,0) A6(5,0) A7(6,0) A8(7,0) A9(8,0) A10(9,0) A11(10,0) A12(13,0) A13(14,0) A14(15,0) A15(16,0) A16(17,0) A17(18,0) A18(19,0) A19(20,0) A20(21,0) A21(22,0) A22(23,0) A23(24,0) A24(25,0) A25(26,0) A26(27,0) A27(28,0) A28(29,0) A29(30,0) A30(31,0) A31(32,0) A32(33,0) A33(34,0) A34(35,0) A35(36,0) A36(37,0) A37(38,0) A38(39,0) A39(40,0) A40(41,0) A41(42,0) A42(43,0) A43(44,0) A44(45,0) A45(46,0) A46(47,0) A47(48,0) A48(49,0) A49(50,0) A50(51,0) A51(52,0) A52(53,0) A53(54,0) A54(55,0) A55(56,0) A56(57,0) A57(58,0) A58(59,0) A59(60,0) A60(61,0) A61(62,0) A62(63,0) A63(64,0) A64(65,0) A65(66,0) A66(67,0) A67(68,0) A68(69,0) A69(70,0) A70(71,0) A71(72,0) A72(73,0) A73(74,0) A74(75,0) A75(76,0) A76(77,0) A77(78,0) A78(79,0) A79(80,0) A80(81,0) A81(82,0) A82(83,0) B1(0,0) B2(1,0) B3(2,0) B4(3,0) B5(4,0) B6(5,0) B7(6,0) B8(7,0) B9(8,0) B10(9,0) B11(10,0) B12(13,0) B13(14,0) B14(15,0) B15(16,0) B16(17,0) B18(19,0) B19(20,0) B20(21,0) B21(22,0) B22(23,0) B23(24,0) B24(25,0) B25(26,0) B26(27,0) B27(28,0) B28(29,0) B29(30,0) B30(31,0) B32(33,0) B33(34,0) B34(35,0) B35(36,0) B36(37,0) B37(38,0) B38(39,0) B39(40,0) B40(41,0) B41(42,0) B42(43,0) B43(44,0) B44(45,0) B45(46,0) B46(47,0) B47(48,0) B49(50,0) B50(51,0) B51(52,0) B52(53,0) B53(54,0) B54(55,0) B55(56,0) B56(57,0) B57(58,0) B58(59,0) B59(60,0) B60(61,0) B61(62,0) B62(63,0) B63(64,0) B64(65,0) B65(66,0) B66(67,0) B67(68,0) B68(69,0) B69(70,0) B70(71,0) B71(72,0) B72(73,0) B73(74,0) B74(75,0) B75(76,0) B76(77,0) B77(78,0) B78(79,0) B79(80,0) B80(81,0) B82(83,0)
QFN32-FTDI
  custom 0.07x0.07 smd: 1(-2.305,1.75) 8(-2.305,-1.75) 9(-1.75,-2.305) 16(1.75,-2.305) 17(2.305,-1.75) 24(2.305,1.75) 25(1.75,2.305) 32(-1.75,2.305)
  rect 0.61x0.279 smd: 2(-2.305,1.25) 3(-2.305,0.75) 4(-2.305,0.25) 5(-2.305,-0.25) 6(-2.305,-0.75) 7(-2.305,-1.25) 18(2.305,-1.25) 19(2.305,-0.75) 20(2.305,-0.25) 21(2.305,0.25) 22(2.305,0.75) 23(2.305,1.25)
  rect 0.279x0.61 smd: 10(-1.25,-2.305) 11(-0.75,-2.305) 12(-0.25,-2.305) 13(0.25,-2.305) 14(0.75,-2.305) 15(1.25,-2.305) 26(1.25,2.305) 27(0.75,2.305) 28(0.25,2.305) 29(-0.25,2.305) 30(-0.75,2.305) 31(-1.25,2.305)
  rect 3.2x3.2 smd: 33(0,0)
QFN40P500X800X80-53N
  rect 0.69x0.22 smd: 1(-2.42,3.2) 2(-2.42,2.8) 3(-2.42,2.4) 4(-2.42,2) 5(-2.42,1.6) 6(-2.42,1.2) 7(-2.42,0.8) 8(-2.42,0.4) 9(-2.42,0) 10(-2.42,-0.4) 11(-2.42,-0.8) 12(-2.42,-1.2) 13(-2.42,-1.6) 14(-2.42,-2) 15(-2.42,-2.4) 16(-2.42,-2.8) 17(-2.42,-3.2) 27(2.42,-3.2) 28(2.42,-2.8) 29(2.42,-2.4) 30(2.42,-2) 31(2.42,-1.6) 32(2.42,-1.2) 33(2.42,-0.8) 34(2.42,-0.4) 35(2.42,0) 36(2.42,0.4) 37(2.42,0.8) 38(2.42,1.2) 39(2.42,1.6) 40(2.42,2) 41(2.42,2.4) 42(2.42,2.8) 43(2.42,3.2)
  rect 0.22x0.69 smd: 18(-1.6,-3.92) 19(-1.2,-3.92) 20(-0.8,-3.92) 21(-0.4,-3.92) 22(0,-3.92) 23(0.4,-3.92) 24(0.8,-3.92) 25(1.2,-3.92) 26(1.6,-3.92) 44(1.6,3.92) 45(1.2,3.92) 46(0.8,3.92) 47(0.4,3.92) 48(0,3.92) 49(-0.4,3.92) 50(-0.8,3.92) 51(-1.2,3.92) 52(-1.6,3.92)
  rect 3.75x6.75 smd: 53(0,0)
QFN48
  oval 0.838x0.279 smd: 1(-3.469,2.75) 2(-3.469,2.25) 3(-3.469,1.75) 4(-3.469,1.25) 5(-3.469,0.75) 6(-3.469,0.25) 7(-3.469,-0.25) 8(-3.469,-0.75) 9(-3.469,-1.25) 10(-3.469,-1.75) 11(-3.469,-2.25) 12(-3.469,-2.75) 25(3.469,-2.75) 26(3.469,-2.25) 27(3.469,-1.75) 28(3.469,-1.25) 29(3.469,-0.75) 30(3.469,-0.25) 31(3.469,0.25) 32(3.469,0.75) 33(3.469,1.25) 34(3.469,1.75) 35(3.469,2.25) 36(3.469,2.75)
  oval 0.279x0.838 smd: 13(-2.75,-3.469) 14(-2.25,-3.469) 15(-1.75,-3.469) 16(-1.25,-3.469) 17(-0.75,-3.469) 18(-0.25,-3.469) 19(0.25,-3.469) 20(0.75,-3.469) 21(1.25,-3.469) 22(1.75,-3.469) 23(2.25,-3.469) 24(2.75,-3.469) 37(2.75,3.469) 38(2.25,3.469) 39(1.75,3.469) 40(1.25,3.469) 41(0.75,3.469) 42(0.25,3.469) 43(-0.25,3.469) 44(-0.75,3.469) 45(-1.25,3.469) 46(-1.75,3.469) 47(-2.25,3.469) 48(-2.75,3.469)
  rect 3.556x3.556 smd: 49(0,0)
QFN56
  oval 0.813x0.279 smd: 1(-3.9,3.25) 2(-3.9,2.75) 3(-3.9,2.25) 4(-3.9,1.75) 5(-3.9,1.25) 6(-3.9,0.75) 7(-3.9,0.25) 8(-3.9,-0.25) 9(-3.9,-0.75) 10(-3.9,-1.25) 11(-3.9,-1.75) 12(-3.9,-2.25) 13(-3.9,-2.75) 14(-3.9,-3.25) 29(3.9,-3.25) 30(3.9,-2.75) 31(3.9,-2.25) 32(3.9,-1.75) 33(3.9,-1.25) 34(3.9,-0.75) 35(3.9,-0.25) 36(3.9,0.25) 37(3.9,0.75) 38(3.9,1.25) 39(3.9,1.75) 40(3.9,2.25) 41(3.9,2.75) 42(3.9,3.25)
  oval 0.279x0.813 smd: 15(-3.25,-3.9) 16(-2.75,-3.9) 17(-2.25,-3.9) 18(-1.75,-3.9) 19(-1.25,-3.9) 20(-0.75,-3.9) 21(-0.25,-3.9) 22(0.25,-3.9) 23(0.75,-3.9) 24(1.25,-3.9) 25(1.75,-3.9) 26(2.25,-3.9) 27(2.75,-3.9) 28(3.25,-3.9) 43(3.25,3.9) 44(2.75,3.9) 45(2.25,3.9) 46(1.75,3.9) 47(1.25,3.9) 48(0.75,3.9) 49(0.25,3.9) 50(-0.25,3.9) 51(-0.75,3.9) 52(-1.25,3.9) 53(-1.75,3.9) 54(-2.25,3.9) 55(-2.75,3.9) 56(-3.25,3.9)
  rect 5.842x5.842 smd: 57(0,0)
QFN64_9X9_SI5341
  oval 0.86x0.28 smd: 1(-4.45,3.75) 2(-4.45,3.25) 3(-4.45,2.75) 4(-4.45,2.25) 5(-4.45,1.75) 6(-4.45,1.25) 7(-4.45,0.75) 8(-4.45,0.25) 9(-4.45,-0.25) 10(-4.45,-0.75) 11(-4.45,-1.25) 12(-4.45,-1.75) 13(-4.45,-2.25) 14(-4.45,-2.75) 15(-4.45,-3.25) 16(-4.45,-3.75) 33(4.45,-3.75) 34(4.45,-3.25) 35(4.45,-2.75) 36(4.45,-2.25) 37(4.45,-1.75) 38(4.45,-1.25) 39(4.45,-0.75) 40(4.45,-0.25) 41(4.45,0.25) 42(4.45,0.75) 43(4.45,1.25) 44(4.45,1.75) 45(4.45,2.25) 46(4.45,2.75) 47(4.45,3.25) 48(4.45,3.75)
  oval 0.28x0.86 smd: 17(-3.75,-4.45) 18(-3.25,-4.45) 19(-2.75,-4.45) 20(-2.25,-4.45) 21(-1.75,-4.45) 22(-1.25,-4.45) 23(-0.75,-4.45) 24(-0.25,-4.45) 25(0.25,-4.45) 26(0.75,-4.45) 27(1.25,-4.45) 28(1.75,-4.45) 29(2.25,-4.45) 30(2.75,-4.45) 31(3.25,-4.45) 32(3.75,-4.45) 49(3.75,4.45) 50(3.25,4.45) 51(2.75,4.45) 52(2.25,4.45) 53(1.75,4.45) 54(1.25,4.45) 55(0.75,4.45) 56(0.25,4.45) 57(-0.25,4.45) 58(-0.75,4.45) 59(-1.25,4.45) 60(-1.75,4.45) 61(-2.25,4.45) 62(-2.75,4.45) 63(-3.25,4.45) 64(-3.75,4.45)
  rect 5.309x5.309 smd: 65(0,0)
R0402
  rect 0.508x0.508 smd: 1(0,0.445) 2(0,-0.445)
RES_CSNL2512_0_005-0_006
  rect 2.38x3.4 smd: 1(-2.21,0) 2(2.21,0)
RESC1005X40L20L
  rect 0.508x0.508 smd: 1(0,0.445) 2(0,-0.445)
RESC1608X60L27N
  rect 1.016x1.016 smd: 1(-0.762,0) 2(0.762,0)
SC70_TI
  rect 0.406x1.245 smd: 1(-0.65,-0.997) 2(0,-0.997) 3(0.65,-0.997) 4(0.65,0.997) 5(-0.65,0.997)
SHORT
  rect 0.305x0.406 smd: 1(0,0.254) 2(0,-0.254)
SI510
  rect 1.854x1.905 smd: 1(-2.54,-1.952) 2(0,-1.952) 3(2.54,-1.952) 4(2.54,1.952) 5(0,1.952) 6(-2.54,1.952)
SI52202
  oval 0.229x0.686 smd: 1(-0.8,-1.543) 2(-0.4,-1.543) 3(0,-1.543) 4(0.4,-1.543) 5(0.8,-1.543) 11(0.8,1.543) 12(0.4,1.543) 13(0,1.543) 14(-0.4,1.543) 15(-0.8,1.543)
  oval 0.686x0.229 smd: 6(1.543,-0.8) 7(1.543,-0.4) 8(1.543,0) 9(1.543,0.4) 10(1.543,0.8) 16(-1.543,0.8) 17(-1.543,0.4) 18(-1.543,0) 19(-1.543,-0.4) 20(-1.543,-0.8)
  rect 1.651x1.651 smd: 21(0,0)
SL1616A-R06LU
  rect 1.956x1.905 smd: 1(-1.428,0) 2(1.428,0)
SMT38
  round 0.762 hole 0.762 unplated: (-15.113,-0.991) (15.113,0)
  round 2.388 hole 2.388 unplated: (11.43,0)
  rect 0.432x1.27 smd: 1(5.715,3.531) 2(5.715,-3.531) 3(5.08,3.531) 4(5.08,-3.531) 5(4.445,3.531) 6(4.445,-3.531) 7(3.81,3.531) 8(3.81,-3.531) 9(3.175,3.531) 10(3.175,-3.531) 11(2.54,3.531) 12(2.54,-3.531) 13(1.905,3.531) 14(1.905,-3.531) 15(1.27,3.531) 16(1.27,-3.531) 17(0.635,3.531) 18(0.635,-3.531) 19(0,3.531) 20(0,-3.531) 21(-0.635,3.531) 22(-0.635,-3.531) 23(-1.27,3.531) 24(-1.27,-3.531) 25(-1.905,3.531) 26(-1.905,-3.531) 27(-2.54,3.531) 28(-2.54,-3.531) 29(-3.175,3.531) 30(-3.175,-3.531) 31(-3.81,3.531) 32(-3.81,-3.531) 33(-4.445,3.531) 34(-4.445,-3.531) 35(-5.08,3.531) 36(-5.08,-3.531) 37(-5.715,3.531) 38(-5.715,-3.531)
  round 1.321 hole 0.813: 39(5.08,0) 40(2.54,0) 41(0,0) 42(-2.54,0) 43(-5.08,0)
SON6
  rect 0.279x0.686 smd: 1(-0.5,-0.468)
  rect 0.279x0.66 smd: 2(0,-0.48) 3(0.5,-0.48) 4(0.5,0.48) 5(0,0.48) 6(-0.5,0.48)
SOT23
  rect 1.016x1.422 smd: 1(-0.95,-1.1) 2(0.95,-1.1) 3(0,1.1)
SOT23-3
  rect 0.965x1.422 smd: 1(-0.95,-1.111) 2(0.95,-1.111) 3(0,1.111)
SOT23-8P
  rect 1.219x0.508 smd: 1(-1.31,0.975) 2(-1.31,0.325) 3(-1.31,-0.325) 4(-1.31,-0.975) 5(1.31,-0.975) 6(1.31,-0.325) 7(1.31,0.325) 8(1.31,0.975)
SOT-143
  rect 1.321x1.143 smd: 1(-1.06,0.762)
  rect 1.321x0.762 smd: 2(-1.06,-0.965) 3(1.06,-0.965) 4(1.06,0.965)
STAR_VIA
  round 0.508 smd: 1(0,0)
T-PBGA24
  round 0.406 smd: A2(-1,2) A3(0,2) A4(1,2) A5(2,2) B1(-2,1) B2(-1,1) B3(0,1) B4(1,1) B5(2,1) C1(-2,0) C2(-1,0) C3(0,0) C4(1,0) C5(2,0) D1(-2,-1) D2(-1,-1) D3(0,-1) D4(1,-1) D5(2,-1) E1(-2,-2) E2(-1,-2) E3(0,-2) E4(1,-2) E5(2,-2)
TPS22902BYFPR
  round 0.229 smd: A1(-0.2,0.2) A2(0.2,0.2) B1(-0.2,-0.2) B2(0.2,-0.2)
TSLP-3-7
  rect 0.279x0.635 smd: 1(-0.24,-0.468) 2(0.24,-0.468)
  rect 0.762x0.635 smd: 3(0,0.468)
TSSOP20
  rect 0.406x1.778 smd: 1(-2.925,-2.946) 2(-2.275,-2.946) 3(-1.625,-2.946) 4(-0.975,-2.946) 5(-0.325,-2.946) 6(0.325,-2.946) 7(0.975,-2.946) 8(1.625,-2.946) 9(2.275,-2.946) 10(2.925,-2.946) 11(2.925,2.946) 12(2.275,2.946) 13(1.625,2.946) 14(0.975,2.946) 15(0.325,2.946) 16(-0.325,2.946) 17(-0.975,2.946) 18(-1.625,2.946) 19(-2.275,2.946) 20(-2.925,2.946)
TSSOP-14
  rect 1.499x0.406 smd: 1(-2.95,1.95) 2(-2.95,1.3) 3(-2.95,0.65) 4(-2.95,0) 5(-2.95,-0.65) 6(-2.95,-1.3) 7(-2.95,-1.95) 8(2.95,-1.95) 9(2.95,-1.3) 10(2.95,-0.65) 11(2.95,0) 12(2.95,0.65) 13(2.95,1.3) 14(2.95,1.95)
TVS_5P0SMDJ12A
  rect 2.438x3.454 smd: 1(3.378,0) 2(-3.378,0)
UMLP
  rect 0.45x0.25 smd: 1(-0.5,0)
  rect 0.25x0.35 smd: 2(-0.4,-0.45) 3(0,-0.45) 4(0.4,-0.45) 6(0.4,0.45) 7(0,0.45) 8(-0.4,0.45)
  rect 0.35x0.25 smd: 5(0.55,0)
unnamed#2
  round 7 hole 4.6: 1(0,0)
unnamed#3
  round 0 smd: 1(0.02,0.198)
unnamed#4
  round 1.016 smd: (0,0)
UQFN-16
  rect 0.203x0.889 smd: 1(-0.6,-0.843)
  rect 0.203x0.787 smd: 2(-0.2,-0.894) 3(0.2,-0.894) 4(0.6,-0.894) 9(0.6,0.894) 10(0.2,0.894) 11(-0.2,0.894) 12(-0.6,0.894)
  rect 0.787x0.203 smd: 5(1.294,-0.6) 6(1.294,-0.2) 7(1.294,0.2) 8(1.294,0.6) 13(-1.294,0.6) 14(-1.294,0.2) 15(-1.294,-0.2) 16(-1.294,-0.6)
VFBGA-153
  round 0.254 smd: A1(-3.25,3.25) A2(-2.75,3.25) A3(-2.25,3.25) A4(-1.75,3.25) A5(-1.25,3.25) A6(-0.75,3.25) A7(-0.25,3.25) A8(0.25,3.25) A9(0.75,3.25) A10(1.25,3.25) A11(1.75,3.25) A12(2.25,3.25) A13(2.75,3.25) A14(3.25,3.25) B1(-3.25,2.75) B2(-2.75,2.75) B3(-2.25,2.75) B4(-1.75,2.75) B5(-1.25,2.75) B6(-0.75,2.75) B7(-0.25,2.75) B8(0.25,2.75) B9(0.75,2.75) B10(1.25,2.75) B11(1.75,2.75) B12(2.25,2.75) B13(2.75,2.75) B14(3.25,2.75) C1(-3.25,2.25) C2(-2.75,2.25) C3(-2.25,2.25) C4(-1.75,2.25) C5(-1.25,2.25) C6(-0.75,2.25) C7(-0.25,2.25) C8(0.25,2.25) C9(0.75,2.25) C10(1.25,2.25) C11(1.75,2.25) C12(2.25,2.25) C13(2.75,2.25) C14(3.25,2.25) D1(-3.25,1.75) D2(-2.75,1.75) D3(-2.25,1.75) D4(-1.75,1.75) D12(2.25,1.75) D13(2.75,1.75) D14(3.25,1.75) E1(-3.25,1.25) E2(-2.75,1.25) E3(-2.25,1.25) E5(-1.25,1.25) E6(-0.75,1.25) E7(-0.25,1.25) E8(0.25,1.25) E9(0.75,1.25) E10(1.25,1.25) E12(2.25,1.25) E13(2.75,1.25) E14(3.25,1.25) F1(-3.25,0.75) F2(-2.75,0.75) F3(-2.25,0.75) F5(-1.25,0.75) F10(1.25,0.75) F12(2.25,0.75) F13(2.75,0.75) F14(3.25,0.75) G1(-3.25,0.25) G2(-2.75,0.25) G3(-2.25,0.25) G5(-1.25,0.25) G10(1.25,0.25) G12(2.25,0.25) G13(2.75,0.25) G14(3.25,0.25) H1(-3.25,-0.25) H2(-2.75,-0.25) H3(-2.25,-0.25) H5(-1.25,-0.25) H10(1.25,-0.25) H12(2.25,-0.25) H13(2.75,-0.25) H14(3.25,-0.25) J1(-3.25,-0.75) J2(-2.75,-0.75) J3(-2.25,-0.75) J5(-1.25,-0.75) J10(1.25,-0.75) J12(2.25,-0.75) J13(2.75,-0.75) J14(3.25,-0.75) K1(-3.25,-1.25) K2(-2.75,-1.25) K3(-2.25,-1.25) K5(-1.25,-1.25) K6(-0.75,-1.25) K7(-0.25,-1.25) K8(0.25,-1.25) K9(0.75,-1.25) K10(1.25,-1.25) K12(2.25,-1.25) K13(2.75,-1.25) K14(3.25,-1.25) L1(-3.25,-1.75) L2(-2.75,-1.75) L3(-2.25,-1.75) L12(2.25,-1.75) L13(2.75,-1.75) L14(3.25,-1.75) M1(-3.25,-2.25) M2(-2.75,-2.25) M3(-2.25,-2.25) M4(-1.75,-2.25) M5(-1.25,-2.25) M6(-0.75,-2.25) M7(-0.25,-2.25) M8(0.25,-2.25) M9(0.75,-2.25) M10(1.25,-2.25) M11(1.75,-2.25) M12(2.25,-2.25) M13(2.75,-2.25) M14(3.25,-2.25) N1(-3.25,-2.75) N2(-2.75,-2.75) N3(-2.25,-2.75) N4(-1.75,-2.75) N5(-1.25,-2.75) N6(-0.75,-2.75) N7(-0.25,-2.75) N8(0.25,-2.75) N9(0.75,-2.75) N10(1.25,-2.75) N11(1.75,-2.75) N12(2.25,-2.75) N13(2.75,-2.75) N14(3.25,-2.75) P1(-3.25,-3.25) P2(-2.75,-3.25) P3(-2.25,-3.25) P4(-1.75,-3.25) P5(-1.25,-3.25) P6(-0.75,-3.25) P7(-0.25,-3.25) P8(0.25,-3.25) P9(0.75,-3.25) P10(1.25,-3.25) P11(1.75,-3.25) P12(2.25,-3.25) P13(2.75,-3.25) P14(3.25,-3.25)
VSON-11
  custom 0.07x0.07 smd: 1(-1,-1.525) 2(-0.5,-1.525) 3(0,-1.525) 4(0.5,-1.525) 5(1,-1.525) 6(1,1.525) 7(0.5,1.525) 8(0,1.525) 9(-0.5,1.525) 10(-1,1.525)
  custom 0.412x0.412 smd: 11(0,0)
WURTH_6X3P5_TACT_SWITCH
  rect 2.311x1.499 smd: 1(-3.355,0) 2(3.355,0)
WURTH_MICRO-SD_CARD
  rect 0.8x1.5 smd: 1(-1.94,3.1) 2(-0.84,2.7) 3(0.26,3.1) 4(1.36,3.3) 5(2.46,3.1) 6(3.56,3.3) 7(4.66,3.1) 8(5.76,3.1)
  rect 1.4x1.9 smd: 9(6.55,5.95) 10(-6.6,6.95)
  rect 1.8x1.4 smd: 11(4.95,-7.2) 12(-0.75,-7.2)
XTAL_3MMX2MM
  rect 1.372x1.143 smd: 1(-1.186,-0.922) 2(1.186,-0.922) 3(1.186,0.922) 4(-1.186,0.922)
XTAL_FA-128
  rect 0.94x0.838 smd: 1(-0.725,-0.575) 2(0.725,-0.575) 3(0.725,0.575) 4(-0.725,0.575)

## Nets
5V: C449.1 C450.1 C451.1 C452.1 C453.2 C1895.1 FB30.1 FB31.2 R307.1 R439.1 R668.1 R5966.2 R5967.1 U43.C1 U43.D1 U43.D2 U43.E1 U43.E2(VOUT5)
5V_AGND: C448.1 C454.1 C455.1 R437.2 R441.2 R443.1 U43.B4
5V_LDO1: C456.1 FB30.2 R446.1 R785.1 U44.9 U44.10
5V_LDO2: C457.1 FB31.1 R447.1 R786.1 U45.9 U45.10
5V_PG: R431.1 R432.1 U30.C13 U43.C2
12V_AUX: C417.2 C418.1 D15.1(C) J16.1 J16.2 J16.3 R404.1 U33.1 U33.2 U33.3(S3) U35.2
12V_G1: C419.2 C421.1 C422.2 C423.2 C424.2 C428.1 C429.1 C430.1 C431.1 C1817.2 C1824.1 C1825.1 C1826.1 C1827.1 C1829.2 C1831.2 C1832.2 C1833.1 C1834.1 C1835.2 C1836.2 C1837.2 C1838.2 C1848.1 C1849.1 C1850.2 C1851.2 C1852.2 C1853.2 C1859.1 C1860.1 C1861.2 C1862.2 C1863.2 C1864.2 C1872.2 C1873.1 C1875.1 C1876.1 C1877.2 C1878.2 C1879.2 C1880.2 C1918.1 C2011.2 C2030.2 J15.2 R1.1 R2.1 R17.1 R18.1 R54.1 R55.1 R68.1 R69.1 R425.1 R5957.2 R6003.2 R6007.1 R6008.1 U34.1 U34.2 U34.3(S3) U36.6(VOUT) U47.32 U76.20 U76.21 U76.37 U76.38 U76.43(VIN5) U77.20 U77.21 U77.37 U77.38 U77.43(VIN5) U78.20 U78.21 U78.37 U78.38 U78.43(VIN5) U79.20 U79.21 U79.37 U79.38 U79.43(VIN5) U124.A2 U124.B3 U124.D3 U124.E2
12V_G1_OV_PG: R424.1 U30.D12 U42.6
12V_G1_PG: R407.2 U30.F12 U36.7
12V_G1_UV_PG: R423.1 U30.D9 U42.1
12V_G2: C436.1 C437.1 C438.1 C439.1 C440.1 C441.1 C442.2 C445.2 C446.2 C447.2 C1667.2 C1669.2 C1670.2 C1673.1 C1890.1 C1891.2 C1892.2 C1893.2 C1894.2 C1901.2 C1903.2 C1948.2 C1949.2 C1950.1 C1958.2 C1959.2 C1960.1 C1976.2 C1977.2 C1986.2 C1987.1 C1990.2 C1991.2 C2000.2 C2001.2 C2002.2 C2035.2 C2037.2 C7767.2 C7768.2 C7769.2 C7770.2 C7779.1 R433.1 R440.2 R5777.1 R5965.1 R6268.2 U39.1 U39.2 U39.3(S3) U41.6(VOUT) U42.5(VDD) U43.D5 U43.E5 U46.4 U46.5 U46.18 U46.19 U51.C5 U51.D5 U51.E5 U57.B3 U57.B4 U57.B5 U57.E3 U57.E4 U57.E5 U57.H3 U57.H4 U57.H5 U57.L3 U57.L4 U57.L5 U58.B3 U58.B4 U58.B5 U58.E3 U58.E4 U58.E5 U58.H3 U58.H4 U58.H5 U58.L3 U58.L4 U58.L5 U61.C5 U61.D5 U61.E5 U66.A4 U66.B4 U66.F4 U66.G4 U70.A4 U70.B4 U70.F4 U70.G4 U71.A9 U71.B9 U71.C9 U71.D9 U71.J9 U71.K9 U71.L9 U71.M9 U125.D3 U125.D4 U125.E3 U125.E4 U125.F4 U125.G4
12V_G2_PG: R419.1 U30.E12 U41.7
12V_GROUP1: C425.1 Q12.1 Q12.2 Q12.3(S3) R405.1 R406.1 R411.1 R426.2 U33.5 U34.5 U35.1 U35.6(VDD) U36.4 U37.2 U37.4
12V_GROUP2: C427.1 C435.1 Q12.5 R417.1 R418.1 U37.8 U38.5 U39.5 U40.1 U40.6(VDD) U41.4
GND: C1.2 C2.2 C3.2 C4.2 C5.2 C6.2 C7.2 C8.2 C9.2 C10.2 C11.2 C12.2 C13.2 C14.2 C15.2 C16.1 C17.2 C18.2 C19.2 C20.1 C21.1 C22.2 C23.2 C24.2 C25.2 C26.2 C27.2 C28.2 C29.2 C31.2 C32.1 C33.2 C34.2 C35.2 C37.2 C38.2 C39.2 C40.2 C41.2 C42.2 C43.2 C44.2 C45.2 C46.2 C47.2 C48.2 C49.2 C50.2 C51.2 C52.1 C53.2 C54.1 C55.2 C57.2 C58.2 C60.2 C61.1 C62.2 C63.2 C64.2 C65.1 C66.1 C67.2 C68.2 C69.2 C70.2 C71.2 C73.2 C74.2 C75.2 C76.2 C77.2 C78.2 C79.2 C80.2 C81.2 C82.2 C83.2 C84.2 C85.2 C86.2 C87.2 C88.1 C89.2 C90.2 C91.2 C92.1 C93.1 C94.2 C95.2 C96.2 C97.2 C98.2 C99.2 C100.2 C101.2 C103.2 C104.1 C105.2 C106.2 C107.2 C109.2 C110.2 C111.2 C112.2 C113.2 C114.2 C115.2 C116.2 C117.2 C118.2 C119.2 C120.2 C121.1 C122.2 C123.2 C124.2 C125.1 C126.1 C127.2 C128.2 C129.2 C130.2 C131.2 C132.2 C133.2 C134.2 C136.2 C137.1 C138.2 C139.2 C140.2 C142.2 C143.1 C144.2 C145.1 C146.1 C147.1 C148.2 C149.1 C150.1 C151.1 C152.2 C153.1 C154.1 C155.1 C156.2 C157.2 C158.1 C159.2 C160.1 C161.1 C162.1 C163.2 C164.1 C165.1 C166.1 C167.2 C168.1 C169.1 C170.1 C171.2 C173.2 C174.2 C176.2 C207.2 C208.2 C209.2 C210.2 C211.2 C212.2 C213.2 C214.2 C215.1 C216.2 C217.1 C218.1 C219.2 C220.1 C221.1 C222.1 C223.2 C224.1 C226.1 C227.1 C228.1 C229.2 C230.2 C231.1 C232.1 C233.2 C234.2 C235.1 C236.2 C237.1 C238.1 C239.1 C240.1 C241.1 C242.1 C243.2 C244.2 C245.2 C246.2 C247.2 C248.1 C249.1 C250.2 C251.1 C252.2 C253.2 C254.1 C255.2 C256.1 C257.2 C258.1 C259.1 C260.1 C261.2 C262.1 C263.1 C264.2 C265.2 C266.1 C267.2 C268.2 C269.2 C270.2 C271.2 C272.2 C273.2 C275.2 C276.2 C277.2 C278.2 C279.2 C280.2 C281.2 C282.2 C283.2 C284.2 C285.2 C286.2 C287.2 C289.2 C290.2 C291.2 C292.2 C293.2 C294.2 C295.2 C296.2 C297.2 C298.2 C299.2 C300.2 C301.2 C302.2 C303.2 C304.2 C305.2 C306.2 C307.2 C308.2 C309.2 C310.2 C311.2 C312.2 C313.2 C314.2 C319.2 C320.2 C321.2 C322.2 C323.2 C324.2 C325.2 C326.2 C327.1 C328.1 C329.1 C330.1 C331.1 C332.1 C333.2 C334.1 C335.2 C336.1 C337.1 C338.1 C339.2 C340.1 C341.2 C342.2 C343.2 C344.2 C345.2 C346.2 C347.2 C348.2 C349.2 C350.2 C351.2 C352.2 C353.2 C354.2 C355.2 C356.1 C357.2 C358.2 C359.2 C360.2 C361.2 C362.2 C363.2 C364.2 C365.2 C366.2 C367.2 C368.1 C369.2 C370.2 C371.2 C372.2 C373.2 C374.2 C375.2 C376.2 C377.2 C378.2 C379.2 C380.1 C381.2 C393.1 C394.1 C396.2 C397.1 C398.1 C399.1 C400.1 C401.1 C402.1 C403.1 C404.1 C405.1 C406.1 C407.1 C408.1 C409.1 C410.1 C411.1 C412.1 C413.1 C414.1 C415.1 C416.1 C417.1 C418.2 C419.1 C420.1 C421.2 C422.1 C423.1 C424.1 C425.2 C426.2 C428.2 C429.2 C430.2 C431.2 C432.2 C433.2 C434.1 C435.2 C436.2 C437.2 C438.2 C439.2 C440.2 C441.2 C442.1 C443.1 C444.1 C445.1 C446.1 C447.1 C449.2 C450.2 C451.2 C452.2 C456.2 C457.2 C460.2 C461.2 C462.2 C463.2 C464.2 C465.2 C466.2 C467.2 C555.2 C558.2 C559.2 C560.2 C561.2 C652.1 C653.2 C654.2 C655.2 C656.2 C657.2 C658.2 C659.2 C660.2 C661.1 C662.2 C663.2 C664.2 C665.2 C666.2 C667.2 C668.2 C669.2 C670.2 C671.2 C672.2 C673.2 C679.2 C680.2 C681.2 C682.2 C684.2 C685.2 C686.2 C687.2 C702.2 C703.1 C704.2 C705.1 C706.2 C707.2 C708.2 C737.2 C762.2 C763.2 C764.2 C765.2 C766.2 C767.2 C768.2 C769.2 C770.2 C771.2 C772.2 C773.2 C774.2 C775.2 C776.2 C777.2 C778.2 C779.2 C780.2 C781.2 C782.2 C783.2 C784.2 C785.2 C786.2 C787.2 C788.2 C789.2 C790.2 C791.2 C792.2 C793.2 C794.2 C795.2 C796.2 C797.2 C798.2 C799.2 C800.2 C801.2 C802.1 C803.1 C804.1 C805.1 C806.1 C807.1 C808.2 C809.2 C810.2 C811.2 C812.2 C814.2 C815.2 C817.2 C818.2 C819.2 C821.2 C825.2 C828.2 C829.2 C830.2 C831.2 C832.2 C833.2 C834.2 C835.2 C836.2 C837.2 C838.2 C839.2 C840.1 C841.1 C842.1 C843.2 C844.2 C845.2 C846.2 C847.2 C848.2 C849.2 C850.2 C851.2 C852.2 C853.2 C854.2 C855.2 C856.2 C857.2 C858.1 C859.1 C860.2 C861.2 C1196.2 C1197.2 C1199.2 C1200.2 C1201.2 C1202.2 C1203.2 C1204.2 C1205.2 C1206.2 C1207.2 C1208.1 C1209.1 C1210.1 C1211.2 C1212.1 C1213.2 C1214.2 C1215.2 C1216.2 C1217.2 C1218.2 C1219.2 C1220.2 C1222.2 C1223.2 C1224.2 C1225.2 C1227.2 C1228.2 C1229.2 C1230.2 C1231.2 C1232.2 C1233.2 C1234.2 C1235.2 C1236.1 C1237.2 C1238.2 C1239.2 C1240.2 C1241.1 C1242.2 C1243.2 C1244.1 C1245.1 C1246.1 C1247.1 C1248.1 C1249.1 C1250.1 C1251.2 C1252.2 C1253.2 C1254.2 C1255.2 C1256.2 C1257.2 C1258.2 C1259.2 C1260.2 C1261.2 C1262.2 C1263.2 C1264.2 C1265.2 C1266.2 C1267.2 C1268.2 C1269.2 C1270.2 C1271.2 C1272.2 C1273.2 C1274.2 C1275.2 C1276.2 C1277.2 C1278.2 C1279.2 C1280.2 C1281.2 C1282.2 C1283.2 C1284.2 C1285.2 C1286.1 C1287.1 C1288.1 C1289.1 C1290.1 C1291.1 C1292.1 C1293.1 C1294.1 C1295.1 C1296.1 C1297.1 C1298.2 C1299.2 C1302.2 C1303.2 C1304.2 C1305.2 C1306.2 C1307.2 C1308.2 C1309.2 C1310.2 C1311.2 C1312.2 C1313.2 C1314.2 C1315.2 C1317.2 C1318.2 C1319.2 C1320.2 C1321.1 C1323.2 C1324.2 C1325.2 C1326.2 C1327.2 C1328.2 C1329.2 C1330.2 C1331.2 C1332.2 C1333.2 C1334.2 C1335.2 C1336.2 C1337.2 C1338.2 C1339.2 C1340.2 C1341.1 C1342.1 C1343.1 C1344.1 C1345.2 C1346.2 C1347.2 C1348.2 C1349.2 C1350.2 C1351.2 C1352.2 C1353.2 C1354.2 C1355.2 C1356.2 C1357.2 C1358.2 C1359.2 C1360.2 C1361.1 C1362.1 C1363.1 C1364.1 C1365.2 C1366.2 C1367.2 C1368.2 C1369.2 C1370.2 C1371.2 C1372.2 C1373.2 C1374.2 C1375.2 C1376.2 C1377.2 C1378.2 C1379.2 C1380.2 C1381.2 C1382.2 C1383.2 C1384.1 C1385.1 C1386.1 C1387.1 C1388.2 C1389.2 C1390.2 C1391.2 C1392.2 C1393.2 C1394.2 C1395.2 C1396.2 C1397.2 C1398.2 C1399.2 C1400.2 C1401.2 C1402.2 C1403.2 C1404.2 C1405.1 C1406.1 C1407.1 C1408.1 C1410.1 C1421.2 C1422.2 C1423.1 C1424.2 C1425.2 C1426.1 C1427.2 C1428.2 C1429.2 C1430.1 C1431.1 C1432.1 C1433.1 C1434.2 C1435.2 C1436.2 C1437.2 C1438.2 C1439.2 C1440.1 C1441.1 C1443.2 C1445.1 C1446.2 C1447.2 C1448.2 C1449.2 C1450.2 C1483.1 C1484.1 C1485.1 C1486.1 C1487.1 C1488.1 C1489.1 C1490.1 C1491.1 C1492.1 C1493.1 C1494.1 C1495.1 C1496.1 C1497.1 C1498.1 C1499.1 C1500.1 C1501.1 C1502.1 C1503.1 C1504.1 C1505.1 C1506.1 C1507.1 C1508.1 C1509.1 C1510.1 C1511.1 C1512.1 C1513.1 C1514.1 C1515.1 C1516.1 C1517.1 C1518.2 C1519.2 C1520.2 C1521.2 C1522.2 C1523.2 C1524.1 C1525.2 C1550.1 C1655.2 C1659.2 C1660.1 C1663.1 C1667.1 C1669.1 C1670.1 C1673.2 C1674.1 C1816.1 C1817.1 C1818.1 C1819.2 C1820.2 C1821.2 C1822.1 C1823.2 C1824.2 C1825.2 C1826.2 C1827.2 C1829.1 C1831.1 C1832.1 C1833.2 C1834.2 C1835.1 C1836.1 C1837.1 C1838.1 C1839.1 C1840.2 C1841.2 C1842.1 C1843.1 C1844.2 C1845.2 C1846.2 C1847.2 C1848.2 C1849.2 C1850.1 C1851.1 C1852.1 C1853.1 C1856.2 C1857.1 C1858.1 C1859.2 C1860.2 C1861.1 C1862.1 C1863.1 C1864.1 C1867.1 C1868.2 C1869.2 C1870.1 C1871.1 C1872.1 C1873.2 C1874.1 C1875.2 C1876.2 C1877.1 C1878.1 C1879.1 C1880.1 C1883.2 C1884.1 C1885.1 C1886.2 C1887.1 C1888.1 C1889.1 C1890.2 C1891.1 C1892.1 C1893.1 C1894.1 C1895.2 C1896.1 C1897.1 C1898.1 C1899.2 C1900.1 C1903.1 C1905.2 C1906.2 C1907.1 C1908.1 C1910.1 C1911.1 C1912.2 C1913.1 C1915.1 C1916.1 C1917.1 C1918.2 C1919.1 C1920.1 C1921.1 C1922.1 C1923.1 C1924.1 C1925.1 C1926.1 C1928.2 C1929.2 C1930.1 C1931.1 C1932.1 C1934.2 C1941.1 C1942.1 C1944.1 C1945.1 C1946.2 C1947.1 C1948.1 C1949.1 C1950.2 C1951.2 C1952.1 C1953.1 C1954.1 C1956.1 C1957.1 C1958.1 C1959.1 C1960.2 C1961.2 C1962.1 C1963.1 C1964.1 C1967.1 C1975.1 C1977.1 C1980.2 C1981.2 C1986.1 C1987.2 C1988.2 C1989.2 C1990.1 C1991.1 C1992.2 C1993.2 C1994.2 C1995.1 C1996.2 C1997.1 C1998.2 C1999.1 C2000.1 C2001.1 C2002.1 C2007.1 C2008.1 C2009.1 C2010.1 C2011.1 C2013.1 C2014.1 C2015.1 C2016.1 C2017.1 C2018.2 C2019.2 C2020.1 C2021.1 C2022.1 C2023.1 C2024.1 C2025.2 C2026.1 C2027.2 C2028.1 C2029.1 C2030.1 C2035.1 C2037.1 C2038.2 C2039.1 C7765.2 C7766.2 C7767.1 C7768.1 C7769.1 C7770.1 C7771.2 C7772.2 C7773.2 C7774.2 C7775.2 C7776.2 C7777.1 C7779.2 D4.3 D5.3 D6.3 D15.2 D16.2 J1.2 J1.4 J1.6 J1.9 J1.11 J1.13 J1.15 J1.17 J1.20 J1.22 J1.24 J1.26 J1.28 J1.31 J1.33 J1.35 J1.37 J1.39 J1.42 J1.44 J1.46 J1.48 J1.50 J1.53 J1.55 J1.57 J1.94 J1.96 J1.98 J1.101 J1.103 J1.105 J1.107 J1.109 J1.112 J1.114 J1.116 J1.118 J1.120 J1.123 J1.125 J1.127 J1.129 J1.131 J1.134 J1.136 J1.138 J1.147 J1.149 J1.151 J1.154 J1.156 J1.158 J1.160 J1.162 J1.165 J1.167 J1.169 J1.171 J1.173 J1.176 J1.178 J1.180 J1.182 J1.184 J1.187 J1.189 J1.191 J1.193 J1.195 J1.198 J1.200 J1.202 J1.239 J1.241 J1.243 J1.246 J1.248 J1.250 J1.252 J1.254 J1.257 J1.259 J1.261 J1.263 J1.265 J1.268 J1.270 J1.272 J1.274 J1.276 J1.279 J1.281 J1.283 J2.2 J2.4 J2.6 J2.9 J2.11 J2.13 J2.15 J2.17 J2.20 J2.22 J2.24 J2.26 J2.28 J2.31 J2.33 J2.35 J2.37 J2.39 J2.42 J2.44 J2.46 J2.48 J2.50 J2.53 J2.55 J2.57 J2.94 J2.96 J2.98 J2.101 J2.103 J2.105 J2.107 J2.109 J2.112 J2.114 J2.116 J2.118 J2.120 J2.123 J2.125 J2.127 J2.129 J2.131 J2.134 J2.136 J2.138 J2.147 J2.149 J2.151 J2.154 J2.156 J2.158 J2.160 J2.162 J2.165 J2.167 J2.169 J2.171 J2.173 J2.176 J2.178 J2.180 J2.182 J2.184 J2.187 J2.189 J2.191 J2.193 J2.195 J2.198 J2.200 J2.202 J2.239 J2.241 J2.243 J2.246 J2.248 J2.250 J2.252 J2.254 J2.257 J2.259 J2.261 J2.263 J2.265 J2.268 J2.270 J2.272 J2.274 J2.276 J2.279 J2.281 J2.283 J3.2 J3.4 J3.6 J3.9 J3.11 J3.13 J3.15 J3.17 J3.20 J3.22 J3.24 J3.26 J3.28 J3.31 J3.33 J3.35 J3.37 J3.39 J3.42 J3.44 J3.46 J3.48 J3.50 J3.53 J3.55 J3.57 J3.94 J3.96 J3.98 J3.101 J3.103 J3.105 J3.107 J3.109 J3.112 J3.114 J3.116 J3.118 J3.120 J3.123 J3.125 J3.127 J3.129 J3.131 J3.134 J3.136 J3.138 J3.147 J3.149 J3.151 J3.154 J3.156 J3.158 J3.160 J3.162 J3.165 J3.167 J3.169 J3.171 J3.173 J3.176 J3.178 J3.180 J3.182 J3.184 J3.187 J3.189 J3.191 J3.193 J3.195 J3.198 J3.200 J3.202 J3.239 J3.241 J3.243 J3.246 J3.248 J3.250 J3.252 J3.254 J3.257 J3.259 J3.261 J3.263 J3.265 J3.268 J3.270 J3.272 J3.274 J3.276 J3.279 J3.281 J3.283 J4.2 J4.4 J4.6 J4.9 J4.11 J4.13 J4.15 J4.17 J4.20 J4.22 J4.24 J4.26 J4.28 J4.31 J4.33 J4.35 J4.37 J4.39 J4.42 J4.44 J4.46 J4.48 J4.50 J4.53 J4.55 J4.57 J4.94 J4.96 J4.98 J4.101 J4.103 J4.105 J4.107 J4.109 J4.112 J4.114 J4.116 J4.118 J4.120 J4.123 J4.125 J4.127 J4.129 J4.131 J4.134 J4.136 J4.138 J4.147 J4.149 J4.151 J4.154 J4.156 J4.158 J4.160 J4.162 J4.165 J4.167 J4.169 J4.171 J4.173 J4.176 J4.178 J4.180 J4.182 J4.184 J4.187 J4.189 J4.191 J4.193 J4.195 J4.198 J4.200 J4.202 J4.239 J4.241 J4.243 J4.246 J4.248 J4.250 J4.252 J4.254 J4.257 J4.259 J4.261 J4.263 J4.265 J4.268 J4.270 J4.272 J4.274 J4.276 J4.279 J4.281 J4.283 J5.1 J5.4 J5.7 J5.13 J5.16 J5.19 J5.20 J5.23 J5.26 J5.32 J5.35 J5.38 J5.39 J5.42 J5.45 J5.51 J5.54 J5.57 J5.58 J5.61 J5.64 J5.70 J5.73 J5.76 J6.1 J6.4 J6.7 J6.13 J6.16 J6.19 J6.20 J6.23 J6.26 J6.32 J6.35 J6.38 J6.39 J6.42 J6.45 J6.51 J6.54 J6.57 J6.58 J6.61 J6.64 J6.70 J6.73 J6.76 J7.A4 J7.A12 J7.A15 J7.A18 J7.A20 J7.A23 J7.A24 J7.A27 J7.A28 J7.A31 J7.A34 J7.A37 J7.A38 J7.A41 J7.A42 J7.A45 J7.A46 J7.A49 J7.A51 J7.A54 J7.A55 J7.A58 J7.A59 J7.A62 J7.A63 J7.A66 J7.A67 J7.A70 J7.A71 J7.A74 J7.A75 J7.A78 J7.A79 J7.A82 J7.B4 J7.B7 J7.B13 J7.B16 J7.B18 J7.B21 J7.B22 J7.B25 J7.B26 J7.B29 J7.B32 J7.B35 J7.B36 J7.B39 J7.B40 J7.B43 J7.B44 J7.B47 J7.B49 J7.B52 J7.B53 J7.B56 J7.B57 J7.B60 J7.B61 J7.B64 J7.B65 J7.B68 J7.B69 J7.B72 J7.B73 J7.B76 J7.B77 J7.B80 J10.5 J11.6(VSS) J11.9 J11.10 J11.11 J11.12 J12.5 J12.16 J12.18 J12.20 J12.22 J12.23 J12.24 J12.25 J12.26 J12.27 J12.28 J12.29 J12.31 J12.33 J12.35 J12.37 J12.38 J12.39 J12.40 J12.41 J12.42 J12.43 J13.5 J14.10 J15.1 J16.4(SENSE1) J16.5 J16.6 J16.7 J16.8 J17.3 J22.1 J22.3 Q1.2(SOURCE) Q2.2(SOURCE) Q3.2(SOURCE) Q4.2(SOURCE) Q5.2(SOURCE) Q6.2(SOURCE) Q7.2(SOURCE) Q8.2(SOURCE) Q9.2(SOURCE) Q10.2(SOURCE) Q11.2(SOURCE) Q13.2(SOURCE) Q24.2(SOURCE) Q25.2(SOURCE) Q26.2(SOURCE) Q27.2(SOURCE) Q28.2(SOURCE) Q29.2(SOURCE) R7.1 R8.1 R9.1 R11.1 R12.1 R13.1 R15.1 R24.1 R25.1 R27.1 R28.1 R29.1 R32.1 R33.1 R34.1 R35.1 R43.1 R45.1 R48.1 R58.1 R60.1 R62.1 R63.1 R64.1 R66.1 R74.1 R76.1 R77.1 R78.1 R84.2 R86.2 R87.1 R88.1 R94.1 R97.1 R110.1 R111.1 R112.1 R114.1 R115.1 R119.1 R135.2 R137.2 R139.2 R142.2 R145.2 R147.2 R149.2 R151.2 R153.2 R155.2 R166.1 R173.2 R176.1 R196.1 R201.1 R202.2 R203.1 R204.1 R206.2 R208.1 R209.1 R211.1 R217.1 R241.2 R242.2 R260.2 R266.2 R267.2 R274.1 R275.1 R278.1 R279.1 R295.1 R297.1 R299.1 R300.1 R308.1 R310.2 R315.2 R325.1 R327.1 R328.2 R329.2 R333.1 R335.1 R344.1 R347.2 R355.1 R356.1 R359.1 R387.2 R395.1 R404.2 R413.2 R414.2 R416.2 R422.2 R429.1 R430.2 R432.2 R438.2 R441.1 R442.2 R448.2 R449.1 R548.2 R549.1 R650.1 R652.2 R656.1 R658.2 R671.1 R682.1 R710.2 R711.2 R714.2 R720.2 R722.2 R723.2 R724.1 R773.1 R774.1 R775.1 R776.1 R777.1 R778.1 R779.1 R780.1 R781.1 R782.1 R783.1 R793.1 R802.2 R803.2 R804.2 R805.2 R806.2 R807.2 R808.2 R814.2 R816.2 R818.2 R820.2 R822.1 R5786.1 R5788.1 R5936.2 R5939.1 R5940.1 R5941.1 R5942.1 R5948.1 R5949.1 R5956.1 R5958.2 R5978.1 R5991.1 R5998.2 R6016.1 R6017.1 R6028.2 R6034.1 R6036.2 R6043.2 R6062.1 R6066.1 R6073.1 R6077.1 R6078.2 R6085.1 R6086.1 R6100.1 R6102.2 R6267.1 R6270.1 R6272.1 R6287.1 R6288.1 S1.1 S2.1 S3.1 S4.1 S5.2 ST3.2 ST11.2 ST12.2 ST13.2 ST14.2 ST15.2 ST16.2 ST17.2 ST19.2 ST20.2 ST21.1 ST31.1 ST32.2 SW4.5(B4) SW4.6 SW4.7 SW4.8 SW7.2(B1) U1.7 U2.A2 U2.A4 U2.A18 U2.A32 U2.A46 U2.A58 U2.A60 U2.AA40 U2.AA50 U2.AA54 U2.AA58 U2.AA60 U2.AB21 U2.AB41 U2.AB49 U2.AB51 U2.AB53 U2.AB57 U2.AB59 U2.AC20 U2.AC24 U2.AC26 U2.AC28 U2.AC30 U2.AC32 U2.AC34 U2.AC36 U2.AC38 U2.AC40 U2.AC48 U2.AC50 U2.AC52 U2.AC54 U2.AC58 U2.AC60 U2.AD41 U2.AD47 U2.AD51 U2.AD55 U2.AD57 U2.AD61 U2.AE2 U2.AE4 U2.AE6 U2.AE8 U2.AE10 U2.AE12 U2.AE14 U2.AE16 U2.AE18 U2.AE20 U2.AE22 U2.AE24 U2.AE26 U2.AE28 U2.AE30 U2.AE32 U2.AE34 U2.AE36 U2.AE38 U2.AE40 U2.AE42 U2.AE46 U2.AE50 U2.AE54 U2.AE56 U2.AE60 U2.AE62 U2.AF11 U2.AF13 U2.AF15 U2.AF17 U2.AF39 U2.AF45 U2.AF47 U2.AF49 U2.AF51 U2.AF53 U2.AF57 U2.AF59 U2.AG2 U2.AG8 U2.AG10 U2.AG12 U2.AG14 U2.AG16 U2.AG18 U2.AG20 U2.AG22 U2.AG24 U2.AG26 U2.AG28 U2.AG30 U2.AG32 U2.AG34 U2.AG36 U2.AG38 U2.AG40 U2.AG42 U2.AG44 U2.AG48 U2.AG50 U2.AG52 U2.AG54 U2.AG58 U2.AG60 U2.AH1 U2.AH3 U2.AH7 U2.AH9 U2.AH11 U2.AH13 U2.AH15 U2.AH17 U2.AH39 U2.AH47 U2.AH51 U2.AH55 U2.AH57 U2.AH61 U2.AJ4 U2.AJ6 U2.AJ10 U2.AJ12 U2.AJ14 U2.AJ16 U2.AJ18 U2.AJ22 U2.AJ38 U2.AJ40 U2.AJ42 U2.AJ44 U2.AJ50 U2.AJ54 U2.AJ56 U2.AJ60 U2.AJ62 U2.AK3 U2.AK5 U2.AK9 U2.AK11 U2.AK13 U2.AK15 U2.AK17 U2.AK19 U2.AK43 U2.AK45 U2.AK47 U2.AK49 U2.AK51 U2.AK53 U2.AK57 U2.AK59 U2.AL2 U2.AL6 U2.AL8 U2.AL12 U2.AL14 U2.AL16 U2.AL18 U2.AL20 U2.AL22 U2.AL24 U2.AL26 U2.AL28 U2.AL30 U2.AL32 U2.AL34 U2.AL36 U2.AL38 U2.AL40 U2.AL42 U2.AL44 U2.AL46 U2.AL48 U2.AL50 U2.AL52 U2.AL54 U2.AL58 U2.AL60 U2.AM1 U2.AM3 U2.AM7 U2.AM9 U2.AM13 U2.AM15 U2.AM17 U2.AM43 U2.AM45 U2.AM47 U2.AM51 U2.AM55 U2.AM57 U2.AM61 U2.AN4 U2.AN6 U2.AN10 U2.AN12 U2.AN16 U2.AN22 U2.AN24 U2.AN26 U2.AN28 U2.AN30 U2.AN32 U2.AN34 U2.AN36 U2.AN38 U2.AN40 U2.AN42 U2.AN44 U2.AN50 U2.AN54 U2.AN56 U2.AN60 U2.AN62 U2.AP3 U2.AP5 U2.AP9 U2.AP11 U2.AP15 U2.AP19 U2.AP43 U2.AP45 U2.AP47 U2.AP51 U2.AP53 U2.AP57 U2.AP59 U2.AR2 U2.AR6 U2.AR8 U2.AR12 U2.AR16 U2.AR22 U2.AR24 U2.AR26 U2.AR38 U2.AR40 U2.AR42 U2.AR46 U2.AR50 U2.AR52 U2.AR54 U2.AR58 U2.AR60 U2.AT1 U2.AT3 U2.AT7 U2.AT9 U2.AT15 U2.AT43 U2.AT45 U2.AT47 U2.AT51 U2.AT55 U2.AT57 U2.AT61 U2.AU4 U2.AU6 U2.AU10 U2.AU12 U2.AU14 U2.AU16 U2.AU18 U2.AU22 U2.AU24 U2.AU26 U2.AU38 U2.AU40 U2.AU42 U2.AU48 U2.AU50 U2.AU54 U2.AU56 U2.AU60 U2.AU62 U2.AV3 U2.AV5 U2.AV9 U2.AV11 U2.AV13 U2.AV17 U2.AV19 U2.AV45 U2.AV51 U2.AV53 U2.AV57 U2.AV59 U2.AW2 U2.AW6 U2.AW8 U2.AW12 U2.AW16 U2.AW18 U2.AW22 U2.AW24 U2.AW26 U2.AW38 U2.AW40 U2.AW42 U2.AW48 U2.AW50 U2.AW52 U2.AW54 U2.AW58 U2.AW60 U2.AY1 U2.AY3 U2.AY7 U2.AY9 U2.AY13 U2.AY45 U2.AY51 U2.AY55 U2.AY57 U2.AY61 U2.B1 U2.B3 U2.B11 U2.B25 U2.B39 U2.B53 U2.B59 U2.B61 U2.BA4 U2.BA6 U2.BA10 U2.BA12 U2.BA16 U2.BA18 U2.BA20 U2.BA22 U2.BA24 U2.BA38 U2.BA40 U2.BA42 U2.BA46 U2.BA48 U2.BA50 U2.BA54 U2.BA56 U2.BA60 U2.BA62 U2.BB3 U2.BB5 U2.BB9 U2.BB11 U2.BB13 U2.BB43 U2.BB45 U2.BB47 U2.BB51 U2.BB53 U2.BB57 U2.BB59 U2.BC2 U2.BC6 U2.BC8 U2.BC12 U2.BC16 U2.BC18 U2.BC22 U2.BC24 U2.BC26 U2.BC38 U2.BC40 U2.BC42 U2.BC50 U2.BC52 U2.BC54 U2.BC58 U2.BC60 U2.BD1 U2.BD3 U2.BD7 U2.BD9 U2.BD13 U2.BD15 U2.BD17 U2.BD45 U2.BD47 U2.BD51 U2.BD55 U2.BD57 U2.BD61 U2.BE4 U2.BE6 U2.BE10 U2.BE12 U2.BE18 U2.BE22 U2.BE24 U2.BE26 U2.BE38 U2.BE40 U2.BE42 U2.BE48 U2.BE50 U2.BE54 U2.BE56 U2.BE60 U2.BE62 U2.BF3 U2.BF5 U2.BF9 U2.BF11 U2.BF13 U2.BF15 U2.BF17 U2.BF19 U2.BF45 U2.BF47 U2.BF49 U2.BF51 U2.BF53 U2.BF57 U2.BF59 U2.BG2 U2.BG6 U2.BG8 U2.BG12 U2.BG18 U2.BG20 U2.BG22 U2.BG24 U2.BG26 U2.BG38 U2.BG40 U2.BG42 U2.BG44 U2.BG46 U2.BG48 U2.BG50 U2.BG52 U2.BG54 U2.BG58 U2.BG60 U2.BH1 U2.BH3 U2.BH7 U2.BH9 U2.BH13 U2.BH15 U2.BH17 U2.BH51 U2.BH55 U2.BH57 U2.BH61 U2.BJ4 U2.BJ6 U2.BJ10 U2.BJ12 U2.BJ16 U2.BJ18 U2.BJ22 U2.BJ24 U2.BJ26 U2.BJ38 U2.BJ40 U2.BJ42 U2.BJ44 U2.BJ46 U2.BJ48 U2.BJ50 U2.BJ54 U2.BJ56 U2.BJ60 U2.BJ62 U2.BK3 U2.BK5 U2.BK9 U2.BK11 U2.BK13 U2.BK43 U2.BK45 U2.BK47 U2.BK51 U2.BK53 U2.BK57 U2.BK59 U2.BL2 U2.BL6 U2.BL8 U2.BL12 U2.BL16 U2.BL18 U2.BL22 U2.BL24 U2.BL26 U2.BL28 U2.BL30 U2.BL32 U2.BL34 U2.BL36 U2.BL38 U2.BL40 U2.BL42 U2.BL52 U2.BL54 U2.BL58 U2.BL60 U2.BM1 U2.BM3 U2.BM7 U2.BM9 U2.BM13 U2.BM19 U2.BM51 U2.BM55 U2.BM57 U2.BM61 U2.BN4 U2.BN6 U2.BN10 U2.BN12 U2.BN16 U2.BN18 U2.BN20 U2.BN22 U2.BN24 U2.BN26 U2.BN28 U2.BN30 U2.BN32 U2.BN34 U2.BN36 U2.BN38 U2.BN40 U2.BN42 U2.BN48 U2.BN54 U2.BN56 U2.BN60 U2.BN62 U2.BP3 U2.BP5 U2.BP9 U2.BP11 U2.BP13 U2.BP43 U2.BP45 U2.BP49 U2.BP51 U2.BP53 U2.BP57 U2.BP59 U2.BR2 U2.BR6 U2.BR8 U2.BR12 U2.BR14 U2.BR16 U2.BR18 U2.BR22 U2.BR38 U2.BR40 U2.BR42 U2.BR46 U2.BR48 U2.BR52 U2.BR54 U2.BR58 U2.BR60 U2.BT1 U2.BT3 U2.BT7 U2.BT9 U2.BT13 U2.BT15 U2.BT17 U2.BT25 U2.BT55 U2.BT57 U2.BT61 U2.BU4 U2.BU6 U2.BU10 U2.BU12 U2.BU18 U2.BU20 U2.BU22 U2.BU24 U2.BU26 U2.BU28 U2.BU30 U2.BU32 U2.BU34 U2.BU36 U2.BU38 U2.BU40 U2.BU42 U2.BU54 U2.BU56 U2.BU62 U2.BV3 U2.BV5 U2.BV9 U2.BV11 U2.BV25 U2.BV57 U2.BV59 U2.BV61 U2.BW2 U2.BW6 U2.BW8 U2.BW12 U2.BW14 U2.BW16 U2.BW20 U2.BW22 U2.BW24 U2.BW26 U2.BW28 U2.BW30 U2.BW32 U2.BW34 U2.BW36 U2.BW38 U2.BW40 U2.BW42 U2.BW44 U2.BW46 U2.BW48 U2.BW50 U2.BW52 U2.BW54 U2.BW56 U2.BW58 U2.BW60 U2.BW62 U2.BY1 U2.BY3 U2.BY7 U2.BY9 U2.BY13 U2.BY23 U2.BY51 U2.BY59 U2.C2 U2.C4 U2.C18 U2.C32 U2.C46 U2.C60 U2.C62 U2.CA2 U2.CA4 U2.CA6 U2.CA8 U2.CA10 U2.CA12 U2.CA20 U2.CA22 U2.CA24 U2.CA26 U2.CA28 U2.CA30 U2.CA32 U2.CA34 U2.CA36 U2.CA38 U2.CA40 U2.CA42 U2.CA44 U2.CA46 U2.CA62 U2.CB3 U2.CB5 U2.CB9 U2.CB11 U2.CB23 U2.CB55 U2.CC4 U2.CC6 U2.CC10 U2.CC12 U2.CC40 U2.CC42 U2.CC44 U2.CC46 U2.CC54 U2.CD1 U2.CD3 U2.CD5 U2.CD7 U2.CD9 U2.CD11 U2.CD13 U2.CD15 U2.CD17 U2.CD19 U2.CD21 U2.CD23 U2.CD25 U2.CD27 U2.CD29 U2.CD31 U2.CD33 U2.CD35 U2.CD37 U2.CD39 U2.CD41 U2.CD43 U2.CD45 U2.CD47 U2.CD49 U2.CD51 U2.CD53 U2.CD55 U2.CD57 U2.CD59 U2.CD61 U2.CE2 U2.CE16 U2.CE30 U2.CE44 U2.CE58 U2.CE62 U2.CF9 U2.CF23 U2.CF37 U2.CF51 U2.CG2 U2.CG16 U2.CG30 U2.CG44 U2.CG58 U2.CG62 U2.CH9 U2.CH23 U2.CH37 U2.CH51 U2.CJ2 U2.CJ4 U2.CJ6 U2.CJ8 U2.CJ10 U2.CJ12 U2.CJ14 U2.CJ16 U2.CJ18 U2.CJ20 U2.CJ22 U2.CJ24 U2.CJ26 U2.CJ28 U2.CJ30 U2.CJ32 U2.CJ34 U2.CJ36 U2.CJ38 U2.CJ40 U2.CJ42 U2.CJ44 U2.CJ46 U2.CJ48 U2.CJ50 U2.CJ52 U2.CJ54 U2.CJ56 U2.CJ58 U2.CJ60 U2.CJ62 U2.CK9 U2.CK23 U2.CK37 U2.CK51 U2.CL2 U2.CL16 U2.CL30 U2.CL44 U2.CL58 U2.CL62 U2.CM9 U2.CM23 U2.CM37 U2.CM51 U2.CN2 U2.CN16 U2.CN30 U2.CN44 U2.CN58 U2.CN62 U2.CP1 U2.CP3 U2.CP5 U2.CP7 U2.CP9 U2.CP11 U2.CP13 U2.CP15 U2.CP17 U2.CP19 U2.CP21 U2.CP23 U2.CP25 U2.CP27 U2.CP29 U2.CP31 U2.CP33 U2.CP35 U2.CP37 U2.CP39 U2.CP41 U2.CP43 U2.CP45 U2.CP47 U2.CP49 U2.CP51 U2.CP53 U2.CP55 U2.CP57 U2.CP59 U2.CP61 U2.CR2 U2.CR16 U2.CR30 U2.CR44 U2.CR58 U2.CT9 U2.CT23 U2.CT37 U2.CT51 U2.CU2 U2.CU16 U2.CU30 U2.CU44 U2.CU58 U2.CV9 U2.CV23 U2.CV37 U2.CV51 U2.CW2 U2.CW4 U2.CW6 U2.CW8 U2.CW10 U2.CW12 U2.CW14 U2.CW16 U2.CW18 U2.CW20 U2.CW22 U2.CW24 U2.CW26 U2.CW28 U2.CW30 U2.CW32 U2.CW34 U2.CW36 U2.CW38 U2.CW40 U2.CW42 U2.CW44 U2.CW46 U2.CW48 U2.CW50 U2.CW52 U2.CW54 U2.CW56 U2.CW58 U2.CW60 U2.CW62 U2.CY1 U2.CY9 U2.CY23 U2.CY37 U2.CY51 U2.CY61 U2.D1 U2.D3 U2.D11 U2.D25 U2.D39 U2.D53 U2.D61 U2.DA2 U2.DA16 U2.DA30 U2.DA44 U2.DA58 U2.DA60 U2.DA62 U2.DB1 U2.DB3 U2.DB9 U2.DB23 U2.DB37 U2.DB51 U2.DB59 U2.DB61 U2.DC2 U2.DC4 U2.DC16 U2.DC30 U2.DC44 U2.DC58 U2.DC60 U2.E2 U2.E4 U2.E6 U2.E8 U2.E10 U2.E12 U2.E14 U2.E16 U2.E18 U2.E20 U2.E22 U2.E24 U2.E26 U2.E28 U2.E30 U2.E32 U2.E34 U2.E36 U2.E38 U2.E40 U2.E42 U2.E44 U2.E46 U2.E48 U2.E50 U2.E52 U2.E54 U2.E56 U2.E58 U2.E60 U2.E62 U2.F11 U2.F25 U2.F39 U2.F53 U2.G4 U2.G18 U2.G32 U2.G46 U2.G60 U2.H11 U2.H25 U2.H39 U2.H53 U2.J4 U2.J18 U2.J32 U2.J46 U2.J60 U2.K1 U2.K3 U2.K5 U2.K7 U2.K9 U2.K11 U2.K13 U2.K15 U2.K17 U2.K19 U2.K21 U2.K23 U2.K25 U2.K27 U2.K29 U2.K31 U2.K33 U2.K35 U2.K37 U2.K39 U2.K41 U2.K43 U2.K45 U2.K47 U2.K49 U2.K51 U2.K53 U2.K55 U2.K57 U2.K59 U2.K61 U2.L4 U2.L18 U2.L32 U2.L46 U2.L60 U2.M11 U2.M25 U2.M39 U2.M53 U2.N4 U2.N18 U2.N32 U2.N46 U2.N60 U2.P11 U2.P25 U2.P39 U2.P53 U2.R2 U2.R4 U2.R6 U2.R8 U2.R10 U2.R12 U2.R14 U2.R16 U2.R18 U2.R20 U2.R22 U2.R24 U2.R26 U2.R28 U2.R30 U2.R32 U2.R34 U2.R36 U2.R38 U2.R40 U2.R42 U2.R44 U2.R46 U2.R48 U2.R50 U2.R52 U2.R54 U2.R56 U2.R58 U2.R60 U2.R62 U2.T11 U2.T25 U2.T39 U2.T53 U2.U4 U2.U18 U2.U32 U2.U46 U2.U60 U2.V11 U2.V25 U2.V39 U2.V53 U2.W4 U2.W18 U2.W32 U2.W46 U2.W60 U2.Y1 U2.Y3 U2.Y5 U2.Y7 U2.Y9 U2.Y11 U2.Y13 U2.Y15 U2.Y17 U2.Y19 U2.Y21 U2.Y23 U2.Y25 U2.Y27 U2.Y29 U2.Y31 U2.Y33 U2.Y35 U2.Y37 U2.Y39 U2.Y41 U2.Y43 U2.Y45 U2.Y47 U2.Y49 U2.Y51 U2.Y53 U2.Y55 U2.Y57 U2.Y59 U2.Y61 U3.7 U4.7 U5.7 U6.B3 U7.29(VSS) U7.49 U8.5 U8.11 U9.3 U10.3 U11.4 U11.17 U11.20 U11.24 U11.26 U11.33 U12.3 U13.4 U14.1 U15.B1 U16.A6 U16.C4 U16.D4 U16.E7 U16.G5 U16.H10 U16.J5 U16.K8 U16.N1 U16.N2 U16.N5 U16.P4 U16.P6 U17.65 U18.5 U18.9 U18.11 U18.20 U18.21 U19.3 U20.4 U21.4 U22.4 U23.7 U24.1 U25.1 U26.A1 U26.A13 U26.B8 U26.C3 U26.D2 U26.D5 U26.E2 U26.E11 U26.F3 U26.G7 U26.H12 U26.J4 U26.L9 U26.M6 U26.N1 U26.N13(GND__N13) U27.3(GND) U28.6 U28.10 U28.12 U28.14 U28.26 U28.28 U28.41 U28.53 U28.56 U28.57 U29.6 U29.13 U30.A1 U30.A13 U30.B8 U30.C3 U30.D5 U30.E11 U30.F3 U30.G7 U30.H12 U30.J4 U30.L9 U30.M6 U30.N1 U30.N13(GND__N13) U32.21 U32.25 U35.4 U35.7 U36.1 U36.9 U40.4 U40.7 U41.1 U41.9 U42.2 U43.B3 U43.C3 U43.D3 U43.D4 U43.E3 U44.5 U44.11 U45.5 U45.11 U46.6 U46.7 U46.8 U46.15 U46.16 U46.17 U46.29 U46.30 U46.31 U46.32 U47.40 U47.41(VSENSE1-) U47.53 U50.5 U50.11 U51.B3 U51.C3 U51.D3 U51.D4 U51.E3 U52.2 U55.A3 U55.A4 U55.A5 U55.A6 U55.B1 U55.B3 U55.B4 U55.B5 U55.B6 U55.C1 U55.C2 U55.C3 U55.C4 U55.C5 U55.C6 U55.D2 U55.D3 U55.D4 U55.D5 U55.D6 U55.E5 U55.E6 U55.F5 U55.F6 U55.F7 U55.G5 U55.G6 U55.G7 U55.G8 U55.H5 U55.H6 U55.H7 U55.H8 U55.J2 U55.J3 U55.J4 U55.J5 U55.J6 U55.K2 U55.K3 U55.K4 U55.K5 U55.K6 U55.L1 U55.L3 U55.L4 U55.L5 U55.L6 U55.M3 U55.M4 U55.M5 U55.M6 U56.A1 U56.A2 U56.A3 U56.A4 U56.A5 U56.A6 U56.A7 U56.A8 U56.A9 U56.A10 U56.A11 U56.B1 U56.B9 U56.B10 U56.B11 U56.F3 U56.F7 U56.F8 U56.G1 U56.G2 U56.G3 U56.G4 U56.G5 U56.G6 U56.G7 U56.G8 U57.A4 U57.A5 U57.B1 U57.B2 U57.C5 U57.D3 U57.D4 U57.D5 U57.E1 U57.E2 U57.F5 U57.G3 U57.G4 U57.G5 U57.H1 U57.H2 U57.J5 U57.K3 U57.K4 U57.L1 U57.L2 U58.A4 U58.A5 U58.B1 U58.B2 U58.C5 U58.D3 U58.D4 U58.D5 U58.E1 U58.E2 U58.F5 U58.G3 U58.G4 U58.G5 U58.H1 U58.H2 U58.J5 U58.K3 U58.K4 U58.L1 U58.L2 U59.4 U59.8 U59.11 U60.4 U60.8 U60.11 U61.B3 U61.C3 U61.D3 U61.D4 U61.E3 U63.1 U63.2 U63.9 U64.5 U64.11 U65.A1 U65.A2 U65.A3 U65.A4 U65.A5 U65.A6 U65.A7 U65.A8 U65.A9 U65.A10 U65.A11 U65.B1 U65.B9 U65.B10 U65.B11 U65.F3 U65.F7 U65.F8 U65.G1 U65.G2 U65.G3 U65.G4 U65.G5 U65.G6 U65.G7 U65.G8 U66.A2 U66.A3 U66.A5 U66.A6 U66.B2 U66.B3 U66.B5 U66.B6 U66.C2 U66.C6 U66.D3 U66.D4 U66.D5 U66.E2 U66.E6 U66.F2 U66.F3 U66.F5 U66.F6 U66.G2 U66.G3 U66.G5 U66.G6 U67.7 U68.7 U70.A2 U70.A3 U70.A5 U70.A6 U70.B2 U70.B3 U70.B5 U70.B6 U70.C2 U70.C6 U70.D3 U70.D4 U70.D5 U70.E2 U70.E6 U70.F2 U70.F3 U70.F5 U70.F6 U70.G2 U70.G3 U70.G5 U70.G6 U71.A2 U71.A3 U71.A4 U71.A5 U71.A6 U71.A7 U71.A8 U71.B2 U71.B3 U71.B4 U71.B5 U71.B6 U71.B7 U71.C2 U71.C4 U71.C5 U71.C6 U71.C7 U71.C8 U71.D2 U71.D5 U71.E1 U71.E9 U71.F1 U71.F8 U71.G1 U71.G8 U71.G9 U71.H1 U71.H8 U71.H9 U71.J2 U71.J8 U71.K2 U71.K5 U71.K6 U71.K7 U71.K8 U71.L2 U71.L3 U71.L4 U71.L5 U71.L6 U71.L7 U71.M2 U71.M3 U71.M4 U71.M5 U71.M6 U71.M7 U71.M8 U72.7 U72.15 U72.24 U72.25 U73.4 U76.7 U76.8 U76.9 U76.17 U76.18 U76.19 U76.27 U76.31 U76.39 U76.40 U76.41 U77.7 U77.8 U77.9 U77.17 U77.18 U77.19 U77.27 U77.31 U77.39 U77.40 U77.41 U78.7 U78.8 U78.9 U78.17 U78.18 U78.19 U78.27 U78.31 U78.39 U78.40 U78.41 U79.7 U79.8 U79.9 U79.17 U79.18 U79.19 U79.27 U79.31 U79.39 U79.40 U79.41 U124.B5 U124.C1 U124.C2 U124.D5 U125.B2 U125.B6 U125.C3 U125.C4 U125.C5 U125.C6 U125.C7 U125.D5 U125.D6 U125.D7 U125.E5 U125.E6 U125.E7 U125.F5 U125.F6 U125.F7 U125.G6 U125.G7 U126.3 Y1.2 Y3.2 Y3.4 Y4.2 Y4.4
GND_CHS: C341.1 J13.6 J13.7 J13.8 J13.9 R329.1
GND_ETH_PHY: C706.1 J8.18 J8.19 R724.2
GND_QSFPDD0_CAGE: B1.1 B1.2 B1.3 B1.4 B1.5 B1.6 B1.7 B1.8 B1.9(PIN9) B1.10 B1.11 B1.12 C156.1 R94.2
GND_QSFPDD1_CAGE: B2.1 B2.2 B2.3 B2.4 B2.5 B2.6 B2.7 B2.8 B2.9(PIN9) B2.10 B2.11 B2.12 C171.1 R97.2
GNDSENSE: C274.1 R239.1 U2.BA26
PVCC: C1839.2 C1867.2 C1868.1 C1995.2 C1997.2 C1999.2 C2029.2 C2031.2 R5944.2 R6087.2 R6088.2 R6089.2 U76.28 U76.29 U77.28 U77.29 U78.28 U78.29 U79.28 U79.29 U124.A1 U124.B1(VOUT2_2) U124.D1 U124.E1
SVIN0: U56.E5 U56.F4
SVIN1: U65.E5 U65.F4
VBUS_5V: J13.1(VBUS) R340.1
VCC_HSSI_AGND: C1935.2 C1940.2 R6005.1 R6013.2 R6015.1 R6022.1 R6023.2 ST11.1 U55.F9 U55.F10 U55.G9 U55.G10
VCC_HSSI_EN: R370.2 R6014.1
VCC_HSSI_PG: R6012.1 U30.A7 U55.D9 U55.J7
VCC_INT: C1934.1 U55.E7
VCC_SENSE: R238.2 R5947.2 R6115.1
VCCA_PLL: C1659.1 C1660.2 C1663.2 C1665.2 C1674.2 FB17.2 FB18.2 R5785.2 U125.A1 U125.A2 U125.A3 U125.A4 U125.A5 U125.F3 U125.G1 U125.G2 U125.G3
VCCA_PLL_EN: R5789.2 R6273.2
VCCA_PLL_FLTR: C1216.1 C1217.1 C1218.1 C1222.1 C1223.1 C1224.1 C1225.1 C1319.1 C1320.1 C1321.2 FB17.1 FB18.1 R5784.1 U2.AA28 U2.AA30 U2.AA32 U2.AA34 U2.CC28 U2.CC30 U2.CC32 U2.CC34
VCCA_PLL_PG: R5776.1 U30.E6 U125.B5
VCCAPLL_AGND: C1654.2 C1656.1 R978.2 ST31.2 U125.A7
VCCCLK_GXPL1: C275.1 C276.1 FB38.1 U2.BH45 U2.BH47
VCCFUSE_GXP: C1201.1 C1202.1 FB12.1 FB13.1 U2.BR44
VCCFUSEWR_EN: R380.2 R547.1 R549.2 U50.7
VCCFUSEWR_PG: R788.1 U30.N12 U50.4
VCCFUSEWR_SDM: C293.1 C557.2 C558.1 C559.1 C560.1 C1235.1 R546.2 U2.BY49 U2.CB49 U50.1 U50.2(VOUT2)
VCCH_GXER1_AGND: R6294.1 ST17.1
VCCH_GXER1_EN: R703.2 R6084.2
VCCH_GXER1_PG: R6079.1 U30.C11 U66.D2
VCCH_GXPL1: C1227.1 C1228.1 C1229.1 C1230.1 C1231.1 C1232.1 C1233.1 C1234.1 FB11.2 U2.AN46 U2.AU46 U2.AV47 U2.AW46 U2.AY47 U2.BC46 U2.BE46
VCCH_VOSNS+: C1933.1 R6101.1 U55.A11 U55.M11
VCCH_VOSNS-: C1933.2 ST21.2 U55.A12 U55.M12
VCCL_HPS_AGND: R5999.1 R6001.1 R6091.2 ST16.1 U65.E1 U65.F5
VCCL_HPS_EN: R365.2 R5997.1
VCCL_HPS_MGN: R6000.1 R6001.2 U65.B8
VCCL_HPS_PG: R5994.1 U30.A10 U65.C7
VCCL_SDM_EN: R364.2 R5990.2
VCCL_SDM_PG: R5984.1 U30.B10 U51.C2
VCCLSENSE: C274.2 R238.1 U2.BB25
VCCPLL_HPS: C291.1 C292.1 FB14.2 U2.AA22 U2.AC22
VCCPLL_SDM: C289.1 C290.1 FB15.2 U2.BY47 U2.CB47
VCCPLLDIG_HPS: C278.1 C279.1 FB10.1 U2.AB23 U2.AD23
VCCPLLDIG_SDM: C280.1 C281.1 FB9.1 U2.BY45 U2.CB45
VCCR_AGND: R6029.1 R6031.1 R6092.2 ST12.1 U56.E1 U56.F5
VCCR_EN: R371.2 R6027.1
VCCR_MGN: R6030.1 R6031.2 U56.B8
VCCR_PG: R6024.1 U30.A4 U56.C7
VCCRTPLL_GXER1: C282.1 C283.1 C1448.1 C1449.1 C1450.1 FB16.1 U2.BE16 U2.BG16
VDD25OUT: TP47.1 U71.J4
VDD33_OUT1: C7766.1 R6261.2 R6265.2 R6269.2 U46.20
VDDIM: C265.1 C266.2 U16.C1 U16.C2
VSS_SENSE: R239.2 R5949.2 R6114.1
0P6V_DDR4_VTT_CH23_PG: R653.2 U30.F8 U60.9
0P6V_VREF_DDR4_CH01: C18.1 C24.1 C54.2 C284.1 C285.1 C286.1 C287.1 C658.1 J1.146 J2.146 U2.AA24(VREFB3DN0) U2.AA26 U2.AA36 U2.AA38 U59.6
0P6V_VREF_DDR4_CH23: C90.1 C100.1 C123.1 C133.1 C294.1 C295.1 C296.1 C297.1 C672.1 J3.146 J4.146 U2.CC24 U2.CC26 U2.CC36 U2.CC38 U60.6
