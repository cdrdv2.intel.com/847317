# Allegro board TS28247BC0_FM61_agilex_PCIe_DEVKIT_ADI_REVB1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_DIMM_CH0_DQ68: length 42.1
  L16_SIG6 w0.081: v1(133.97,81.43) 133.97,80.51 132.6,79.15 130.64,79.15 129.14,80.64 129.14,81.68 128.89,81.93 128.53,81.93 128.39,82.07 128.39,84.63 126.39,86.64 125.94,86.64 125.73,86.85 125.31,86.85 124.78,87.38 124.78,87.93 124,88.71 123.13,88.71 122.76,89.08 122.76,89.69 122.52,89.92 121,89.92 120.79,90.14 114.66,90.14 113.94,89.42 108.77,89.42 107.47,90.71 106.67,90.71 106.32,91.07 105.97,91.07 105.76,91.28 105.76,92.31 105.48,92.59 105.48,92.98 105.38,93.08 105.11,93.08 105.01,92.98 105.01,92.48 105.29,92.2 v1(105.29,91.44)
DDR4_DIMM_CH0_DQ69: length 44.2
  L16_SIG6 w0.081: v1(106.14,97.44) 106.52,97.82 108.08,97.82 108.3,97.6 108.3,91.31 108.57,91.04 110.2,91.04 112.14,92.98 123.53,92.98 125.25,91.26 125.25,91.05 126.78,89.52 127.46,89.52 128.29,88.7 128.29,88.23 128.58,87.93 129.59,87.93 130.99,86.53 130.99,82.94 131.11,82.82 131.11,82.19 130.99,82.08 130.99,81.76 131.08,81.67 131.08,81.19 130.99,81.09 130.99,80.77 131.73,80.03 132.41,80.03 133.1,80.72 v1(133.1,80.93)
DDR4_DIMM_CH0_DQ70: length 43.7
  L16_SIG6 w0.081: v1(111.19,91.44) 111.95,91.44 112.52,92.01 112.52,92.54 112.63,92.64 112.84,92.64 112.93,92.55 112.93,92.27 113.03,92.17 113.17,92.17 113.27,92.27 113.27,92.55 113.37,92.64 113.51,92.64 113.6,92.55 113.6,92.27 113.7,92.17 113.84,92.17 113.94,92.27 113.94,92.55 114.04,92.64 114.18,92.64 114.27,92.55 114.27,92.27 114.37,92.17 114.51,92.17 114.61,92.27 114.61,92.55 114.71,92.64 114.9,92.64 115,92.55 115,92.28 115.15,92.13 115.66,92.13 115.87,92.35 115.87,92.54 115.97,92.64 116.64,92.64 116.76,92.53 116.76,92.27 116.87,92.16 117.36,92.16 117.54,92.35 117.54,92.52 117.65,92.62 117.83,92.62 117.97,92.48 117.97,92.29 118.07,92.19 118.21,92.19 118.3,92.29 118.3,92.55 118.4,92.64 118.54,92.64 118.64,92.55 118.64,92.29 118.74,92.19 118.88,92.19 118.98,92.29 118.98,92.55 119.07,92.64 119.22,92.64 119.35,92.51 119.35,92.23 119.58,92 119.9,92 120.13,92.22 120.13,92.52 120.23,92.63 120.47,92.63 120.57,92.53 120.57,92.34 120.67,92.25 120.81,92.25 120.91,92.34 120.91,92.53 121.01,92.63 121.14,92.63 121.24,92.53 121.24,92.34 121.34,92.25 121.48,92.25 121.58,92.34 121.58,92.53 121.68,92.63 121.81,92.63 121.91,92.52 121.91,92.32 122.09,92.14 122.46,92.14 122.68,92.36 122.68,92.5 122.8,92.63 123.41,92.63 124.8,91.24 124.8,91.03 126.65,89.18 127.33,89.18 127.81,88.7 127.81,88.23 128.45,87.58 129.31,87.58 129.48,87.41 129.48,86.2 129.58,86.11 129.72,86.11 129.82,86.2 129.82,86.86 129.92,86.96 130.06,86.96 130.15,86.86 130.15,83.2 130.36,83 130.54,83 130.88,82.65 130.88,82.28 130.75,82.15 130.75,81.7 130.88,81.58 130.88,81.27 130.69,81.09 130.69,80.77 130.93,80.53 130.93,80.12 131.34,79.71 132.57,79.71 133.47,80.61 133.47,81.09 133.34,81.22 133.34,81.69 v1(133.1,81.93)
DDR4_DIMM_CH0_DQ71: length 42.3
  L16_SIG6 w0.081: v1(112.09,97.44) 112.38,97.44 113.98,95.84 116,95.84 116.73,96.57 117.54,96.57 117.64,96.48 117.64,96.34 117.54,96.24 117.01,96.24 116.91,96.14 116.91,96 117.01,95.9 118.02,95.9 118.64,96.53 120.09,96.53 120.19,96.43 120.19,96.29 120.09,96.19 119.05,96.19 118.95,96.09 118.95,95.83 119.05,95.73 124.77,95.73 125.55,94.94 127.08,94.94 129.22,92.8 130.11,92.8 130.87,92.04 132.23,92.04 134.85,89.43 134.85,86.74 134.75,86.64 134.49,86.64 134.39,86.54 134.39,86.4 134.49,86.3 134.75,86.3 134.85,86.21 134.85,86.07 134.75,85.97 134.49,85.97 134.39,85.87 134.39,85.73 134.49,85.63 134.75,85.63 134.85,85.54 134.85,85.4 134.75,85.3 134.49,85.3 134.39,85.2 134.39,85.06 134.49,84.96 134.75,84.96 134.85,84.86 134.85,84.73 134.75,84.63 134.49,84.63 134.39,84.53 134.39,84.39 134.49,84.29 134.75,84.29 134.85,84.19 134.85,84.06 134.75,83.96 134.49,83.96 134.39,83.86 134.39,83.72 134.49,83.62 134.75,83.62 134.85,83.52 134.85,83.31 v1(133.97,82.43)
DDR4_DIMM_CH0_DQS_N0: length 75.7
  L16_SIG6 w0.079: v1(119.24,78.93) 119.24,79.15 119.14,79.25 119,79.25 118.92,79.17 118.9,79.13 arc(118.86,79.04) 118.79,78.96 118.77,78.95 arc(118.63,78.85) 118.46,78.81 118.33,78.81 arc(118.2,78.78) 118.1,78.7 117.95,78.51 arc(117.77,78.37) 117.55,78.31 117.47,78.31 arc(117.35,78.28) 117.25,78.2 117.1,78.01 arc(116.92,77.87) 116.69,77.81 116.61,77.81 arc(116.48,77.78) 116.38,77.7 116.29,77.58 arc(116.04,77.38) 115.74,77.31 arc(115.62,77.29) 115.52,77.2 115.39,77.05 arc(115.18,76.88) 114.91,76.81 arc(114.75,76.78) 114.63,76.68 114.5,76.51 arc(114.32,76.37) 114.09,76.31 114.01,76.31 arc(113.88,76.29) 113.78,76.2 113.63,76.01 arc(113.45,75.87) 113.23,75.81 113.14,75.81 arc(112.92,75.87) 112.74,76.01 112.58,76.21 arc(112.48,76.29) 112.36,76.31 112.28,76.31 arc(112.15,76.29) 112.05,76.2 111.9,76.01 arc(111.72,75.87) 111.5,75.81 111.41,75.81 arc(111.19,75.87) 111.01,76.01 110.86,76.21 arc(110.76,76.29) 110.63,76.31 110.54,76.31 arc(110.41,76.29) 110.31,76.2 110.16,76.01 arc(109.98,75.87) 109.76,75.81 109.67,75.81 arc(109.44,75.87) 109.26,76.01 109.11,76.21 arc(109.01,76.29) 108.88,76.31 108.82,76.31 arc(108.69,76.29) 108.59,76.2 108.44,76.01 arc(108.26,75.87) 108.04,75.81 107.94,75.81 arc(107.72,75.87) 107.54,76.01 107.38,76.21 arc(107.28,76.29) 107.16,76.31 107.07,76.31 arc(106.94,76.29) 106.84,76.2 106.69,76.01 arc(106.51,75.87) 106.28,75.81 106.22,75.81 arc(105.99,75.87) 105.81,76.01 105.66,76.21 arc(105.56,76.29) 105.43,76.31 105.35,76.31 arc(105.13,76.37) 104.95,76.51 104.8,76.7 arc(104.7,76.79) 104.57,76.81 104.44,76.81 arc(104.21,76.87) 104.03,77.01 103.88,77.2 arc(103.78,77.29) 103.66,77.31 103.61,77.31 arc(103.38,77.37) 103.2,77.51 103.05,77.7 arc(102.95,77.79) 102.83,77.81 102.75,77.81 arc(102.52,77.87) 102.34,78.01 102.19,78.2 arc(102.09,78.29) 101.97,78.31 101.91,78.31 arc(101.66,78.37) 101.46,78.53 101.32,78.7 arc(101.22,78.78) 101.1,78.81 101.02,78.81 arc(100.79,78.87) 100.61,79.01 100.46,79.2 arc(100.36,79.28) 100.24,79.31 100.14,79.31 arc(100.02,79.28) 99.92,79.2 99.79,79.04 arc(99.58,78.87) 99.32,78.81 99.31,78.81 arc(99.06,78.87) 98.86,79.03 98.74,79.19 arc(98.62,79.29) 98.46,79.32 93.54,79.32 arc(93.3,79.28) 93.1,79.14 92.96,79 arc(92.75,78.86) 92.51,78.81 92.35,78.81 arc(92.12,78.87) 91.94,79.01 91.79,79.2 arc(91.69,79.28) 91.57,79.31 91.46,79.31 arc(91.24,79.37) 91.06,79.51 90.9,79.7 arc(90.8,79.78) 90.68,79.81 90.62,79.81 arc(90.39,79.87) 90.21,80.01 90.06,80.2 arc(89.96,80.28) 89.83,80.31 85.11,80.31 84.62,79.82 79.03,79.82 74.88,83.97 71.71,83.97 70.35,85.33 70.35,87.9 68.29,89.96 68.29,91.59 68.07,91.8 68.07,92.58 68.5,93.01 69.42,93.01 69.72,93.3 69.72,93.72 69.53,93.91 68.57,93.91 68.28,94.19 68.28,94.66 68.57,94.95 69.54,94.95 69.72,95.12 69.72,95.42 69.95,95.66 71.62,95.66 72.4,96.44 72.4,97.18 v1(72.14,97.44)
DDR4_DIMM_CH0_DQS_N1: length 57.6
  L12_SIG4 w0.085: v1(81.49,97.44) 81.81,97.12 81.81,96.53 81.61,96.33 80.23,96.33 79.97,96.07 79.97,95.55 80.31,95.2 81.56,95.2 81.65,95.11 81.65,94.86 81.35,94.56 78.72,94.56 78.42,94.27 78.42,93.41 79.13,92.71 79.13,91.94 81.07,90 85.37,90 87.54,87.82 88.23,87.82 90.34,85.71 91.7,85.71 93.6,83.81 105.05,83.81 106.05,84.8 115.19,84.8 116.24,83.75 116.54,83.75 117.68,82.62 arc(117.74,82.53) 117.76,82.43 arc(117.77,82.33) 117.8,82.24 117.85,82.1 117.97,81.98 arc(118.16,81.86) 118.37,81.82 118.43,81.82 arc(118.51,81.8) 118.58,81.75 118.7,81.63 118.76,81.49 118.94,81.31 119.09,81.31 119.24,81.16 v1(119.24,80.93)
DDR4_DIMM_CH0_DQS_N2: length 59.2
  L16_SIG6 w0.079: v1(90.84,97.44) 91.15,97.13 91.15,96.83 90.9,96.58 89.23,96.58 88.93,96.28 88.93,95.84 89.23,95.54 91.77,95.54 92.15,95.91 93.14,95.91 93.36,95.69 93.36,95.13 93.18,94.95 89.56,94.95 89.29,94.68 89.29,94.28 89.79,93.78 89.79,93.56 89.32,93.09 88.92,93.09 88.5,92.68 88.5,91.78 90.42,89.87 99.5,89.87 102.55,86.82 104.67,86.82 106.06,85.43 106.67,85.43 107.28,84.82 115.51,84.82 116.49,85.8 118.7,85.8 119.68,84.82 120.48,84.82 121.47,83.82 122.04,83.82 122.89,82.97 123.15,82.97 123.31,82.81 123.75,82.81 124.23,82.33 124.5,82.33 124.65,82.27 124.74,82.18 124.82,81.98 124.99,81.81 125.15,81.81 125.31,81.66 v1(125.31,81.43)
DDR4_DIMM_CH0_DQS_N3: length 53.6
  L12_SIG4 w0.085: v1(125.31,78.43) 125.31,78.71 125.41,78.81 125.46,78.81 125.55,78.78 125.6,78.73 125.67,78.55 125.78,78.44 arc(125.92,78.35) 126.09,78.31 126.21,78.31 arc(126.44,78.37) 126.62,78.51 126.77,78.7 arc(126.87,78.78) 126.99,78.81 127.08,78.81 arc(127.3,78.87) 127.48,79.01 127.63,79.2 arc(127.73,79.28) 127.86,79.31 127.92,79.31 arc(128.13,79.36) 128.31,79.48 128.37,79.53 arc(128.48,79.69) 128.51,79.88 128.51,80.03 128.39,80.34 128.39,80.52 128.51,80.81 128.51,81.05 128.38,81.37 128.38,81.49 128.51,81.81 128.51,82.06 128.38,82.38 128.38,89.17 126.84,90.71 126.84,92.68 123.54,95.98 122.94,95.98 122.59,96.33 121.19,96.33 120.84,95.98 119.89,95.98 119.58,95.68 119.13,95.68 118.82,95.98 117.9,95.98 117.57,96.32 117.02,96.32 116.76,96.06 116.76,95.59 116.67,95.5 116.09,95.5 116,95.59 116,96.06 115.74,96.32 113.75,96.32 113.63,96.44 113.63,96.78 113.37,97.04 112.77,97.04 112.51,96.78 112.51,96.25 112.39,96.12 112.01,96.12 111.85,96.28 111.85,97.14 111.48,97.51 111.48,98.32 111.12,98.68 110.58,98.68 109.99,98.09 109.65,98.09 109.06,98.68 108.42,98.68 107.83,98.09 107.51,98.09 106.92,98.68 106.46,98.68 105.87,98.09 105.21,98.09 104.62,98.68 100.71,98.68 100.46,98.43 100.46,97.71 v1(100.19,97.44)
DDR4_DIMM_CH0_DQS_N4: length 44.8
  L03_SIG1 w0.079: v4(155.44,97.44) 155.73,97.15 155.73,96.67 156.23,96.18 157.03,96.18 157.2,96.01 157.2,95.76 157.03,95.59 154.4,95.59 154.02,95.21 151.77,95.21 150.69,94.14 150.15,94.14 149.19,95.1 146.19,95.1 145.37,94.28 142.47,94.28 141.33,93.14 140.68,93.14 139.74,92.2 139.04,92.2 137.94,91.1 137.94,90.84 137.29,90.18 135.31,90.18 134.18,89.05 133.51,89.05 132.26,87.8 131.6,87.8 130.94,87.14 130.29,87.14 129.8,86.65 129.8,82.52 130.01,82 130.01,81.85 129.89,81.56 129.89,81.31 130.01,81.01 130.01,80.85 129.9,80.57 129.9,80.26 130.01,80.01 130.01,79.83 129.9,79.57 129.9,79.31 130.01,79.03 130.23,78.81 130.78,78.81 130.99,79.02 131.06,79.2 131.15,79.28
  L03_SIG1 w0.081: v4(131.37,78.93) 131.35,78.94 131.35,79.2 131.27,79.28 131.15,79.28
DDR4_DIMM_CH0_DQS_N5: length 53.3
  L16_SIG6 w0.079: 160.56,98.26 163.83,98.26 163.93,98.16 163.93,97.95 164.03,97.85 164.16,97.85 164.26,97.95 164.26,98.16 164.36,98.26 164.94,98.26 165.1,98.09 165.1,97.75 v1(164.79,97.44) ; v1(137.43,78.43) 137.43,78.71 137.53,78.81 137.74,78.81 137.92,79 138.05,79.31 138.05,79.52 137.91,79.87 137.91,79.97 arc(137.93,80.06) 137.97,80.13 139.11,81.26 ; 144.35,90.03 145.02,90.03 145.49,90.5 145.49,91.43 145.89,91.82 151.34,91.82 151.67,91.49 154.11,91.49 154.79,90.81 162.79,90.81 164.54,92.57 164.54,94.71 164.06,95.19
  L16_SIG6 w0.081: 144.35,90.03 141.53,87.2 141.53,84.06 139.89,82.42 139.11,81.26 ; 160.56,98.26 159.75,97.45 159.75,95.84 160.39,95.19 164.06,95.19
DDR4_DIMM_CH0_DQS_N6: length 60.1
  L03_SIG1 w0.079: 157.11,83.48 157.36,83.48 160.4,86.53 161.02,86.53 161.84,87.35 161.84,87.58 163.49,89.23 163.49,89.38 164.17,90.06 171.25,90.06 174.29,93.1 174.29,93.56 173.9,93.94 169.7,93.94 169.44,94.2 169.44,94.52 169.7,94.78 173.69,94.78 174.08,95.16 174.08,95.61 174.17,95.71 174.26,95.71 ; 155.33,81.84 153.31,79.82 147.18,79.82 144.18,82.81 139.06,82.81 138.7,82.66 138.08,82.25 137.98,82.15 137.92,82 137.74,81.81 137.53,81.81 137.43,81.71 v4(137.43,81.43) ; v4(174.14,97.44) 174.44,97.44 174.56,97.55 174.56,97.75 174.46,97.86 173.85,97.86 ; 174.26,96.04 174.17,96.04 174.08,96.14
  L03_SIG1 w0.081: 173.85,97.86 173.56,97.57 173.56,97.19 174.08,96.68 174.08,96.14 ; 174.26,95.71 174.36,95.8 174.36,95.94 174.26,96.04 ; 157.11,83.48 155.47,81.84 155.33,81.84
DDR4_DIMM_CH0_DQS_N7: length 67.3
  L07_SIG3 w0.085: v1(137.43,73.43) 137.43,73.67 137.57,73.81 137.71,73.81 137.93,74.04 138.04,74.3 138.04,74.54 137.97,74.7 arc(137.93,74.82) 137.92,74.95 arc(137.95,75.07) 138.02,75.18 138.05,75.21 arc(138.16,75.28) 138.3,75.31 138.33,75.31 arc(138.56,75.36) 138.74,75.51 138.89,75.7 arc(138.99,75.78) 139.12,75.81 139.2,75.81 arc(139.42,75.86) 139.6,76.01 139.75,76.2 arc(139.85,76.28) 139.98,76.31 140.07,76.31 arc(140.29,76.36) 140.47,76.51 140.62,76.7 arc(140.72,76.78) 140.85,76.81 140.94,76.81 arc(141.07,76.78) 141.17,76.7 141.32,76.51 arc(141.5,76.36) 141.72,76.31 141.8,76.31 arc(142.03,76.36) 142.21,76.51 142.36,76.7 arc(142.46,76.78) 142.59,76.81 155.15,76.81 156.07,77.72 156.07,78.42 156.5,78.85 158.11,78.85 158.64,79.39 159.31,79.39 159.98,80.06 159.98,80.57 164.52,85.1 167.85,85.1 169.46,86.71 175.63,86.71 177.56,88.64 180.46,88.64 181.03,89.21 181.03,90.39 183,92.35 183,93.16 181.64,94.52 181.64,94.95 181.87,95.17 183.52,95.17 183.8,95.46 183.8,95.93 183.5,96.24 182.35,96.24 182.21,96.37 182.21,96.97 182.57,97.33 182.71,97.33 182.81,97.23 182.95,97.23 183.05,97.33 183.05,97.47 182.95,97.57 182.95,97.7 183.08,97.84 183.72,97.84 183.83,97.73 183.83,97.54 183.73,97.44 v1(183.49,97.44)
DDR4_DIMM_CH0_DQS_N8: length 45.6
  L16_SIG6 w0.079: v1(131.37,80.93) 131.37,81.21 131.47,81.31 131.53,81.31 131.6,81.28 131.64,81.25 131.7,81.1 131.86,80.94 arc(132,80.85) 132.16,80.81 132.27,80.81 arc(132.46,80.85) 132.62,80.96 132.69,81.03 arc(132.81,81.2) 132.85,81.4 132.85,81.45 arc(132.84,81.55) 132.81,81.65 132.75,81.8 arc(132.73,81.86) 132.72,81.92 132.72,82 arc(132.74,82.09) 132.8,82.17 133.55,82.93 133.55,89.09 131.51,91.13 130.31,91.13 129.38,92.06 129.13,92.06 127.01,94.18 125.49,94.18 124.71,94.96 112.65,94.96 112.53,95.08 109.37,95.08 109.13,95.32 109.13,95.69 109.41,95.96 112.17,95.96 112.4,96.2 112.4,96.58 110.75,98.22 110.09,98.22 109.85,97.99 109.85,97.75 v1(109.54,97.44)
DDR4_DIMM_CH0_DQS_P0: length 75.5
  L16_SIG6 w0.079: v1(119.24,79.93) 119.24,79.58 119.14,79.48 118.91,79.48 118.73,79.3 118.69,79.22 arc(118.67,79.17) 118.63,79.13 118.61,79.11 arc(118.54,79.06) 118.46,79.04 118.33,79.04 arc(118.1,78.99) 117.92,78.84 117.77,78.65 arc(117.67,78.57) 117.55,78.54 117.47,78.54 arc(117.25,78.49) 117.07,78.34 116.92,78.15 arc(116.82,78.07) 116.69,78.04 116.61,78.04 arc(116.38,77.99) 116.2,77.84 116.11,77.72 arc(115.94,77.59) 115.74,77.54 arc(115.52,77.49) 115.34,77.35 115.21,77.19 arc(115.08,77.08) 114.91,77.04 arc(114.65,76.98) 114.45,76.82 114.32,76.65 arc(114.22,76.57) 114.09,76.54 114.01,76.54 arc(113.78,76.49) 113.6,76.35 113.45,76.15 arc(113.35,76.07) 113.23,76.04 113.14,76.04 arc(113.02,76.07) 112.92,76.15 112.76,76.35 arc(112.58,76.49) 112.36,76.54 112.28,76.54 arc(112.05,76.49) 111.87,76.35 111.72,76.15 arc(111.62,76.07) 111.5,76.04 111.41,76.04 arc(111.29,76.07) 111.19,76.15 111.04,76.35 arc(110.86,76.49) 110.63,76.54 110.54,76.54 arc(110.31,76.49) 110.13,76.35 109.98,76.15 arc(109.88,76.07) 109.76,76.04 109.67,76.04 arc(109.54,76.07) 109.44,76.15 109.29,76.35 arc(109.11,76.49) 108.88,76.54 108.82,76.54 arc(108.59,76.49) 108.41,76.35 108.26,76.15 arc(108.16,76.07) 108.04,76.04 107.94,76.04 arc(107.82,76.07) 107.72,76.15 107.56,76.35 arc(107.38,76.49) 107.16,76.54 107.07,76.54 arc(106.84,76.49) 106.66,76.35 106.51,76.15 arc(106.41,76.07) 106.28,76.04 106.22,76.04 arc(106.09,76.07) 105.99,76.15 105.84,76.35 arc(105.66,76.49) 105.43,76.54 105.35,76.54 arc(105.23,76.57) 105.13,76.65 104.98,76.85 arc(104.8,76.99) 104.57,77.04 104.44,77.04 arc(104.31,77.07) 104.21,77.15 104.06,77.35 arc(103.88,77.49) 103.66,77.54 103.61,77.54 arc(103.48,77.57) 103.38,77.65 103.23,77.85 arc(103.05,77.99) 102.83,78.04 102.75,78.04 arc(102.62,78.07) 102.52,78.15 102.37,78.35 arc(102.19,78.49) 101.97,78.54 101.91,78.54 arc(101.76,78.58) 101.64,78.68 101.5,78.85 arc(101.32,78.99) 101.1,79.04 101.02,79.04 arc(100.89,79.07) 100.79,79.15 100.64,79.35 arc(100.46,79.49) 100.24,79.54 100.14,79.54 arc(99.92,79.49) 99.74,79.34 99.61,79.18 arc(99.48,79.08) 99.32,79.04 99.31,79.04 arc(99.16,79.08) 99.04,79.17 98.92,79.33 arc(98.72,79.49) 98.46,79.55 93.54,79.55 arc(93.21,79.49) 92.94,79.3 92.79,79.16 arc(92.66,79.07) 92.51,79.04 92.35,79.04 arc(92.22,79.07) 92.12,79.15 91.97,79.35 arc(91.79,79.49) 91.57,79.54 91.46,79.54 arc(91.34,79.57) 91.24,79.65 91.08,79.85 arc(90.9,79.99) 90.68,80.04 90.62,80.04 arc(90.49,80.07) 90.39,80.15 90.24,80.35 arc(90.06,80.49) 89.83,80.54 85.02,80.54 84.53,80.05 79.12,80.05 74.97,84.2 71.81,84.2 70.58,85.43 70.58,87.99 68.52,90.05 68.52,91.68 68.3,91.9 68.3,92.49 68.6,92.78 69.52,92.78 69.94,93.21 69.94,93.81 69.62,94.14 68.66,94.14 68.51,94.29 68.51,94.57 68.66,94.72 69.64,94.72 69.94,95.03 69.94,95.33 70.05,95.43 71.71,95.43 72.63,96.35 72.63,97.08 v1(72.99,97.44)
DDR4_DIMM_CH0_DQS_P1: length 57.2
  L12_SIG4 w0.085: v1(82.34,97.44) 82.04,97.14 82.04,96.43 81.71,96.1 80.32,96.1 80.2,95.97 80.2,95.64 80.41,95.43 81.65,95.43 81.88,95.2 81.88,94.77 81.44,94.34 78.81,94.34 78.65,94.17 78.65,93.51 79.36,92.8 79.36,92.04 81.17,90.23 85.46,90.23 87.64,88.05 88.32,88.05 90.44,85.93 91.8,85.93 93.69,84.04 104.96,84.04 105.95,85.03 115.29,85.03 116.34,83.98 116.64,83.98 117.84,82.78 arc(117.95,82.62) 117.99,82.43 arc(117.99,82.37) 118.01,82.33 118.05,82.23 118.13,82.14 arc(118.24,82.07) 118.37,82.04 118.43,82.04 arc(118.6,82.01) 118.75,81.91 118.9,81.76 118.95,81.62 119.03,81.54 119.14,81.54 119.24,81.64 v1(119.24,81.93)
DDR4_DIMM_CH0_DQS_P2: length 58.9
  L16_SIG6 w0.079: v1(125.31,82.43) 125.31,82.14 125.2,82.04 125.08,82.04 125.02,82.11 124.93,82.31 124.78,82.46 124.54,82.56 124.33,82.56 123.84,83.04 123.41,83.04 123.25,83.2 122.98,83.2 122.13,84.05 121.57,84.05 120.57,85.05 119.78,85.05 118.79,86.03 116.4,86.03 115.41,85.04 107.38,85.04 106.76,85.66 106.16,85.66 104.76,87.05 102.64,87.05 99.6,90.09 90.51,90.09 88.73,91.87 88.73,92.58 89.01,92.87 89.42,92.87 90.02,93.47 90.02,93.88 89.52,94.38 89.52,94.59 89.65,94.72 93.28,94.72 93.59,95.03 93.59,95.79 93.23,96.14 92.05,96.14 91.67,95.76 89.32,95.76 89.15,95.93 89.15,96.18 89.32,96.35 91,96.35 91.38,96.74 91.38,97.13 v1(91.69,97.44)
DDR4_DIMM_CH0_DQS_P3: length 53.3
  L12_SIG4 w0.085: v1(101.04,97.44) 100.69,97.79 100.69,98.33 100.81,98.45 101.09,98.45 101.19,98.36 101.19,98.16 101.29,98.06 101.43,98.06 101.52,98.16 101.52,98.36 101.62,98.45 104.53,98.45 105.12,97.87 105.97,97.87 106.56,98.45 106.83,98.45 107.42,97.87 107.92,97.87 108.51,98.45 108.97,98.45 109.55,97.87 110.09,97.87 110.68,98.45 111.02,98.45 111.25,98.23 111.25,97.42 111.62,97.05 111.62,96.19 111.91,95.89 112.48,95.89 112.74,96.15 112.74,96.69 112.87,96.82 113.27,96.82 113.4,96.69 113.4,96.35 113.66,96.09 115.64,96.09 115.77,95.96 115.77,95.49 115.99,95.27 116.77,95.27 116.99,95.49 116.99,95.96 117.12,96.09 117.48,96.09 117.81,95.76 118.72,95.76 119.03,95.45 119.67,95.45 119.98,95.76 120.94,95.76 121.29,96.1 122.5,96.1 122.84,95.76 123.44,95.76 126.61,92.59 126.61,90.61 128.15,89.07 128.15,83 128.05,82.9 127.98,82.9 127.88,82.81 127.88,82.67 127.98,82.57 128.05,82.57 128.15,82.47 128.15,82.33 128.28,82.02 128.28,81.85 128.15,81.53 128.15,81.33 128.28,81.01 128.28,80.85 128.16,80.56 128.16,80.29 128.28,79.98 128.28,79.88 arc(128.26,79.78) 128.21,79.69 128.15,79.64 arc(128.04,79.57) 127.92,79.54 127.86,79.54 arc(127.63,79.49) 127.45,79.35 127.3,79.15 arc(127.2,79.07) 127.08,79.04 126.99,79.04 arc(126.77,78.99) 126.59,78.85 126.44,78.65 arc(126.34,78.57) 126.21,78.54 126.09,78.54 arc(126.01,78.56) 125.94,78.6 125.87,78.68 125.79,78.86 125.68,78.97 125.51,79.04 125.41,79.04 125.31,79.14 v1(125.31,79.43)
DDR4_DIMM_CH0_DQS_P4: length 44.6
  L03_SIG1 w0.079: 130.02,86.56 130.38,86.91 131.03,86.91 131.69,87.57 132.36,87.57 133.6,88.82 134.27,88.82 135.41,89.95 137.38,89.95 138.17,90.74 138.17,91.01 139.13,91.97 139.84,91.97 140.77,92.91 141.43,92.91 142.57,94.05 145.47,94.05 146.28,94.87 149.1,94.87 150.06,93.91 150.79,93.91 151.86,94.99 154.12,94.99 154.5,95.36 157.13,95.36 157.43,95.66 157.43,96.11 157.13,96.41 156.32,96.41 155.96,96.77 155.96,97.11 v4(156.29,97.44) ; 131.05,79.51 130.87,79.33 130.79,79.15 130.69,79.04 130.33,79.04 130.21,79.16 130.13,79.35 130.13,79.52 130.24,79.78 130.24,80.05 130.13,80.31 130.13,80.53 130.24,80.8 130.24,81.06 130.12,81.35 130.12,81.51 130.24,81.8 130.24,82.05 130.02,82.57 130.02,82.71
  L03_SIG1 w0.081: 130.02,86.56 130.02,83.27 130.21,83.09 130.21,82.89 130.02,82.71 ; v4(131.37,79.93) 131.37,79.64 131.23,79.51 131.05,79.51
DDR4_DIMM_CH0_DQS_P5: length 53.1
  L16_SIG6 w0.079: 160.32,94.96 163.97,94.96 164.31,94.62 164.31,92.66 162.7,91.04 154.89,91.04 154.21,91.72 151.76,91.72 151.43,92.05 145.79,92.05 145.26,91.52 ; v1(165.64,97.44) 165.33,97.75 165.33,98.19 165.03,98.49 ; 139.71,82.56 138.93,81.41 137.81,80.29 arc(137.72,80.15) 137.68,79.97 137.68,79.83 137.83,79.48 137.83,79.36 137.73,79.12 137.65,79.04 137.53,79.04 137.43,79.14 v1(137.43,79.43)
  L16_SIG6 w0.081: 165.03,98.49 160.44,98.49 159.54,97.59 159.54,95.73 160.32,94.96 ; 139.71,82.56 141.31,84.16 141.31,87.3 144.26,90.25 144.94,90.25 145.26,90.57 145.26,91.52
DDR4_DIMM_CH0_DQS_P6: length 59.9
  L03_SIG1 w0.079: v4(137.43,82.43) 137.43,82.14 137.53,82.04 137.64,82.04 137.73,82.13 137.79,82.28 137.94,82.43 138.59,82.86 139.01,83.04 144.28,83.04 147.27,80.05 153.21,80.05 155.24,82.07 ; 173.85,95.26 173.6,95.01 169.6,95.01 169.21,94.62 169.21,94.11 169.6,93.72 173.81,93.72 174.06,93.46 174.06,93.19 171.15,90.29 164.07,90.29 163.26,89.48 163.26,89.32 161.61,87.68 161.61,87.45 160.93,86.76 160.31,86.76 157.26,83.71 157.01,83.71 ; v4(174.99,97.44) 174.99,97.44 174.79,97.65 174.79,97.85 174.55,98.08 173.75,98.08
  L03_SIG1 w0.081: 173.85,95.26 173.85,96.59 173.33,97.1 173.33,97.67 173.75,98.08 ; 155.24,82.07 155.37,82.07 157.01,83.71
DDR4_DIMM_CH0_DQS_P7: length 67.1
  L07_SIG3 w0.085: v1(184.34,97.44) 184.06,97.72 184.06,97.82 183.82,98.07 182.99,98.07 181.98,97.06 181.98,96.28 182.25,96.01 183.4,96.01 183.57,95.83 183.57,95.55 183.42,95.4 181.77,95.4 181.41,95.04 181.41,94.42 182.77,93.07 182.77,92.44 180.8,90.48 180.8,89.3 180.37,88.86 177.46,88.86 175.53,86.93 169.37,86.93 167.76,85.33 164.42,85.33 159.76,80.66 159.76,80.15 159.22,79.61 158.55,79.61 158.02,79.08 156.41,79.08 155.84,78.51 155.84,77.82 155.06,77.04 142.59,77.04 arc(142.36,76.99) 142.18,76.84 142.03,76.65 arc(141.93,76.57) 141.8,76.54 141.72,76.54 arc(141.6,76.57) 141.5,76.65 141.35,76.84 arc(141.17,76.99) 140.94,77.04 140.85,77.04 arc(140.62,76.99) 140.44,76.84 140.29,76.65 arc(140.19,76.57) 140.07,76.54 139.98,76.54 arc(139.75,76.49) 139.58,76.34 139.42,76.15 arc(139.32,76.07) 139.2,76.04 139.12,76.04 arc(138.89,75.99) 138.71,75.84 138.56,75.65 arc(138.46,75.57) 138.33,75.54 138.3,75.54 arc(138.07,75.5) 137.89,75.37 137.85,75.34 arc(137.73,75.16) 137.69,74.95 arc(137.71,74.78) 137.76,74.61 137.81,74.49 137.81,74.35 137.73,74.17 137.61,74.04 137.52,74.04 137.43,74.13 v1(137.43,74.43)
DDR4_DIMM_CH0_DQS_P8: length 45.3
  L16_SIG6 w0.079: v1(110.39,97.44) 110.08,97.75 110.08,97.89 110.18,98 110.66,98 110.87,97.79 110.87,97.63 110.79,97.55 110.79,97.4 110.9,97.28 111.06,97.28 111.14,97.36 111.3,97.36 112.17,96.48 112.17,96.29 112.07,96.19 109.31,96.19 108.91,95.78 108.91,95.22 109.28,94.85 112.43,94.85 112.56,94.73 124.61,94.73 125.39,93.95 126.91,93.95 129.04,91.83 129.29,91.83 130.22,90.9 131.42,90.9 133.32,89 133.32,83.03 133.16,82.86 133.02,82.86 132.94,82.94 132.8,82.94 132.71,82.84 132.71,82.7 132.78,82.62 132.78,82.49 132.63,82.34 arc(132.53,82.18) 132.49,82 132.49,81.92 arc(132.5,81.81) 132.53,81.71 132.59,81.57 arc(132.61,81.51) 132.62,81.45 132.62,81.4 arc(132.6,81.29) 132.53,81.19 132.46,81.12 arc(132.37,81.06) 132.27,81.04 132.16,81.04 arc(132.08,81.06) 132.02,81.1 131.89,81.22 131.83,81.38 131.73,81.48 131.58,81.54 131.47,81.54 131.37,81.64 v1(131.37,81.93)
DDR4_DIMM_CH0_ODT0: length 83.1
  L12_SIG4 w0.089: v1(119.24,76.93) 119.53,76.64 119.53,76.32 119.92,75.92 120.3,75.92 120.81,75.42 121.09,75.42 121.52,74.98 122.1,74.98 122.44,75.31 122.97,75.31 123.35,74.93 123.81,74.93 124.24,75.36 124.72,75.36 125.05,75.03 125.26,75.03 125.62,74.67 125.79,74.26 125.79,73.85 125.86,73.7 126.1,73.46 126.3,73.46 126.83,72.93 127.18,72.93 127.67,72.44 128.1,72.44 128.58,72.93 128.91,72.93 129.39,72.44 129.85,72.44 130.33,72.93 130.69,72.93 131.17,72.44 131.58,72.44 132.04,72.9 132.37,72.9 132.9,73.43 133.28,73.43 133.74,73.89 134.07,73.89 134.63,74.45 135.03,74.45 135.49,74.91 135.87,74.91 136.38,75.42 136.76,75.42 137.24,75.9 137.48,75.9 137.83,76.26 137.83,80.69 137.66,80.86 137.66,82.52 137.76,82.62 137.9,82.62 138.01,82.52 138.01,81.18 138.11,81.08 138.25,81.08 138.35,81.18 138.35,84.07 140.08,85.8 140.08,85.94 139.98,86.04 139.83,86.04 138.55,84.75 138.4,84.75 138.3,84.85 138.3,84.99 139.64,86.33 139.64,86.62 139.97,86.95 140.46,86.95 140.74,87.23 140.74,88.25 140.84,88.36 140.99,88.36 141.09,88.25 141.09,87.48 141.19,87.38 141.33,87.38 141.43,87.48 141.43,88.46 141.76,88.79 145.47,88.79 147.08,90.4 147.08,91.72 147.8,92.45 147.8,92.96 148.32,93.48 148.97,93.48 149.44,93.94 150.05,93.94 150.29,93.7 152.06,93.7 152.83,92.93 155.41,92.93 155.98,93.5 155.98,95.16 155.62,95.52 151.34,95.52 150.59,96.27 149.9,96.27 149.01,95.38 148.5,95.38 148.06,94.94 146.59,94.94 145.85,94.2 145.85,92.37 144.92,91.44 v1(144.39,91.44)
DDR4_DIMM_CH0_ODT1: length 82.8
  L12_SIG4 w0.089: v1(119.24,75.93) 119.56,75.61 119.56,75.29 119.95,74.91 120.35,74.91 120.83,74.42 121.17,74.42 121.62,73.97 122.08,73.97 122.45,74.34 122.98,74.34 123.32,73.99 123.91,73.99 124.16,73.74 124.16,73.2 124.01,73.06 124.01,72.71 124.31,72.42 124.57,72.42 125.08,71.91 125.36,71.91 125.64,71.62 125.76,71.34 125.76,70.67 126.02,70.41 126.4,70.41 126.88,69.93 127.21,69.93 127.67,69.47 128.15,69.47 128.58,69.9 129.01,69.9 129.5,69.42 129.8,69.42 130.28,69.9 130.72,69.9 131.1,69.52 131.66,69.52 132.09,69.95 132.47,69.95 132.95,70.44 133.31,70.44 133.79,70.92 134.14,70.92 134.65,71.43 135.01,71.43 135.57,71.99 135.97,71.99 136.41,72.42 136.76,72.42 137.27,72.93 137.65,72.93 138.16,73.43 138.54,73.43 139.05,73.94 139.35,73.94 139.83,74.42 140.16,74.42 140.43,74.69 140.43,82.76 141.61,83.93 144.59,83.93 145,84.33 145,86.18 145.1,86.28 145.24,86.28 145.34,86.18 145.34,84.52 145.44,84.42 145.58,84.42 145.68,84.52 145.68,87.05 148.91,90.27 159.04,90.27 159.25,90.48 159.25,91.81 159.59,92.15 159.59,94.03 159.24,94.38 156.88,94.38 156.67,94.17 156.67,91.87 156.46,91.66 153.13,91.66 151.87,92.92 150.16,92.92 149.52,92.29 148.71,92.29 v1(147.87,91.44)
DDR4_DIMM_CH0_PAR: length 80.8
  L12_SIG4 w0.089: v1(121.84,76.43) 122.22,76.43 122.33,76.54 122.95,76.54 123.23,76.82 123.95,76.82 124.23,76.54 124.63,76.54 124.9,76.81 125.51,76.81 125.88,76.44 126.36,76.44 126.74,76.83 127.38,76.83 127.68,76.52 128.14,76.52 128.64,76.03 129.11,76.03 129.41,76.32 129.85,76.32 130.46,76.93 130.64,76.93 131.14,77.43 131.54,77.43 131.87,77.75 131.87,78.88 133.53,80.54 133.53,82.35 133.43,82.45 133.11,82.45 133.01,82.55 133.01,82.69 133.11,82.79 133.71,82.79 133.81,82.89 133.81,83.04 133.71,83.14 133.11,83.14 133.01,83.24 133.01,83.38 133.11,83.48 133.49,83.48 133.59,83.58 133.59,83.72 133.49,83.82 133.11,83.82 133.01,83.92 133.01,84.07 133.11,84.17 133.48,84.17 133.58,84.27 133.58,84.41 133.48,84.51 133.11,84.51 133.01,84.61 133.01,84.75 133.11,84.85 133.62,84.85 133.72,84.95 133.72,85.09 133.62,85.19 133.11,85.19 133.01,85.3 133.01,85.44 133.11,85.54 133.52,85.54 133.62,85.64 133.62,85.78 133.52,85.88 133.11,85.88 133.01,85.98 133.01,86.12 133.11,86.22 133.79,86.22 133.89,86.32 133.89,86.47 133.79,86.57 133.12,86.57 133.02,86.67 133.02,89.23 133.13,89.33 133.36,89.33 133.46,89.23 133.46,87.04 133.6,86.91 134.21,86.91 134.35,86.77 134.35,85.11 134.45,85.01 134.66,85.01 134.76,85.11 134.76,87.45 134.66,87.55 134.46,87.55 134.36,87.65 134.36,87.79 134.46,87.89 134.66,87.89 134.76,87.99 134.76,88.13 134.66,88.23 134.46,88.23 134.36,88.33 134.36,88.47 134.46,88.57 134.66,88.57 134.76,88.67 134.76,88.82 134.66,88.92 134.46,88.92 134.36,89.02 134.36,89.16 134.46,89.26 134.66,89.26 134.76,89.36 134.76,89.75 134.57,89.95 133.46,89.95 133.3,90.1 133.3,96.16 133.45,96.3 133.64,96.3 133.79,96.16 133.79,90.5 133.89,90.4 134.03,90.4 134.13,90.5 134.13,92.73 134.23,92.83 134.37,92.83 134.47,92.73 134.47,90.52 134.58,90.42 134.72,90.42 134.82,90.52 134.82,92.53 134.92,92.63 135.06,92.63 135.16,92.53 135.16,90.53 135.26,90.43 135.4,90.43 135.5,90.53 135.5,92.53 135.6,92.63 135.75,92.63 135.85,92.53 135.85,92.1 135.95,92 136.15,92 136.74,92.59 136.74,94.88 137.18,95.32 137.18,97 137.08,97.1 136.94,97.1 136.84,97 136.84,95.58 136.74,95.48 136.59,95.48 136.49,95.58 136.49,97.19 v1(136.74,97.44)
DDR4_DIMM_CH0_RESET_N: length 86.3
  L14_SIG5 w0.081: v1(114.64,91.44) 114.64,93.08 115.69,94.13 115.69,95.42 115.79,95.51 115.93,95.51 116.03,95.42 116.03,94.73 116.12,94.63 116.26,94.63 117.74,96.1 117.74,96.24 117.64,96.34 117.5,96.34 116.59,95.43 116.45,95.43 116.36,95.53 116.36,95.67 117.44,96.75 117.72,96.75 118.5,97.54 118.5,99.28 118.4,99.38 118.27,99.38 118.17,99.28 118.17,97.71 117.65,97.19 117.51,97.19 117.41,97.29 117.41,97.43 117.68,97.69 117.68,97.83 117.58,97.93 117.44,97.93 116.76,97.25 116.76,96.61 116.05,95.9 113.37,95.9 113.27,96 113.27,96.14 113.37,96.24 115.77,96.24 115.87,96.33 115.87,96.47 115.77,96.57 111.56,96.57 111.46,96.47 111.46,96.33 111.56,96.24 112.76,96.24 112.86,96.14 112.86,96 112.76,95.9 110.32,95.9 110.22,96 110.22,96.14 110.32,96.24 110.98,96.24 111.08,96.33 111.08,96.47 110.98,96.57 110.1,96.57 109.73,96.2 108.42,96.2 108.31,96.09 108.31,94.72 108.21,94.62 108.07,94.62 107.97,94.72 107.97,96.12 107.87,96.22 107.74,96.22 107.64,96.12 107.64,92.69 107.74,92.59 107.87,92.59 107.97,92.69 107.97,94.15 108.07,94.25 108.21,94.25 108.31,94.15 108.31,92.76 108.58,92.48 108.58,92.09 109.08,91.6 109.08,91.18 108.93,91.03 108.46,91.03 108.33,90.9 108.33,90.31 108.23,90.22 108.09,90.22 108,90.31 108,90.91 107.9,91.01 107.76,91.01 107.66,90.91 107.66,89.89 107.76,89.79 108.23,89.79 108.33,89.7 108.33,89.3 108.23,89.2 108.03,89.2 107.94,89.1 107.94,88.97 108.03,88.87 108.31,88.87 108.41,88.77 108.41,88.63 108.31,88.53 108.03,88.53 107.94,88.43 107.94,87.92 108.03,87.82 108.87,87.82 108.97,87.73 108.97,87.44 108.86,87.33 108.5,87.33 108.4,87.23 108.4,87.09 108.5,87 108.86,87 108.96,86.9 108.96,86.76 108.86,86.66 108.5,86.66 108.4,86.56 108.4,86.42 108.5,86.33 108.86,86.33 108.96,86.23 108.96,86.09 108.86,85.99 108.12,85.99 108.02,85.89 108.02,85.75 108.12,85.66 109.23,85.66 109.33,85.55 109.33,85.37 109.23,85.26 108.63,85.26 108.53,85.16 108.53,85.02 108.63,84.92 109.78,84.92 110.1,84.6 110.1,83.98 110.64,83.44 112.57,83.44 112.89,83.12 113.16,83.12 113.91,82.37 114.21,82.37 114.62,81.96 115.04,81.96 115.32,81.68 115.32,76.79 115.64,76.47 115.94,76.47 116.48,75.93 v1(117.51,75.93)
  BOTTOM w0.149: R10.1 114.53,93.14 114.53,92.23 R11.2 114.68,91.48 v1(114.64,91.44)
DDR4_DIMM_CH0_RZQ: length 3.5
  BOTTOM w0.149: R15.2 124.87,74.22 124.87,76.5 v1(124.44,76.93)
DDR4_DIMM_CH0_SA0: length 0.6
  BOTTOM w0.149: R7.2 v1(188.59,92.52)
DDR4_DIMM_CH0_SA1:
  vias: v1(189.44,91.44)
DDR4_DIMM_CH0_SA2: length 0.6
  BOTTOM w0.149: R9.2 v1(150.34,97.44)
DDR4_DIMM_CH0_TDQS_N9: length 75.9
  L16_SIG6 w0.079: 78.93,92.4 77.64,92.4 77.45,92.59 77.45,92.9 77.64,93.09 80.45,93.09 80.79,93.43 80.79,94.13 80.45,94.47 78.56,94.47 78.36,94.67 78.36,94.92 78.56,95.12 81.53,95.12 81.82,94.83 81.82,92.82 81.66,92.66 81.66,91.82 85.84,87.64 86.53,85.97 87.95,84.55 90.66,84.55 92.39,82.82 99.24,82.82 100.17,81.89 101.93,81.89 102.07,81.75 102.32,81.75 102.46,81.89 102.8,81.89 103.56,81.14 arc(103.91,80.9) 104.33,80.81 104.56,80.81 arc(104.68,80.78) 104.78,80.7 104.94,80.51 arc(105.11,80.37) 105.34,80.31 105.36,80.31 arc(105.54,80.27) 105.68,80.16 105.79,80.02 arc(105.98,79.87) 106.21,79.81 106.27,79.81 arc(106.52,79.87) 106.73,80.04 106.85,80.2 arc(106.96,80.28) 107.09,80.31 107.14,80.31 arc(107.29,80.28) 107.41,80.18 107.53,80.02 arc(107.72,79.87) 107.96,79.81 107.98,79.81 arc(108.25,79.88) 108.46,80.05 108.56,80.18 arc(108.69,80.28) 108.84,80.31 108.85,80.31 arc(109.01,80.28) 109.14,80.17 109.26,80.02 arc(109.45,79.87) 109.69,79.81 109.76,79.81 arc(109.98,79.87) 110.16,80.01 110.31,80.2 arc(110.41,80.28) 110.54,80.31 110.63,80.31 arc(110.76,80.28) 110.86,80.2 111.01,80.01 arc(111.19,79.87) 111.42,79.81 111.49,79.81 arc(111.71,79.87) 111.89,80.01 112.01,80.16 arc(112.15,80.27) 112.32,80.31 112.35,80.31 arc(112.47,80.28) 112.57,80.2 112.72,80.01 arc(112.9,79.87) 113.13,79.81 113.22,79.81 arc(113.45,79.87) 113.63,80.01 113.78,80.2 arc(113.88,80.28) 114,80.31 114.1,80.31 arc(114.22,80.28) 114.32,80.2 114.47,80.01 arc(114.65,79.87) 114.88,79.81 114.97,79.81 arc(115.18,79.86) 115.34,79.99 115.49,80.18 arc(115.61,80.28) 115.76,80.31 115.79,80.31 arc(116.04,80.37) 116.24,80.53 116.36,80.68 arc(116.48,80.78) 116.63,80.81 116.69,80.81 arc(116.92,80.87) 117.1,81.01 117.25,81.2 arc(117.35,81.28) 117.47,81.31 117.56,81.31 arc(117.69,81.28) 117.78,81.2 117.94,81.01 arc(118.12,80.87) 118.34,80.81 118.41,80.81 arc(118.53,80.78) 118.63,80.7 118.78,80.51 arc(118.97,80.37) 119.19,80.31 119.26,80.31 arc(119.37,80.29) 119.47,80.23 119.56,80.14 arc(119.61,80.07) 119.62,79.98 119.62,79.83 119.51,79.55 119.51,79.26 119.62,78.98 119.79,78.81 120.01,78.81 120.11,78.71 v1(120.11,78.43) ; 78.93,90.18 73.99,90.18 73.15,91.02 73,91.02 72.9,90.92 72.76,90.92 72.67,91.02 72.67,91.16 72.77,91.26 72.77,91.4 72.15,92.02 71.92,92.02 71.82,91.92 71.82,91.76 v1(72.14,91.44)
  L16_SIG6 w0.081: 78.93,92.4 79.69,91.65 79.69,90.94 78.93,90.18
DDR4_DIMM_CH0_TDQS_N10: length 55.9
  L12_SIG4 w0.085: v1(81.49,91.44) 81.19,91.74 81.19,91.94 81.3,92.05 81.49,92.05 82.16,91.38 82.16,91.25 82.01,91.09 82.01,90.96 82.11,90.86 82.25,90.86 82.4,91.01 82.54,91.01 82.72,90.83 83.67,90.83 84.82,91.97 84.82,94.04 84.46,94.39 84.46,95 84.79,95.32 85.36,95.32 86.2,94.48 89.08,94.48 89.99,93.57 89.99,92.32 89.35,91.68 89.35,91.15 89.8,90.7 90.86,90.7 93.74,87.82 94.29,87.82 94.85,87.26 94.85,86.14 95.54,85.45 104.67,85.45 105.48,86.26 106.72,86.26 107.27,86.82 115.39,86.82 116.38,85.82 117.04,85.82 118.04,84.82 118.54,84.82 118.79,84.57 118.79,83.89 119.05,83.63 119.05,82.68 119.55,82.18 119.62,81.99 119.8,81.81 120.01,81.81 120.11,81.71 v1(120.11,81.43)
DDR4_DIMM_CH0_TDQS_N11: length 59
  L16_SIG6 w0.079: v1(90.84,91.44) 90.53,91.75 90.53,91.84 90.65,91.96 90.88,91.96 91.5,91.34 91.5,91.21 91.33,91.03 91.33,90.9 91.43,90.8 91.56,90.8 91.74,90.97 91.87,90.97 92.12,90.73 94.67,90.73 95.72,91.77 95.72,92.37 94.99,93.09 94.99,93.42 95.83,94.26 96.22,94.26 96.72,94.75 100.91,94.75 101.03,94.63 101.03,94.29 100.91,94.17 97.26,94.17 97,93.91 97,93.38 97.44,92.94 98.28,92.94 98.46,93.12 100.24,93.12 100.4,92.97 100.4,91.82 100.6,91.62 100.6,90.69 102.46,88.83 103.93,88.83 106.5,86.26 107.18,86.26 107.64,85.8 110.1,85.8 110.46,86.16 111.98,86.16 112.33,85.8 115.32,85.8 116.33,86.82 120.17,86.82 120.44,86.55 120.44,86.05 121.59,84.9 122.22,84.9 123.31,83.81 123.9,83.81 124.89,82.81 125.49,82.81 125.69,82.62 125.69,82.36 125.56,82.06 125.56,81.79 125.69,81.5 125.8,81.38 125.97,81.31 126.07,81.31 126.17,81.21 v1(126.17,80.93)
DDR4_DIMM_CH0_TDQS_N12: length 52.2
  L12_SIG4 w0.085: v1(100.2,91.44) 99.89,91.75 99.89,92.4 100.08,92.6 100.36,92.6 100.46,92.5 100.65,92.5 100.75,92.6 101.1,92.6 102.28,93.78 102.28,94.18 101.91,94.55 101.54,94.55 100.64,93.65 100.39,93.65 100.23,93.82 100.23,94.09 101.65,95.51 102.02,95.51 102.56,94.97 102.56,94.74 103.02,94.28 105.03,94.28 105.28,94.53 108.6,94.53 109.15,93.98 109.58,93.98 109.8,93.76 111.73,93.76 112.63,92.86 113.24,92.86 114.06,93.67 114.77,93.67 115.34,93.1 116.71,93.1 116.88,92.93 117.56,92.93 117.79,92.71 118.81,92.71 119,92.9 123.1,92.9 123.57,92.43 123.57,91.93 123.4,91.75 123.25,91.75 122.84,92.16 122.46,92.16 122.01,91.71 122.01,91.34 123.36,90 124.34,90 124.93,89.41 124.93,89.27 124.78,89.13 124.78,88.99 124.88,88.89 125.02,88.89 125.16,89.04 125.3,89.04 125.68,88.65 125.68,82.34 125.56,82.05 125.56,81.82 125.68,81.53 125.68,81.34 125.57,81.06 125.57,80.8 125.68,80.52 125.68,80.34 125.56,80.05 125.56,79.79 125.68,79.51 125.88,79.31 126.07,79.31 126.17,79.21 v1(126.17,78.93)
DDR4_DIMM_CH0_TDQS_N13: length 44.9
  L03_SIG1 w0.079: v4(155.44,91.44) 155.15,91.74 155.15,91.96 154.87,92.24 154.41,92.24 153.15,90.98 152.66,90.98 151.37,92.26 150.73,92.26 150.59,92.12 150.11,92.12 149.81,92.43 148.96,92.43 148.59,92.05 147.03,92.05 146.52,92.57 146,92.57 145.55,92.12 143.14,92.12 142.46,91.44 142.46,88.96 142.27,88.77 142.06,88.77 141.87,88.96 141.87,89.95 141.59,90.23 141.11,90.23 140.83,89.95 140.83,89.17 140.7,89.05 140.37,89.05 140.24,89.17 140.24,89.98 139.98,90.24 139.46,90.24 139.2,89.98 139.2,89.33 137.92,88.04 137.22,88.04 136.9,88.37 136.22,88.37 135.9,88.04 135.3,88.04 134.46,87.2 134.46,86.77 135.07,86.15 135.07,85.89 134.92,85.74 134.66,85.74 133.64,86.75 133.27,86.75 132.76,86.24 132.76,85.87 132.94,85.69 132.94,85.42 132.57,85.05 132.01,85.05 131.6,84.65 131.6,82.35 131.75,82.01 131.75,81.85 131.62,81.56 131.62,81.31 131.74,81.02 131.74,80.84 131.62,80.55 131.62,80.29 131.75,79.98 131.75,79.85 131.63,79.56 131.63,79.3 131.75,79 131.93,78.81 132.13,78.81 132.23,78.71 v4(132.23,78.43)
DDR4_DIMM_CH0_TDQS_N14: length 51.7
  L16_SIG6 w0.079: 153.72,90.25 153.72,90.45 153.59,90.58 153.26,90.58 153.13,90.45 153.13,90.25 152.87,89.99 152.12,89.99 151.86,90.25 151.86,90.51 151.73,90.64 151.4,90.64 151.27,90.51 151.27,90.25 151.01,89.99 148.61,89.99 145.76,87.14 145.39,87.14 145.02,87.51 145.02,87.88 146.46,89.32 146.46,89.5 146.22,89.73 146.04,89.73 144.25,87.94 144.25,87.17 143.9,86.82 142.54,86.82 142.35,86.63 142.35,86.25 142.55,86.05 145.16,86.05 145.49,85.72 145.49,85.14 145.16,84.82 143.42,84.82 143.25,84.64 143.25,84.2 143.4,84.04 145.18,84.04 145.52,83.7 145.52,83.02 145.18,82.68 143.34,82.68 142.34,81.68 142.21,81.51 arc(142.03,81.37) 141.8,81.31 141.71,81.31 arc(141.58,81.28) 141.48,81.2 141.33,81.01 arc(141.15,80.87) 140.92,80.81 140.86,80.81 arc(140.73,80.78) 140.63,80.7 140.48,80.51 arc(140.3,80.37) 140.07,80.31 139.98,80.31 arc(139.86,80.28) 139.76,80.2 139.61,80.01 arc(139.43,79.87) 139.2,79.81 139.11,79.81 arc(139.02,79.8) 138.94,79.75 138.86,79.66 138.8,79.52 138.59,79.31 138.4,79.31 138.29,79.21 v1(138.29,78.93)
  L16_SIG6 w0.081: 153.72,90.25 153.95,90.02 164.23,90.02 164.53,90.31 164.53,91.22 164.75,91.44 v1(164.79,91.44)
DDR4_DIMM_CH0_TDQS_N15: length 60
  L03_SIG1 w0.079: v4(138.29,80.93) 138.29,81.21 138.4,81.32 138.43,81.32 arc(138.58,81.35) 138.71,81.45 138.86,81.64 arc(139.01,81.77) 139.21,81.82 arc(139.43,81.87) 139.61,82.01 139.77,82.21 arc(139.87,82.29) 139.99,82.32 140.07,82.32 arc(140.2,82.29) 140.3,82.21 140.45,82.01 arc(140.63,81.87) 140.85,81.82 140.94,81.82 arc(141.06,81.79) 141.16,81.71 141.32,81.5 arc(141.49,81.36) 141.71,81.32 141.81,81.32 arc(142.03,81.37) 142.21,81.51 142.36,81.7 arc(142.46,81.79) 142.59,81.82 143.91,81.82 145.78,79.95 145.78,79.38 146.35,78.81 154.85,78.81 155.3,79.26 155.3,80.38 155.63,80.7 156.26,80.7 ; v4(174.14,91.44) 173.9,91.19 173.9,90.72 171.68,88.5 168.84,88.5 168.65,88.32 168.65,86.88 168.35,86.58 167.91,86.58 167.61,86.88 167.61,88.32 167.42,88.5 166.43,88.5 166.25,88.32 166.25,87.41 165.94,87.11 165.35,87.11 165.05,87.41 165.05,88.3 164.84,88.5 164.07,88.5 163.47,87.9 163.47,86.71 163.75,86.43 166.66,86.43 167.03,86.06 167.03,85.51 166.66,85.14 163.03,85.14 162.3,85.87 162.01,85.87 161.81,85.67
  L03_SIG1 w0.081: 161.81,85.67 161.81,84.19 160.79,83.16 158.73,83.16 156.26,80.7
DDR4_DIMM_CH0_TDQS_N16: length 65.9
  L07_SIG3 w0.085: 169.65,85.7 167.36,83.42 164.27,83.42 162.15,81.3 162.15,80.75 162.54,80.36 162.94,80.36 164.01,81.42 164.8,81.42 165.44,80.78 165.44,80.08 164.7,79.34 163.59,79.34 161.38,77.13 158.44,77.13 158.12,76.81 156.38,76.81 155.38,75.81 142.58,75.81 arc(142.45,75.78) 142.35,75.7 142.2,75.51 arc(142.02,75.37) 141.8,75.31 141.72,75.31 arc(141.5,75.37) 141.32,75.51 141.17,75.7 arc(141.07,75.78) 140.94,75.81 140.84,75.81 arc(140.72,75.79) 140.62,75.71 140.47,75.51 arc(140.28,75.37) 140.06,75.31 139.98,75.31 arc(139.86,75.28) 139.76,75.2 139.61,75.01 arc(139.43,74.87) 139.2,74.81 139.11,74.81 arc(139,74.79) 138.91,74.73 138.89,74.71 arc(138.86,74.68) 138.84,74.64 138.78,74.48 138.61,74.31 138.4,74.31 138.29,74.21 v1(138.29,73.93) ; 177.33,87.23 177.86,87.76 178.23,87.76 178.39,87.6 178.39,86.28 178.72,85.95 179.27,85.95 179.6,86.28 179.6,87.6 ; 182.91,90.33 182.91,88.95
  L07_SIG3 w0.089: 179.6,87.6 179.78,87.79 181.75,87.79 182.91,88.95 ; 177.33,87.23 177.33,86.4 176.64,85.7 169.65,85.7 ; v1(183.49,91.44) 183.19,91.14 183.19,90.61 182.91,90.33
DDR4_DIMM_CH0_TDQS_N17: length 43.9
  L16_SIG6 w0.079: v1(109.54,91.45) 109.15,91.84 109.15,92.08 109.25,92.18 109.46,92.18 109.56,92.28 109.56,92.42 109.46,92.51 109.25,92.51 109.15,92.61 109.15,93.84 109.31,94 109.69,94 110.11,93.58 110.11,93.02 110.35,92.79 110.94,92.79 111.18,93.02 111.18,93.62 111.28,93.72 112.48,93.72 112.67,93.91 123.61,93.91 124.62,92.9 126.6,92.9 126.76,92.74 126.76,91.89 126.97,91.68 126.97,91.31 126.76,91.09 126.76,90.54 127.14,90.15 128.07,90.15 128.58,90.66 128.79,90.66 129.03,90.42 129.03,90.23 128.48,89.68 128.48,89.35 128.9,88.93 129.23,88.93 130.37,90.06 131.07,90.06 131.62,89.52 131.62,89.16 131.03,88.57 131.03,87.98 131.27,87.75 132.35,87.75 132.5,87.59 132.5,87.31 132.35,87.16 131.89,87.16 131.62,86.89 131.62,82.29 131.74,82 131.87,81.87 132,81.81 132.13,81.81 132.23,81.71 v1(132.23,81.43)
DDR4_DIMM_CH1_A0: length 89.8
  L07_SIG3 w0.089: v1(137.59,99.06) 137.78,99.25 137.78,101.65 138.42,102.28 141.14,102.28 141.64,101.78 143.37,101.78 143.95,102.36 143.95,104.22 144.64,104.91 144.64,106.08 145.31,106.76 145.31,108.17 145.01,108.47 141.1,108.47 140.73,108.09 140.73,103.82 140.35,103.44 138.61,103.44 137.18,102.02 137.18,100.29 136.05,99.16 132.47,99.16 132.12,99.51 130.48,99.51 129.84,98.87 127.82,98.87 127.43,98.48 126.24,98.48 126.14,98.38 126.14,98.23 126.24,98.13 127.37,98.13 127.47,98.03 127.47,97.89 127.37,97.79 125.54,97.79 125.24,98.09 125.01,98.09 124.76,97.84 124.32,97.84 123.79,98.37 122.31,98.37 122.21,98.47 122.21,98.61 122.31,98.71 123.29,98.71 123.39,98.81 123.39,98.95 123.29,99.05 121.61,99.05 121.02,98.46 121.02,96.21 120.76,95.96 120.15,95.96 118.4,94.21 118.03,94.21 117.63,93.81 117.63,93.42 117.21,93.01 116.73,93.01 116.28,92.57 116.07,92.57 115.37,91.86 115.37,91.14 114.87,90.64 110.76,88.95 108.97,88.95 108.45,88.43 108.45,87.34 108.14,87.03 106.65,87.03 105.94,86.33 105.94,85.85 105.29,85.2 105.29,84.16 104.82,83.69 104.82,83.33 104.12,82.63 104.12,82.23 103.79,81.9 103.79,80.32 104.08,80.04 104.08,77.66 103.83,77.42 103.83,75.11 v1(103.66,74.93)
DDR4_DIMM_CH1_A1: length 90.2
  L07_SIG3 w0.089: v1(126.54,99.32) 126.98,99.75 126.98,100.09 127.49,100.6 130.38,100.6 130.71,100.93 131.94,100.93 132.98,99.9 135.73,99.9 136.49,100.66 136.49,103.06 135.5,104.04 134.51,104.04 133.82,103.35 133.82,100.94 133.72,100.84 133.58,100.84 133.48,100.94 133.48,102.91 133.38,103.01 133.23,103.01 133.13,102.91 133.13,101.38 133.03,101.28 132.89,101.28 132.79,101.38 132.79,102.91 132.69,103.01 132.55,103.01 132.45,102.91 132.45,101.46 132.35,101.36 132.21,101.36 132.1,101.46 132.1,102.62 132,102.72 131.86,102.72 131.76,102.62 131.76,101.45 131.66,101.35 131.52,101.35 131.42,101.45 131.42,102.53 131.32,102.63 131.18,102.63 131.08,102.53 131.08,101.43 130.98,101.33 130.83,101.33 130.73,101.43 130.73,102.58 130.07,103.25 128.37,103.25 128.27,103.15 128.27,103.01 128.37,102.91 129.76,102.91 129.86,102.81 129.86,102.67 129.76,102.57 128.91,102.57 128.81,102.47 128.81,102.32 128.91,102.22 130.18,102.22 130.28,102.12 130.28,101.98 130.14,101.85 124.51,101.85 123.54,100.88 123.54,100.68 123.08,100.22 123.08,99.85 122.63,99.4 121.47,99.4 120.48,98.41 120.48,97.14 119.75,96.41 119.75,96.05 118.26,94.55 117.62,94.55 115.98,92.9 115.33,92.9 115.02,92.59 115.02,91.29 114.74,91 110.6,89.29 108.55,89.29 108.09,88.83 108.09,88.36 107.76,88.02 107.15,88.02 105.6,86.47 105.6,85.99 104.93,85.32 104.93,84.3 104.46,83.83 104.46,83.5 103.49,82.53 103.49,80.52 103.27,79.99 103.27,79.85 103.4,79.55 103.4,79.3 103.27,78.99 103.27,78.86 103.4,78.55 103.4,78.33 103.27,78.02 103.27,77.87 103.5,77.31 103.5,75.56 103.27,75 103.27,74.85 v1(103.66,73.93)
DDR4_DIMM_CH1_A2: length 89.4
  L07_SIG3 w0.089: v1(102.79,74.43) 102.35,74.87 102.35,75.88 101.54,76.69 101.54,77.01 101.67,77.3 101.67,77.56 101.54,77.86 101.54,78.01 101.67,78.32 101.67,78.56 101.54,78.87 101.54,79 101.67,79.31 101.67,79.56 101.54,79.87 101.54,80 101.75,80.51 101.75,81.07 101.92,81.23 101.92,84.31 102.52,84.9 102.88,84.9 103.53,85.55 103.53,86.49 104.1,87.06 104.1,90.36 104.4,90.66 110.28,90.66 111.97,91.36 112.66,92.2 114.75,94.29 115.43,94.29 117.66,96.53 117.66,96.8 117.95,97.09 117.95,99.65 118.11,99.81 119.25,99.81 119.35,99.91 119.35,100.05 119.25,100.15 118.08,100.15 117.98,100.25 117.98,100.39 118.08,100.49 119.41,100.49 119.51,100.59 119.51,100.74 119.41,100.84 118.07,100.84 117.97,100.94 117.97,101.08 118.07,101.18 119.21,101.18 119.31,101.28 119.31,101.42 119.21,101.52 118.48,101.52 118.38,101.62 118.38,101.76 118.48,101.86 121.02,101.86 122.36,103.2 122.5,103.2 122.6,103.1 122.6,102.95 121.17,101.52 120.21,101.52 120.11,101.42 120.11,101.28 120.21,101.18 121.31,101.18 122.72,102.59 123.32,102.59 123.6,102.87 123.6,103.3 124.37,104.08 125.22,104.08 126.14,105 126.14,105.26 126.35,105.47 126.79,105.47 127.57,106.25 127.87,106.25 127.97,106.23 128.35,106.07 128.83,106.07 130.37,106.71 133.82,106.71 135.06,107.95 135.67,107.95 135.82,107.8 135.82,106.66 135.92,106.56 136.06,106.56 136.16,106.66 136.16,108.02 136.26,108.12 136.41,108.12 136.51,108.02 136.51,106.32 136.34,106.15 130.45,106.15 129.76,105.47 128,105.47 127.59,105.06 v1(126.54,105.06)
DDR4_DIMM_CH1_A3: length 89.5
  L07_SIG3 w0.089: v1(102.79,73.43) 103.18,73.82 103.18,74.51 103.05,74.81 103.05,75.08 103.17,75.36 103.17,75.58 103,75.76 103,77.02 103.17,77.19 103.17,77.5 103.02,77.87 103.02,77.99 103.17,78.36 103.17,78.48 103.05,78.78 103.05,79.05 103.17,79.35 103.17,79.5 103.04,79.81 103.04,80.05 103.18,80.38 103.18,82.71 104.12,83.65 104.12,84.68 104.58,85.15 104.58,85.46 105.26,86.13 105.26,86.61 106.29,87.64 106.29,88.85 106.46,89.02 107.8,89.02 108.41,89.63 110.52,89.63 113.97,91.06 114.23,91.32 114.23,91.62 114.67,92.06 114.67,92.73 115.19,93.25 115.83,93.25 117.5,94.91 118.13,94.91 119.36,96.15 119.36,96.51 120.13,97.28 120.13,98.55 121.32,99.74 122.49,99.74 122.74,99.99 122.74,100.36 123.2,100.83 123.2,101.02 124.39,102.21 127.08,102.21 127.21,102.34 127.21,103.1 127.31,103.2 127.46,103.2 127.56,103.1 127.56,102.33 127.66,102.23 127.8,102.23 127.9,102.33 127.9,103.36 128.13,103.59 130.21,103.59 130.78,103.02 131.09,103.02 131.26,103.2 131.26,104.25 131.48,104.47 132.24,104.47 132.34,104.37 132.34,103.49 132.44,103.39 132.59,103.39 132.69,103.49 132.69,104.47 132.79,104.57 132.93,104.57 133.03,104.47 133.03,103.49 133.13,103.39 133.27,103.39 133.37,103.49 133.37,105.01 133.47,105.11 133.61,105.11 133.71,105.01 133.71,104.14 133.81,104.04 134.02,104.04 134.36,104.39 135.64,104.39 136.83,103.2 136.83,100.52 135.83,99.52 132.67,99.52 132.3,99.89 130.4,99.89 130.03,100.26 128.66,100.26 127.25,98.85 124.16,98.85 123.69,99.32 123.69,100.2 124.03,100.54 125.08,100.54 125.44,100.9 125.44,101.24 125.6,101.4 126.22,101.4 126.53,101.09 126.53,100.16 v1(125.69,99.32)
DDR4_DIMM_CH1_A4: length 87.1
  L07_SIG3 w0.089: v1(101.92,74.93) 101.92,75.77 101.23,76.46 101.23,76.86 101.44,77.36 101.44,77.5 101.33,77.78 101.33,78.07 101.44,78.35 101.44,78.52 101.32,78.81 101.32,79.05 101.44,79.35 101.44,79.48 101.31,79.79 101.31,80.01 101.49,80.45 101.49,84.57 101.59,84.67 101.78,84.67 101.88,84.77 101.88,84.92 101.78,85.02 101.09,85.02 100.99,85.12 100.99,85.26 101.09,85.36 102.8,85.36 102.9,85.46 102.9,85.6 102.8,85.7 101.11,85.7 101.01,85.8 101.01,85.94 101.11,86.05 101.88,86.05 101.98,86.15 101.98,86.29 101.88,86.39 101.56,86.39 101.45,86.49 101.45,86.63 101.56,86.73 102.28,86.73 102.38,86.63 102.38,86.15 102.48,86.05 103.01,86.05 103.19,86.23 103.19,86.63 103.76,87.21 103.76,90.5 104.27,91.01 109.69,91.01 110.72,92.04 110.72,92.46 111.95,93.69 112.09,93.69 112.19,93.59 112.19,93.44 111.15,92.41 111.15,92.27 111.25,92.17 111.4,92.17 112.52,93.3 112.52,93.77 112.79,94.04 113.54,94.04 114.15,94.65 115.3,94.65 117.24,96.59 117.24,97.12 117.34,97.22 117.46,97.22 117.56,97.32 117.56,97.46 117.46,97.56 117.34,97.56 117.24,97.66 117.24,97.9 117.6,98.26 117.6,98.63 117.18,99.05 117.18,99.53 117.6,99.95 117.6,101.48 118.32,102.21 120.86,102.21 122.19,103.54 123.35,103.54 124.31,104.5 125.03,104.5 125.32,104.79 125.32,105.5 125.66,105.84 125.95,105.84 126.58,106.48 126.58,109.08 126.47,109.2 126.32,109.2 126.22,109.1 126.22,106.57 126.12,106.47 125.74,106.47 125.64,106.57 125.64,107.34 125.53,107.44 125.31,107.44 125.2,107.34 125.2,106.1 125.1,106 124.87,106 124.77,106.1 124.77,107.37 124.57,107.57 124.57,108.07 124.69,108.2 125.74,108.2 125.84,108.3 125.84,108.54 125.74,108.64 122.36,108.64 122.26,108.54 122.26,108.31 122.36,108.21 123.43,108.21 123.53,108.11 123.53,107.95 123.43,107.85 122.36,107.85 122.26,107.75 122.26,107.55 122.36,107.44 123.73,107.44 123.88,107.29 124.24,107.29 124.34,107.19 124.34,106.54 124.04,106.23 124.04,105.65 124.32,105.37 124.53,105.37 v1(124.84,105.06)
DDR4_DIMM_CH1_A5: length 87.6
  L07_SIG3 w0.089: v1(123.99,105.06) 123.67,105.38 123.67,106.95 123.54,107.08 122.73,107.08 122.37,106.72 122,106.72 121.85,106.87 121.85,108.6 121.74,108.71 121.54,108.71 121.44,108.6 121.44,107.1 121.34,106.99 121.15,106.99 121.05,107.1 121.05,108.62 120.95,108.72 120.75,108.72 120.65,108.62 120.65,107.21 120.55,107.11 120.34,107.11 120.24,107.21 120.24,108.62 120.14,108.72 119.92,108.72 119.82,108.62 119.82,107.53 119.72,107.43 119.51,107.43 119.41,107.53 119.41,108.62 119.31,108.72 119.12,108.72 119.02,108.62 119.02,107.53 118.92,107.43 118.69,107.43 118.59,107.53 118.59,108.62 118.49,108.72 118.29,108.72 118.18,108.62 118.18,107.52 118.08,107.42 117.86,107.42 117.76,107.52 117.76,108.62 117.66,108.72 117.45,108.72 117.34,108.62 117.34,107.2 117.52,107.02 119.79,107.02 120.2,106.61 121.1,106.61 121.41,106.3 122.08,106.3 122.36,106.02 122.36,105.55 122.46,105.45 122.7,105.45 122.8,105.55 122.8,106.56 122.9,106.66 123.11,106.66 123.21,106.56 123.21,105 123.6,104.61 123.6,104.43 123.5,104.33 123.31,104.33 123.08,104.56 122.72,104.56 120.71,102.55 118.18,102.55 117.46,101.84 116.53,101.84 116.41,101.72 116.41,101 116.51,100.89 116.87,100.89 116.97,100.79 116.97,100.54 116.87,100.44 116.51,100.44 116.41,100.34 116.41,99.72 116.83,99.3 116.83,98.75 116.75,98.66 116.75,96.58 115.16,94.99 114.01,94.99 113.4,94.38 112.65,94.38 112.31,94.04 111.81,94.04 110.78,93 110.36,93 109.91,92.55 109.91,92.16 109.58,91.83 108.24,91.83 108.16,91.76 107.41,91.76 107.31,91.86 104.21,91.86 104,91.65 104,91.28 103.42,90.7 103.42,89.36 103.13,89.07 103.13,88.85 103.42,88.56 103.42,88.38 103.13,88.09 103.13,87.87 103.42,87.58 103.42,87.35 103.09,87.02 102.61,87.02 102.45,87.18 101.42,87.18 101.27,87.02 100.8,87.02 100.62,86.84 100.62,84.25 100.83,84.04 100.83,83.88 100.61,83.66 100.61,83.21 101.08,82.73 101.08,80.99 100.67,80.58 100.67,80.36 100.79,80.07 100.79,79.78 100.67,79.49 100.67,79.36 100.79,79.08 100.79,78.77 100.67,78.49 100.67,78.37 100.79,78.07 100.79,77.78 100.57,77.24 100.57,75.28 v1(101.92,73.93)
