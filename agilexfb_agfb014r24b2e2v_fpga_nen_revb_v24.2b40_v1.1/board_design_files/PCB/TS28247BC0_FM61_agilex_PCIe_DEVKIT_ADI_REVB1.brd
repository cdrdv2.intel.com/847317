# Allegro board TS28247BC0_FM61_agilex_PCIe_DEVKIT_ADI_REVB1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
QSFPDD0_TX7_N: length 49.5
  L16_SIG6 w0.079: v1(52.03,71.89) 52.31,71.6 52.77,71.6 54.27,70.1 55.38,70.1 56.11,69.37 56.11,68.2 56.45,67.85 57.79,67.85 58.12,68.19 60.3,68.19 61.6,66.88 61.6,64.34 63.02,62.92 65,62.92 65.27,62.64 78.63,62.64 79.35,63.36 83.76,63.36 84.58,62.54 87.17,62.54 87.66,63.03 89.15,63.03 89.64,62.54 91.58,62.54 arc(91.85,62.47) 92.05,62.27 92.08,62.23 92.1,62.19 arc(92.19,62.11) 92.3,62.08 92.44,62.08 arc(92.65,62.04) 92.83,61.92 92.92,61.83 92.96,61.76 arc(93.03,61.61) 93.05,61.44 arc(93.11,61.17) v1(93.26,60.93)
QSFPDD0_TX7_P: length 49.4
  L16_SIG6 w0.079: v1(92.4,61.43) 92.64,61.29 arc(92.72,61.28) 92.78,61.32 92.81,61.37 arc(92.82,61.4) 92.83,61.43 arc(92.81,61.54) 92.76,61.64 92.73,61.69 92.66,61.76 arc(92.56,61.83) 92.44,61.85 92.3,61.85 arc(92.08,61.91) 91.91,62.06 91.88,62.11 91.85,62.16 arc(91.74,62.27) 91.58,62.32 91.3,62.32 91.16,62.18 90.91,62.18 90.77,62.32 90.49,62.32 90.36,62.19 90.08,62.19 89.95,62.32 89.54,62.32 89.06,62.8 88.61,62.8 88.48,62.67 88.2,62.67 88.08,62.8 87.75,62.8 87.27,62.32 84.49,62.32 83.67,63.13 79.44,63.13 78.72,62.42 65.18,62.42 64.9,62.69 62.93,62.69 61.37,64.25 61.37,66.79 60.2,67.96 58.21,67.96 57.88,67.63 56.36,67.63 55.88,68.11 55.88,69.28 55.29,69.87 54.18,69.87 52.67,71.37 52.31,71.37 v1(52.03,71.09)
QSFPDD0_VCC:
  vias: v1(54.11,69.09) v1(54.96,69.09) v1(56.69,69.09) v1(57.54,69.09)
QSFPDD0_VCCR:
  vias: v1(48.46,67.9) v1(49.09,67.9) v1(50.83,67.89) v1(51.68,67.89)
QSFPDD0_VCCT:
  vias: v1(54.11,68.29) v1(54.96,68.29) v1(56.69,68.29) v1(57.54,68.29)
QSFPDD1_1V2_INT_L: length 135.5
  L12_SIG4 w0.089: v1(113.18,81.43) 113.18,80.96 112.52,80.3 112.16,80.3 111.86,80.01 111.86,79.31 111.61,79.05 111.26,79.05 111.01,79.3 110.36,79.3 110.05,78.99 109.39,78.99 109.08,79.3 108.55,79.3 108.29,79.05 107.7,79.05 107.45,79.3 106.87,79.3 106.62,79.05 106.05,79.05 105.55,78.55 105.18,78.55 104.68,78.05 104.59,78.05 104.59,78.05 104.27,78.05 104.02,78.3 103.45,78.3 103.18,78.03 102.51,78.03 102.24,78.3 101.58,78.3 101.24,77.97 100.81,77.97 100.39,77.55 98.3,77.55 97.28,78.58 92.95,78.58 92.69,78.83 92.21,78.83 91.93,78.55 91.26,78.55 91.02,78.8 90.66,78.8 90.16,79.3 89.4,79.3 88.67,80.03 85.17,80.03 83.98,78.85 78.8,78.85 77.43,80.22 69.17,80.22 65.95,76.99 61.81,76.99 58.43,73.61 58.43,70.56 58.05,70.18 58.05,68.15 56.27,66.37 56.27,64.21 53.6,61.55 51.24,61.55 43.31,53.63 43.31,51.51 39.63,47.83 39.63,47.32 39.25,46.94 36.58,46.94 33.92,44.27 29.72,44.27 27.95,42.5 27.95,38.69 27.79,38.53 27.79,29.13 27.23,28.57 27.23,24.22 27.23,24.22 27.23,22.69 27.5,22.42 29.63,22.42 v1(30.03,22.02)
QSFPDD1_1V2_LPMODE: length 142.2
  L12_SIG4 w0.089: v1(30.83,21.22) 30.68,21.22 30.28,21.62 25.73,21.62 25.42,21.94 25.42,25.27 26.43,26.28 26.43,28.97 26.8,29.34 26.8,42.12 29.36,44.67 33.3,44.67 33.65,45.03 33.65,46.11 35.37,47.83 39.12,47.83 42.93,51.64 42.93,53.59 51.21,61.86 52.52,61.86 54.36,63.71 54.36,65.86 56.27,67.77 56.27,69.67 57.22,70.63 57.22,73.04 61.48,77.29 65.39,77.29 68.88,80.78 77.47,80.78 79,79.25 83.85,79.25 85.15,80.55 88.6,80.55 89.6,79.55 90.32,79.55 90.57,79.3 91.92,79.3 92.17,79.05 92.78,79.05 92.98,78.85 97.67,78.85 98.21,78.3 98.79,78.3 99.11,77.98 99.42,77.98 99.75,78.3 100.39,78.3 100.89,78.8 101.44,78.8 101.69,78.55 102.3,78.55 102.55,78.8 103.22,78.8 103.47,78.55 103.84,78.55 104.09,78.8 104.72,78.8 105.22,79.3 105.6,79.3 106.1,79.8 106.52,79.8 106.77,79.55 107.4,79.55 107.65,79.8 108.32,79.8 108.57,79.55 109.14,79.55 109.39,79.8 109.97,79.8 110.22,79.55 110.79,79.55 111.18,79.94 111.49,79.94 112.11,80.55 112.47,80.55 112.7,80.78 112.7,81.48 113.18,81.96 v1(113.18,82.43)
  BOTTOM w0.149: R44.1 R45.2 v1(113.18,82.43)
QSFPDD1_1V2_MODPRS_L: length 144.6
  L12_SIG4 w0.089: v1(112.32,80.93) 112.32,81.4 112.73,81.81 112.73,82.27 112.53,82.48 112.1,82.48 111.61,81.99 111.26,81.99 110.82,81.55 110.37,81.55 109.87,81.05 109.51,81.05 109.26,81.3 106.83,81.3 106.58,81.05 106.05,81.05 105.55,80.55 105.18,80.55 104.68,80.05 104.64,80.05 104.64,80.05 104.2,80.05 103.93,80.32 103.49,80.32 103.22,80.05 102.37,80.05 102.09,80.33 101.75,80.33 101.48,80.05 100.85,80.05 100.35,79.55 99.88,79.55 99.63,79.8 98.98,79.8 98.73,79.55 93.8,79.55 92.55,80.8 92.01,80.8 91.76,80.55 91.14,80.55 90.89,80.8 90.46,80.8 89.96,81.3 89.38,81.3 89.04,81.64 84.94,81.64 83.55,80.24 79.8,80.24 77.88,82.16 67.13,82.16 63.69,78.72 60.48,78.72 55.63,73.87 55.63,70.82 55,70.18 54.49,70.18 53.35,69.04 53.35,67.52 51.32,65.48 51.32,63.71 49.4,61.79 49.18,61.79 48.34,60.95 48.34,60.4 41.66,53.72 41.66,52.15 38.68,49.16 34.23,49.16 32.14,47.07 28.84,47.07 27.82,46.05 26.8,46.05 23.13,42.38 23.13,29.02 23.39,28.77 23.39,23.56 24.16,22.79 24.16,20.17 25.1,19.22 27.22,19.22 27.62,18.82 v1(28.43,18.82)
QSFPDD1_1V2_MODSEL_L: length 145.3
  L12_SIG4 w0.089: v1(112.32,81.93) 112.02,81.63 112.02,81.31 111.69,80.98 111.31,80.98 110.8,80.47 110.31,80.47 109.9,80.05 109.42,80.05 109.17,80.3 108.61,80.3 108.36,80.05 107.75,80.05 107.5,80.3 106.84,80.3 106.59,80.05 106.04,80.05 105.54,79.55 105.18,79.55 104.68,79.05 104.66,79.05 104.66,79.05 104.28,79.05 104.03,79.3 103.42,79.3 103.17,79.05 102.61,79.05 102.36,79.3 101.67,79.3 101.42,79.05 100.85,79.05 100.35,78.55 99.86,78.55 99.6,78.81 99.03,78.81 98.77,78.55 98.29,78.55 97.76,79.08 93.28,79.08 92.53,79.83 92.05,79.83 91.78,79.55 90.71,79.55 89.95,80.32 89.43,80.32 88.82,80.93 85.1,80.93 83.72,79.55 79.19,79.55 77.58,81.16 68.64,81.16 65.67,78.18 61.86,78.18 56.78,73.1 56.78,70.69 55.89,69.8 55.89,67.9 53.98,65.99 53.98,63.96 52.2,62.18 51.19,62.18 42.55,53.55 42.55,51.9 38.95,48.3 35.28,48.3 32.64,45.65 28.44,45.65 28.02,45.23 27.25,45.23 24.01,41.99 24.01,39.07 26.42,36.65 26.42,29.82 25.51,28.91 25.51,27.44 24.44,26.37 24.44,25.73 24.79,25.38 24.79,24.9 24.44,24.54 24.44,23.92 24.89,23.47 24.89,21.49 25.55,20.82 29.43,20.82 29.63,20.62 29.63,20.24 30.03,19.84 v1(30.03,19.62)
  BOTTOM w0.149: v1(112.32,81.93) 112.32,82.67 R41.1
QSFPDD1_1V2_RESET_L: length 147.5
  L12_SIG4 w0.089: v1(29.23,19.62) 28.93,19.32 28.93,18.62 28.73,18.42 25.56,18.42 23.92,20.07 23.92,22.52 22.49,23.95 22.49,28.4 22.74,28.65 22.74,42.62 26.68,46.56 27.57,46.56 29.15,48.15 32.46,48.15 33.92,49.61 38.56,49.61 41.26,52.3 41.26,54.61 41.94,55.3 41.94,57.2 42.81,58.07 42.81,58.75 44.15,60.1 45.93,60.1 48.14,62.31 49.41,62.31 50.93,63.83 50.93,65.74 52.97,67.77 52.97,69.29 54.36,70.69 54.36,73.23 60.21,79.07 63.37,79.07 66.91,82.61 78,82.61 80.04,80.57 83.5,80.57 84.91,81.98 89.06,81.98 89.53,81.51 90.04,81.51 90.51,81.05 91.02,81.05 91.27,81.3 91.82,81.3 92.07,81.05 92.6,81.05 93.86,79.79 97.79,79.79 98.3,80.3 98.74,80.3 98.99,80.05 99.78,80.05 100.06,80.33 100.43,80.33 100.9,80.8 104.73,80.8 105.23,81.3 105.23,81.3 105.6,81.3 106.1,81.8 106.5,81.8 106.75,81.55 107.47,81.55 107.73,81.81 108.35,81.81 108.6,81.55 109.14,81.55 109.53,81.94 109.99,81.94 110.47,82.43 v1(111.45,82.43)
  BOTTOM w0.149: R39.1 111.45,82.67 v1(111.45,82.43)
QSFPDD1_3V3_INT_L: length 38.7
  L03_SIG1 w0.081: v1(46.5,39.17) 46.5,40.17 47.39,41.05 48.38,41.05 49.19,41.86 55.86,41.86 v4(56.7,42.7)
  L07_SIG3 w0.089: v1(36.43,26.02) 35.87,26.02 35.23,25.38 35.23,23.46 35.47,23.22 37.47,23.22 38.27,24.02 38.83,24.02 43.39,28.58 43.71,28.58 46.19,31.06 46.19,34.54 47.15,35.5 47.15,38.52 v1(46.5,39.17)
QSFPDD1_3V3_LPMODE: length 42.6
  TOP w0.149: J6.31 58.19,45.1 v1(58.4,44.88)
  L05_SIG2 w0.081: v1(35.63,24.42) 36.03,24.02 36.65,24.02 37.73,25.1 37.73,26.75 38.36,27.38 39.89,27.38 41.92,29.42 41.92,32.16 40.9,33.18 40.9,37.29 41.28,37.67 41.28,41.61 43.44,43.77 44.58,43.77 44.71,43.64 45.6,43.64 46.87,44.91 52.59,44.91 53.09,45.42 57.87,45.42 v1(58.4,44.88)
QSFPDD1_3V3_MODPRS_L: length 32.8
  L03_SIG1 w0.081: v1(46.5,38.15) 47.07,38.72 47.07,40.26 47.48,40.67 48.48,40.67 49.28,41.48 56.29,41.48 v4(56.7,41.89)
  L07_SIG3 w0.089: v1(36.43,24.42) 37.63,24.42 38.43,25.22 39.47,25.22 40.99,26.74 40.99,28.1 42.83,29.94 44.51,29.94 45.79,31.22 45.79,37.44 v1(46.5,38.15)
QSFPDD1_3V3_MODSEL_L: length 30.1
  L03_SIG1 w0.081: v4(47.89,44.7) 47.34,44.15 v1(45.22,44.15)
  L05_SIG2 w0.081: v1(35.63,25.22) 35.93,25.52 35.93,26.42 36.03,26.52 36.03,27.02 36.23,27.22 37.43,27.22 38.73,28.53 40.27,28.53 41.54,29.8 41.54,31.8 40.27,33.07 40.27,38.43 39.89,38.81 39.89,41.1 42.93,44.15 v1(45.22,44.15)
QSFPDD1_3V3_RESET_L: length 28.5
  L03_SIG1 w0.081: v1(46.87,42.5) 46.87,42.88 v4(47.89,43.89)
  L05_SIG2 w0.081: v1(36.43,23.62) 36.68,23.62 42.3,29.24 42.3,32.39 41.54,33.15 41.54,36.27 41.92,36.65 41.92,37.16 41.66,37.42 41.66,40.97 43.57,42.88 46.49,42.88 v1(46.87,42.5)
QSFPDD1_FPGA_LED0: length 34.6
  L14_SIG5 w0.081: v1(82.56,93.74) 82.56,93.91 82.85,94.2 85.54,94.2 86.88,92.86 87.66,92.86 88.91,91.61 89.5,91.61 89.84,91.96 91.09,91.96 91.44,91.61 92.05,91.61 92.42,91.97 94.39,91.97 94.8,91.55 95.43,91.55 95.71,91.84 96.31,91.84 100.33,87.82 100.33,86.55 102.06,84.82 102.06,83.14 104.15,81.05 104.73,81.05 105.26,80.53 105.56,80.53 106.25,79.84 v1(106.25,79.43)
  BOTTOM w0.149: v1(82.56,93.74) 82.59,93.77 U68.2
QSFPDD1_FPGA_LED1: length 36.5
  L14_SIG5 w0.081: v1(107.12,78.93) 107,78.81 106.04,78.81 105.54,79.32 105.16,79.32 104.66,79.82 104.29,79.82 103.6,80.51 103.28,80.51 100.52,83.28 100.52,84.54 98.83,86.23 98.83,88.06 96.69,90.21 85.16,90.21 84.47,90.9 82.99,90.9 81.29,92.61 v1(81.29,93.74)
  BOTTOM w0.149: v1(81.29,93.74) 81.94,94.39 U68.3
QSFPDD1_FPGA_LED2: length 38.9
  L14_SIG5 w0.081: v1(107.12,79.93) 107.12,79.58 106.58,79.04 106.11,79.04 105.6,79.56 105.23,79.56 104.73,80.06 104.36,80.06 101.43,82.99 101.43,84.67 99.76,86.33 99.76,87.61 96.78,90.59 85.9,90.59 85.33,91.16 85.33,91.88 84.41,92.8 82.43,92.8 81.76,93.47 81.76,93.84 81.48,94.13 80.4,94.13 v1(80.02,93.74)
  BOTTOM w0.149: v1(80.02,93.74) 80.46,94.19 80.91,94.19 81.29,94.57 U68.4
QSFPDD1_LED0: length 83.9
  L12_SIG4 w0.089: v1(82.18,103.08) 81.03,101.93 77.73,101.93 74.43,98.63 70.87,98.63 69.98,97.74 69.98,97.11 68.84,95.96 68.84,95.25 67.87,94.28 66.73,94.28 61.56,89.11 60.46,89.11 57.03,85.68 57.03,84.28 53.07,80.32 52.28,80.32 52.08,80.52 48.7,80.52 47.76,79.58 43.31,79.58 42.93,79.2 42.93,66.12 41.41,64.59 41.41,62.56 40.52,61.67 36.07,61.67 35.31,60.91 29.03,60.91 v1(28.52,60.4)
  BOTTOM w0.149: v1(82.18,103.08) 82.59,102.66 U68.13
QSFPDD1_LED1: length 80.7
  L07_SIG3 w0.089: v1(34.55,62.31) 34.3,62.56 33.18,62.56 v1(31.31,64.42)
  L12_SIG4 w0.089: v1(81.16,103.08) 80.4,102.31 76.59,102.31 73.79,99.52 69.48,99.52 69.17,99.21 69.17,97.3 61.35,89.49 60.2,89.49 56.52,85.8 56.52,84.53 53.22,81.23 44.08,81.23 42.55,79.71 42.55,66.2 41.16,64.8 41.16,63.1 40.11,62.05 34.81,62.05 v1(34.55,62.31)
  BOTTOM w0.149: v1(81.16,103.08) 81.94,102.3 U68.12
QSFPDD1_LED2: length 86.8
  L07_SIG3 w0.089: v1(27.5,64.42) 28.17,63.76 31.38,63.76 33.08,62.05 33.92,62.05 v1(34.55,61.42)
  L12_SIG4 w0.089: v1(34.55,61.42) 34.07,61.9 34.07,62.56 34.22,62.72 35.03,62.72 35.31,62.44 39.96,62.44 40.39,62.87 40.39,63.88 40.79,64.28 40.79,65.06 41.31,65.59 41.31,67.52 42.25,68.46 42.25,80.93 43.44,82.12 51.57,82.12 52.2,82.76 53.98,82.76 56.01,84.79 56.01,85.93 59.95,89.87 61.09,89.87 67.44,96.22 67.44,97.95 68.33,98.84 68.33,99.65 68.65,99.96 73.6,99.96 76.33,102.69 79.7,102.69 v1(80.08,103.08)
  BOTTOM w0.149: U68.11 81.29,102.31 81.06,102.54 80.62,102.54 v1(80.08,103.08)
QSFPDD1_RX0_N: length 70.1
  L03_SIG1 w0.079: v4(95.86,60.43) 95.61,60.29 arc(95.57,60.22) 95.58,60.15 95.61,60.09 arc(95.67,60.03) 95.75,60.01 95.78,60.01 95.89,60.01 arc(96.11,59.96) 96.29,59.84 96.49,59.64 arc(96.59,59.58) 96.7,59.56 96.71,59.56 arc(96.9,59.52) 97.06,59.41 97.12,59.36 arc(97.25,59.15) 97.3,58.91 97.3,58.78 arc(97.29,58.7) 97.27,58.63 97.25,58.58 arc(97.23,58.5) 97.22,58.42 97.22,58.39 arc(97.23,58.33) 97.25,58.26 97.29,58.15 arc(97.32,58.06) 97.33,57.97 arc(97.31,57.85) 97.27,57.73 97.2,57.58 arc(97.17,57.49) 97.17,57.39 97.17,57.35 arc(97.18,57.3) 97.21,57.25 arc(97.29,57.06) 97.32,56.86 97.32,56.82 arc(97.31,56.73) 97.28,56.65 97.25,56.58 arc(97.23,56.5) 97.22,56.41 arc(97.22,56.41) 97.22,56.41 97.22,56.39 arc(97.23,56.32) 97.25,56.25 97.29,56.14 arc(97.33,55.91) 97.26,55.69 97.2,55.6 arc(97.17,55.51) 97.16,55.41 97.16,55.39 arc(97.18,55.31) 97.21,55.24 97.24,55.2 arc(97.29,55.08) 97.31,54.95 97.31,54.88 arc(97.29,54.74) 97.25,54.6 97.24,54.56 arc(97.22,54.5) 97.21,54.45 97.21,54.42 arc(97.22,54.34) 97.24,54.26 97.28,54.17 arc(97.32,53.92) 97.25,53.69 97.21,53.61 arc(97.16,53.42) 97.21,53.24 97.24,53.19 arc(97.3,53.05) 97.33,52.89 arc(97.28,52.69) 97.17,52.51 97.14,52.49 arc(96.95,52.36) 96.73,52.31 96.7,52.31 arc(96.52,52.27) 96.39,52.14 96.36,52.08 arc(96.16,51.89) 95.89,51.81 95.84,51.81 arc(95.67,51.77) 95.54,51.64 95.51,51.59 arc(95.31,51.39) 95.03,51.31 94.98,51.31 arc(94.81,51.27) 94.68,51.14 94.65,51.08 arc(94.45,50.89) 94.18,50.81 94.11,50.81 arc(93.93,50.77) 93.8,50.64 93.77,50.58 arc(93.57,50.39) 93.3,50.31 93.24,50.31 arc(93.07,50.27) 92.94,50.14 92.91,50.08 arc(92.71,49.89) 92.44,49.81 92.38,49.81 arc(92.09,49.89) 91.88,50.11 91.85,50.16 arc(91.73,50.27) 91.57,50.31 91.52,50.31 arc(91.34,50.27) 91.21,50.14 91.18,50.08 arc(90.98,49.89) 90.71,49.81 90.65,49.81 arc(90.47,49.77) 90.34,49.64 90.31,49.58 arc(90.11,49.39) 89.84,49.31 89.79,49.31 arc(89.46,49.25) 89.19,49.07 86.66,46.54 84.11,46.54 82.81,45.24 80.54,45.24 76.41,41.1 76.41,36.89 72.9,33.38 52.57,33.38 49.83,36.12 49.83,36.7 49.55,36.98 49.38,36.98 v4(49.1,36.7)
QSFPDD1_RX0_P: length 70.1
  L03_SIG1 w0.079: v4(49.1,37.5) 49.38,37.21 49.64,37.21 50.06,36.79 50.06,36.22 52.67,33.61 72.8,33.61 76.18,36.98 76.18,41.2 80.45,45.47 82.72,45.47 84.01,46.76 84.94,46.76 85.07,46.89 85.35,46.89 85.47,46.76 85.75,46.76 85.88,46.89 86.16,46.89 86.29,46.76 86.57,46.76 87.11,47.31 87.11,47.49 87.31,47.68 87.49,47.68 87.68,47.88 87.68,48.06 87.88,48.26 88.06,48.26 88.26,48.46 88.26,48.6 88.38,48.72 88.53,48.72 89.03,49.23 arc(89.38,49.46) 89.79,49.54 89.84,49.54 arc(90,49.58) 90.11,49.7 90.14,49.75 arc(90.36,49.96) 90.65,50.04 90.71,50.04 arc(90.87,50.08) 90.98,50.2 91.01,50.25 arc(91.22,50.46) 91.52,50.54 91.57,50.54 arc(91.84,50.47) 92.04,50.27 92.07,50.22 arc(92.2,50.09) 92.38,50.04 92.44,50.04 arc(92.59,50.08) 92.71,50.2 92.74,50.25 arc(92.95,50.46) 93.24,50.54 93.3,50.54 arc(93.46,50.58) 93.57,50.7 93.6,50.75 arc(93.82,50.96) 94.11,51.04 94.18,51.04 arc(94.33,51.08) 94.45,51.2 94.48,51.25 arc(94.69,51.46) 94.98,51.54 95.03,51.54 arc(95.19,51.59) 95.31,51.7 95.34,51.76 arc(95.55,51.97) 95.84,52.04 95.89,52.04 arc(96.05,52.08) 96.16,52.2 96.19,52.25 arc(96.41,52.46) 96.7,52.54 96.73,52.54 arc(96.86,52.57) 96.98,52.65 97.01,52.67 arc(97.07,52.77) 97.1,52.89 arc(97.08,52.98) 97.05,53.07 97.02,53.12 arc(96.93,53.42) 97.01,53.73 97.05,53.8 arc(97.09,53.94) 97.07,54.08 97.03,54.17 arc(97.01,54.23) 97,54.29 arc(96.99,54.35) 96.98,54.42 96.98,54.45 arc(97,54.55) 97.03,54.65 97.04,54.69 arc(97.07,54.78) 97.08,54.88 97.08,54.95 arc(97.07,55.02) 97.04,55.08 97.02,55.12 arc(96.97,55.24) 96.94,55.36 96.93,55.39 arc(96.94,55.56) 97.01,55.72 97.06,55.81 arc(97.1,55.93) 97.08,56.05 97.03,56.16 arc(97,56.28) 96.99,56.39 96.99,56.41 arc(97,56.54) 97.04,56.66 97.07,56.74 arc(97.08,56.78) 97.09,56.82 97.09,56.86 arc(97.07,57) 97.01,57.13 arc(96.97,57.22) 96.94,57.32 96.94,57.36 arc(96.94,57.53) 96.99,57.68 97.07,57.83 arc(97.09,57.9) 97.1,57.97 arc(97.09,58.02) 97.08,58.07 97.04,58.17 arc(97,58.28) 96.99,58.39 96.99,58.42 arc(97,58.55) 97.04,58.67 97.06,58.72 arc(97.07,58.75) 97.07,58.78 97.07,58.91 arc(97.04,59.06) 96.96,59.19 96.9,59.25 arc(96.81,59.31) 96.71,59.33 96.7,59.33 arc(96.5,59.37) 96.33,59.48 96.13,59.68 arc(96.02,59.75) 95.89,59.78 95.77,59.78 95.75,59.78 arc(95.56,59.83) 95.41,59.98 95.38,60.03 arc(95.32,60.08) 95.24,60.07 v4(95,59.93)
QSFPDD1_RX1_N: length 51.4
  L03_SIG1 w0.079: v4(57.89,37.1) 58.17,37.38 58.86,37.38 61.42,39.95 61.42,44.45 64.74,47.76 64.74,48 69.42,52.68 87.43,52.68 87.67,52.92 88.16,52.92 arc(88.23,52.91) 88.3,52.89 88.37,52.86 arc(88.5,52.82) 88.64,52.81 88.73,52.81 arc(88.97,52.76) 89.17,52.63 89.32,52.48 arc(89.5,52.36) 89.72,52.31 89.81,52.31 arc(90.1,52.39) 90.32,52.6 arc(90.32,52.61) 90.33,52.61 90.36,52.67 arc(90.46,52.78) 90.61,52.81 90.7,52.81 arc(90.97,52.89) 91.17,53.08 arc(91.17,53.08) 91.17,53.08 91.2,53.14 arc(91.22,53.16) 91.24,53.19 arc(91.36,53.28) 91.51,53.31 91.54,53.31 arc(91.8,53.38) 91.99,53.57 92.05,53.67 arc(92.18,53.8) 92.37,53.85 92.5,53.85 arc(92.73,53.91) 92.9,54.08 92.91,54.1 arc(93.04,54.23) 93.22,54.28 93.29,54.28 arc(93.59,54.36) 93.81,54.58 93.85,54.65 arc(93.97,54.77) 94.13,54.81 arc(94.39,54.86) 94.61,55.01 94.63,55.03 arc(94.73,55.18) 94.76,55.36 arc(94.74,55.51) 94.68,55.64 94.62,55.75 arc(94.57,55.93) 94.63,56.12 94.64,56.13 arc(94.73,56.39) 94.69,56.67 94.66,56.72 arc(94.64,56.79) 94.63,56.85 arc(94.62,56.86) 94.62,56.86 arc(94.62,56.89) 94.62,56.92 94.62,56.97 arc(94.64,57.07) 94.69,57.15 94.71,57.16 arc(94.83,57.25) 94.99,57.28 95.05,57.28 arc(95.23,57.32) 95.39,57.42 95.51,57.54 arc(95.61,57.69) 95.66,57.87 arc(95.73,58.16) v4(95.86,58.43)
QSFPDD1_RX1_P: length 51.4
  L03_SIG1 w0.079: v4(57.89,37.9) 58.17,37.61 58.76,37.61 61.2,40.04 61.2,44.54 64.51,47.85 64.51,48.09 69.32,52.91 84.96,52.91 85.08,53.04 85.36,53.04 85.49,52.91 85.77,52.91 85.9,53.04 86.18,53.04 86.3,52.91 86.58,52.91 86.71,53.04 86.99,53.04 87.12,52.91 87.34,52.91 87.58,53.15 88.16,53.15 arc(88.27,53.14) 88.38,53.1 88.46,53.07 arc(88.55,53.05) 88.64,53.04 88.73,53.04 arc(89.06,52.97) 89.34,52.79 89.48,52.64 arc(89.59,52.57) 89.72,52.54 89.81,52.54 arc(89.99,52.59) 90.12,52.72 90.14,52.75 90.14,52.75 90.16,52.79 arc(90.35,52.97) 90.61,53.04 90.7,53.04 arc(90.86,53.08) 90.97,53.2 91,53.25 arc(91.03,53.3) 91.07,53.34 arc(91.26,53.49) 91.51,53.54 91.54,53.54 arc(91.69,53.58) 91.8,53.69 91.85,53.78 arc(92.07,54) 92.37,54.08 92.5,54.08 arc(92.62,54.11) 92.71,54.2 92.72,54.22 arc(92.93,54.43) 93.22,54.51 93.29,54.51 arc(93.48,54.56) 93.62,54.7 93.66,54.77 arc(93.86,54.97) 94.13,55.04 arc(94.3,55.08) 94.45,55.17 94.47,55.19 arc(94.52,55.27) 94.54,55.36 arc(94.52,55.44) 94.49,55.53 94.43,55.63 arc(94.34,55.94) 94.44,56.24 94.45,56.26 arc(94.5,56.41) 94.48,56.58 94.45,56.64 arc(94.42,56.72) 94.4,56.8 arc(94.4,56.81) 94.4,56.81 arc(94.4,56.82) 94.4,56.82 arc(94.39,56.87) 94.39,56.92 94.39,56.97 arc(94.43,57.16) 94.53,57.31 94.54,57.33 arc(94.75,57.46) 94.99,57.51 95.05,57.51 arc(95.15,57.53) 95.23,57.58 95.35,57.7 arc(95.41,57.79) 95.43,57.89 arc(95.43,57.93) 95.42,57.97 95.38,58.03 arc(95.32,58.08) 95.24,58.07 v4(94.99,57.93)
QSFPDD1_RX2_N: length 73.1
  L16_SIG6 w0.079: v1(49.1,39.1) 49.1,39.21 49.26,39.37 49.45,39.37 49.45,39.37 49.52,39.37 49.52,39.37 49.59,39.37 53.46,35.51 61.05,35.51 64.46,38.92 65.55,38.92 66.06,39.43 66.06,41.53 66.89,42.35 66.89,43.64 67.7,44.45 70,44.45 71.09,45.54 72.97,45.54 75.44,48 87.61,48 88.3,47.31 89.85,47.31 arc(89.85,47.31) 89.85,47.31 arc(89.86,47.31) 89.86,47.31 arc(89.87,47.31) 89.87,47.31 89.88,47.32 arc(90.14,47.39) 90.33,47.59 90.36,47.64 arc(90.49,47.77) 90.66,47.81 90.71,47.81 arc(90.87,47.77) 90.98,47.66 91.01,47.61 arc(91.22,47.39) 91.52,47.31 91.57,47.31 arc(91.84,47.39) 92.04,47.58 92.07,47.64 arc(92.2,47.77) 92.37,47.81 92.44,47.81 arc(92.6,47.77) 92.71,47.66 92.74,47.61 arc(92.95,47.39) 93.25,47.31 93.31,47.31 arc(93.58,47.39) 93.78,47.58 93.81,47.64 arc(93.94,47.77) 94.11,47.81 94.17,47.81 arc(94.44,47.89) 94.64,48.08 94.67,48.14 arc(94.8,48.27) 94.98,48.31 95.04,48.31 arc(95.31,48.39) 95.51,48.58 95.54,48.64 arc(95.67,48.77) 95.85,48.81 95.9,48.81 arc(96.18,48.89) 96.37,49.08 96.4,49.14 arc(96.53,49.27) 96.71,49.31 96.77,49.31 arc(97.04,49.39) 97.24,49.58 97.27,49.64 arc(97.4,49.77) 97.57,49.81 97.64,49.81 arc(97.91,49.88) 98.1,50.08 98.13,50.13 arc(98.26,50.26) 98.45,50.31 98.5,50.31 arc(98.78,50.39) 98.97,50.58 99,50.64 arc(99.13,50.77) 99.31,50.81 99.37,50.81 arc(99.64,50.89) 99.84,51.08 99.87,51.14 arc(100,51.27) 100.18,51.31 100.25,51.31 arc(100.51,51.39) 100.71,51.59 100.77,51.7 arc(100.83,51.94) 100.76,52.18 100.71,52.27 arc(100.68,52.32) 100.67,52.38 100.67,52.53 arc(100.68,52.57) 100.7,52.61 arc(100.79,52.89) 100.75,53.17 100.7,53.29 arc(100.68,53.33) 100.68,53.38 100.68,53.4 arc(100.69,53.51) 100.72,53.61 100.77,53.72 arc(100.79,53.81) 100.8,53.9 100.8,53.97 arc(100.78,54.12) 100.71,54.25 100.7,54.27 arc(100.65,54.39) 100.67,54.51 100.73,54.64 arc(100.74,54.67) 100.75,54.7 arc(100.79,54.82) 100.79,54.94 arc(100.78,55.07) 100.74,55.19 100.7,55.29 arc(100.69,55.35) 100.68,55.41 arc(100.69,55.52) 100.72,55.63 100.76,55.72 arc(100.79,55.8) 100.79,55.89 arc(100.78,56.02) 100.75,56.14 100.69,56.27 arc(100.67,56.35) 100.66,56.43 100.66,56.48 arc(100.66,56.52) 100.67,56.56 100.76,56.76 arc(100.79,56.86) 100.8,56.97 arc(100.77,57.15) 100.67,57.3 arc(100.66,57.31) 100.66,57.31 100.58,57.39 arc(100.49,57.47) 100.38,57.51 arc(100.28,57.54) 100.19,57.54 arc(100.01,57.59) 99.88,57.72 99.86,57.75 arc(99.65,57.96) 99.36,58.04 99.32,58.04 arc(99.2,58.06) 99.1,58.13 98.9,58.33 arc(98.71,58.46) 98.48,58.51 98.44,58.51 arc(98.3,58.53) 98.17,58.62 98.15,58.64 arc(98.12,58.67) 98.09,58.72 98.04,58.8 arc(98.02,58.87) 98.02,58.94 98.07,59.03 arc(98.14,59.08) 98.21,59.07 v1(98.46,58.93)
QSFPDD1_RX2_P: length 73.1
  L16_SIG6 w0.079: v1(49.1,39.9) 49.1,39.75 49.25,39.6 49.69,39.6 53.56,35.73 60.95,35.73 64.37,39.15 65.46,39.15 65.83,39.53 65.83,41.62 66.66,42.45 66.66,43.73 67.6,44.68 69.91,44.68 70.99,45.76 72.88,45.76 75.35,48.23 86.89,48.23 87.02,48.36 87.3,48.36 87.42,48.23 87.7,48.23 87.79,48.14 87.97,48.14 88.17,47.94 88.17,47.76 88.39,47.54 89.84,47.54 arc(89.85,47.54) 89.86,47.54 89.87,47.54 arc(90.02,47.59) 90.13,47.7 90.16,47.75 arc(90.37,47.96) 90.66,48.04 90.71,48.04 arc(90.98,47.97) 91.18,47.78 91.21,47.72 arc(91.34,47.59) 91.52,47.54 91.57,47.54 arc(91.73,47.58) 91.84,47.7 91.87,47.75 arc(92.08,47.96) 92.37,48.04 92.44,48.04 arc(92.71,47.97) 92.91,47.77 92.94,47.72 arc(93.07,47.59) 93.25,47.54 93.31,47.54 arc(93.46,47.58) 93.58,47.7 93.61,47.75 arc(93.82,47.96) 94.11,48.04 94.17,48.04 arc(94.33,48.08) 94.44,48.2 94.47,48.25 arc(94.68,48.46) 94.98,48.54 95.04,48.54 arc(95.2,48.58) 95.31,48.7 95.34,48.75 arc(95.55,48.96) 95.85,49.04 95.9,49.04 arc(96.06,49.08) 96.18,49.2 96.21,49.25 arc(96.42,49.46) 96.71,49.54 96.77,49.54 arc(96.92,49.58) 97.04,49.7 97.07,49.75 arc(97.28,49.96) 97.57,50.04 97.64,50.04 arc(97.79,50.08) 97.9,50.19 97.93,50.24 arc(98.15,50.46) 98.45,50.54 98.5,50.54 arc(98.66,50.58) 98.78,50.7 98.81,50.75 arc(99.02,50.96) 99.31,51.04 99.37,51.04 arc(99.53,51.08) 99.64,51.2 99.67,51.25 arc(99.88,51.46) 100.18,51.54 100.25,51.54 arc(100.4,51.58) 100.51,51.7 100.57,51.81 arc(100.6,51.94) 100.56,52.06 100.51,52.15 arc(100.46,52.26) 100.45,52.38 100.45,52.53 arc(100.46,52.63) 100.51,52.73 arc(100.56,52.9) 100.54,53.08 100.49,53.2 arc(100.46,53.29) 100.45,53.38 100.45,53.4 arc(100.47,53.55) 100.51,53.69 100.56,53.81 arc(100.57,53.85) 100.58,53.9 100.58,53.97 arc(100.56,54.05) 100.53,54.11 100.51,54.14 arc(100.42,54.37) 100.46,54.61 100.52,54.73 arc(100.53,54.75) 100.54,54.77 arc(100.56,54.85) 100.56,54.93 100.56,54.94 arc(100.56,55.02) 100.53,55.1 100.49,55.2 arc(100.46,55.3) 100.45,55.41 arc(100.47,55.57) 100.51,55.72 100.55,55.8 arc(100.56,55.85) 100.57,55.89 arc(100.56,55.97) 100.53,56.05 100.48,56.18 arc(100.44,56.3) 100.43,56.43 100.43,56.48 arc(100.44,56.57) 100.46,56.65 100.55,56.85 arc(100.56,56.91) 100.57,56.97 arc(100.55,57.06) 100.5,57.14 arc(100.5,57.15) 100.49,57.15 100.41,57.23 arc(100.33,57.29) 100.22,57.31 100.19,57.31 arc(99.89,57.39) 99.68,57.6 99.66,57.64 arc(99.53,57.76) 99.36,57.81 99.32,57.81 arc(99.11,57.85) 98.94,57.97 98.73,58.17 arc(98.62,58.25) 98.48,58.28 98.44,58.28 arc(98.21,58.32) 98.01,58.46 97.99,58.48 arc(97.94,58.54) 97.89,58.6 97.84,58.69 arc(97.79,58.86) 97.81,59.04 97.88,59.15 arc(97.89,59.22) 97.84,59.29 v1(97.59,59.43)
QSFPDD1_RX3_N: length 55.6
  L16_SIG6 w0.079: v1(57.89,39.5) 58.18,39.79 59.54,39.79 59.55,39.78 60.78,39.78 61.63,40.62 61.63,42.91 62.29,43.57 62.29,45.09 63.92,46.72 63.92,49.74 66.54,52.35 86.64,52.35 87.73,52.8 88.44,52.8 88.85,52.38 88.85,51.85 89.21,51.48 arc(89.4,51.36) 89.63,51.31 89.83,51.31 arc(90.11,51.39) 90.32,51.59 90.33,51.62 arc(90.38,51.69) 90.45,51.75 90.47,51.77 arc(90.53,51.8) 90.6,51.81 90.71,51.81 arc(90.86,51.78) 90.97,51.67 90.99,51.65 91.02,51.6 arc(91.23,51.39) 91.52,51.31 91.57,51.31 arc(91.84,51.39) 92.03,51.58 92.06,51.64 arc(92.19,51.77) 92.37,51.81 92.44,51.81 arc(92.6,51.77) 92.71,51.66 92.74,51.61 arc(92.96,51.39) 93.25,51.31 93.3,51.31 arc(93.57,51.39) 93.77,51.58 93.8,51.64 arc(93.93,51.77) 94.11,51.81 94.15,51.81 arc(94.34,51.85) 94.49,51.96 94.63,52.09 arc(94.72,52.23) 94.75,52.39 arc(94.74,52.53) 94.7,52.66 94.64,52.79 arc(94.62,52.85) 94.62,52.92 arc(94.63,53) 94.65,53.07 94.68,53.15 arc(94.79,53.35) 94.93,53.53 95.37,53.97 arc(95.54,54.22) 95.6,54.52 95.6,54.9 arc(95.58,55.08) 95.53,55.25 95.5,55.32 arc(95.49,55.37) 95.48,55.43 95.48,55.48 arc(95.51,55.61) 95.58,55.72 95.87,56.01 arc(96.22,56.24) 96.63,56.33 96.68,56.33 arc(96.93,56.38) 97.14,56.52 97.31,56.69 arc(97.41,56.75) 97.52,56.78 97.63,56.78 arc(97.88,56.84) 98.07,57.03 98.07,57.03 arc(98.14,57.08) 98.21,57.07 v1(98.46,56.93)
QSFPDD1_RX3_P: length 55.5
  L16_SIG6 w0.079: v1(57.89,40.3) 58.15,40.03 59.62,40.03 59.65,40.01 60.69,40.01 61.4,40.72 61.4,43 62.06,43.67 62.06,45.19 62.72,45.85 62.72,46.03 62.72,46.03 62.72,46.21 62.86,46.35 63.05,46.35 63.05,46.35 63.23,46.35 63.7,46.82 63.7,49.83 66.44,52.58 86.6,52.58 87.68,53.03 88.53,53.03 89.08,52.48 89.08,51.94 89.38,51.65 arc(89.49,51.57) 89.63,51.54 89.83,51.54 arc(90,51.59) 90.12,51.71 90.13,51.73 arc(90.21,51.84) 90.31,51.93 90.33,51.95 arc(90.46,52.02) 90.6,52.04 90.71,52.04 arc(90.97,51.98) 91.16,51.8 91.18,51.77 91.21,51.72 arc(91.34,51.59) 91.52,51.54 91.57,51.54 arc(91.72,51.58) 91.84,51.7 91.87,51.75 arc(92.08,51.96) 92.37,52.04 92.44,52.04 arc(92.71,51.97) 92.91,51.77 92.94,51.72 arc(93.07,51.59) 93.25,51.54 93.3,51.54 arc(93.46,51.58) 93.57,51.7 93.6,51.75 arc(93.82,51.96) 94.11,52.04 94.15,52.04 arc(94.25,52.06) 94.33,52.12 94.47,52.25 arc(94.51,52.32) 94.52,52.39 arc(94.51,52.48) 94.49,52.57 94.43,52.7 arc(94.4,52.81) 94.39,52.92 arc(94.4,53.04) 94.44,53.16 94.47,53.24 arc(94.6,53.48) 94.77,53.69 95.21,54.13 arc(95.33,54.31) 95.37,54.52 95.37,54.9 arc(95.36,55.04) 95.32,55.17 95.29,55.23 arc(95.26,55.33) 95.25,55.43 95.25,55.48 arc(95.3,55.7) 95.42,55.89 95.71,56.17 arc(96.13,56.46) 96.63,56.55 96.68,56.55 arc(96.84,56.59) 96.98,56.68 97.15,56.85 arc(97.32,56.97) 97.52,57.01 97.63,57.01 arc(97.77,57.04) 97.87,57.15 97.88,57.15 arc(97.89,57.22) 97.84,57.29 v1(97.59,57.43)
QSFPDD1_RX4_N: length 60.3
  L03_SIG1 w0.079: v4(95.86,56.43) 95.61,56.29 arc(95.57,56.22) 95.58,56.15 95.6,56.11 arc(95.67,56.04) 95.76,56.02 95.79,56.02 95.92,56.02 arc(96.11,55.98) 96.27,55.87 96.33,55.81 arc(96.43,55.66) 96.46,55.49 96.46,55.4 arc(96.45,55.29) 96.42,55.18 arc(96.4,55.12) 96.38,55.06 arc(96.38,55) 96.37,54.94 96.37,54.93 arc(96.38,54.87) 96.4,54.8 96.46,54.67 arc(96.5,54.43) 96.46,54.2 96.36,53.98 arc(96.35,53.94) 96.35,53.91 arc(96.36,53.85) 96.37,53.79 96.4,53.73 arc(96.45,53.58) 96.46,53.41 96.46,53.37 arc(96.43,53.19) 96.32,53.04 96.24,52.96 arc(96.08,52.85) 95.89,52.81 95.84,52.81 arc(95.66,52.77) 95.53,52.64 95.5,52.58 arc(95.3,52.39) 95.03,52.31 94.97,52.31 arc(94.79,52.27) 94.66,52.14 94.63,52.08 arc(94.43,51.89) 94.16,51.81 94.11,51.81 arc(93.93,51.77) 93.8,51.64 93.77,51.58 arc(93.57,51.39) 93.3,51.31 93.24,51.31 arc(93.07,51.27) 92.94,51.14 92.91,51.08 arc(92.71,50.89) 92.44,50.81 92.38,50.81 arc(92.09,50.89) 91.88,51.11 91.85,51.16 arc(91.73,51.27) 91.58,51.31 91.53,51.31 arc(91.35,51.27) 91.22,51.14 91.19,51.08 arc(90.99,50.89) 90.72,50.81 90.65,50.81 arc(90.47,50.77) 90.34,50.64 90.31,50.58 arc(90.11,50.39) 89.84,50.31 89.67,50.31 89.35,50.24 88.51,50.24 87.75,49.48 79.3,49.48 78.94,49.12 70.46,49.12 69.6,48.26 69.6,47.35 68.21,45.95 arc(68.12,45.89) 68.03,45.83 66.43,45.17 arc(66.32,45.11) 66.22,45.03 arc(65.98,44.81) 65.75,44.59 arc(65.61,44.39) 65.54,44.16 arc(65.39,43.7) 65.11,43.31 64.36,42.56 arc(63.77,41.68) 63.56,40.63 63.56,38.73 59.35,34.52 54.25,34.52 52.82,35.95 52.82,36.69 52.53,36.98 52.31,36.98 v4(52.03,36.7)
QSFPDD1_RX4_P: length 60.3
  L03_SIG1 w0.079: v4(94.99,55.93) 95.24,56.07 arc(95.32,56.08) 95.38,56.03 95.4,56 arc(95.55,55.85) 95.76,55.79 95.78,55.79 95.92,55.79 arc(96.02,55.77) 96.11,55.71 96.17,55.65 arc(96.22,55.58) 96.24,55.49 96.24,55.4 arc(96.23,55.33) 96.21,55.27 arc(96.18,55.19) 96.16,55.11 arc(96.15,55.02) 96.14,54.94 96.14,54.93 arc(96.15,54.82) 96.19,54.72 96.24,54.58 arc(96.27,54.43) 96.24,54.28 96.15,54.06 arc(96.13,53.99) 96.12,53.91 arc(96.13,53.8) 96.16,53.7 96.19,53.64 arc(96.22,53.53) 96.23,53.41 96.23,53.37 arc(96.22,53.28) 96.16,53.2 96.08,53.12 arc(95.99,53.06) 95.89,53.04 95.84,53.04 arc(95.55,52.96) 95.33,52.75 95.3,52.7 arc(95.19,52.58) 95.03,52.54 94.97,52.54 arc(94.68,52.46) 94.46,52.25 94.43,52.2 arc(94.32,52.08) 94.16,52.04 94.11,52.04 arc(93.82,51.96) 93.6,51.75 93.57,51.7 arc(93.46,51.58) 93.3,51.54 93.24,51.54 arc(92.95,51.46) 92.74,51.25 92.71,51.2 arc(92.6,51.08) 92.44,51.04 92.38,51.04 arc(92.21,51.09) 92.08,51.22 92.05,51.27 arc(91.85,51.47) 91.58,51.54 91.53,51.54 arc(91.23,51.46) 91.02,51.25 90.99,51.2 arc(90.88,51.08) 90.72,51.04 90.65,51.04 arc(90.36,50.96) 90.14,50.75 90.11,50.7 arc(90,50.58) 89.84,50.54 89.65,50.54 89.32,50.47 89.19,50.47 89.06,50.6 88.81,50.6 88.68,50.47 88.42,50.47 87.71,49.76 87.43,49.76 87.28,49.91 87.04,49.91 86.87,49.74 86.64,49.74 86.47,49.91 86.23,49.91 86.08,49.76 85.8,49.76 85.67,49.89 85.4,49.89 85.22,49.71 79.2,49.71 78.85,49.35 70.37,49.35 69.37,48.36 69.37,47.44 68.05,46.12 arc(68,46.08) 67.94,46.05 66.35,45.39 arc(66.2,45.31) 66.06,45.2 arc(65.82,44.98) 65.59,44.75 arc(65.41,44.49) 65.31,44.2 arc(65.19,43.8) 64.95,43.47 64.2,42.72 arc(63.56,41.76) 63.33,40.63 63.33,38.83 59.26,34.75 54.35,34.75 53.05,36.05 53.05,36.79 52.63,37.21 52.31,37.21 v4(52.03,37.5)
QSFPDD1_RX5_N: length 52.8
  L03_SIG1 w0.079: v4(54.96,37.1) 55.24,37.38 55.54,37.38 55.75,37.17 55.75,36.35 56.48,35.62 58.78,35.62 62.46,39.31 arc(62.49,39.34) 62.49,39.38 62.49,42.17 arc(62.74,43.39) 63.43,44.43 65.03,46.03 68.65,49.64 arc(69.87,50.46) 71.32,50.75 78.69,50.75 78.8,50.85 83.4,50.85 83.65,51.11 87.71,51.11 88.06,51.46 89.28,51.46 arc(89.32,51.46) 89.35,51.43 arc(89.48,51.34) 89.64,51.31 89.84,51.31 arc(90.11,51.39) 90.31,51.58 90.34,51.64 arc(90.47,51.77) 90.65,51.81 90.72,51.81 arc(90.99,51.89) 91.19,52.08 91.22,52.14 arc(91.36,52.27) 91.54,52.32 arc(91.71,52.28) 91.83,52.16 91.86,52.11 arc(92.08,51.89) 92.37,51.81 92.45,51.81 arc(92.73,51.89) 92.92,52.08 92.93,52.1 arc(93.06,52.23) 93.24,52.27 93.33,52.27 arc(93.6,52.35) 93.8,52.55 93.85,52.64 arc(93.98,52.77) 94.16,52.81 94.17,52.81 arc(94.44,52.89) 94.63,53.08 arc(94.68,53.15) 94.74,53.22 arc(94.82,53.27) 94.92,53.29 95.02,53.29 arc(95.24,53.33) 95.43,53.46 95.49,53.52 arc(95.59,53.66) 95.66,53.83 arc(95.74,54.13) v4(95.86,54.43)
QSFPDD1_RX5_P: length 52.5
  L03_SIG1 w0.079: v4(94.99,53.93) 95.24,54.07 arc(95.32,54.08) 95.38,54.03 95.42,53.97 arc(95.43,53.92) 95.43,53.88 arc(95.39,53.77) 95.32,53.68 95.27,53.62 arc(95.15,53.54) 95.02,53.52 94.92,53.52 arc(94.73,53.48) 94.58,53.38 arc(94.5,53.29) 94.44,53.2 94.44,53.2 arc(94.32,53.08) 94.17,53.04 94.16,53.04 arc(93.87,52.96) 93.65,52.75 93.6,52.66 arc(93.49,52.55) 93.33,52.5 93.24,52.5 arc(92.95,52.43) 92.73,52.21 92.73,52.2 arc(92.61,52.08) 92.45,52.04 92.37,52.04 arc(92.19,52.09) 92.06,52.22 92.03,52.27 arc(91.82,52.48) 91.54,52.55 arc(91.24,52.47) 91.02,52.25 90.99,52.2 arc(90.88,52.08) 90.72,52.04 90.65,52.04 arc(90.36,51.96) 90.14,51.75 90.11,51.7 arc(90,51.58) 89.84,51.54 89.64,51.54 arc(89.57,51.56) 89.51,51.6 arc(89.4,51.67) 89.28,51.69 87.97,51.69 87.61,51.34 83.55,51.34 83.3,51.08 78.7,51.08 78.6,50.98 71.32,50.98 arc(69.79,50.68) 68.49,49.81 64.87,46.19 63.27,44.59 arc(62.53,43.48) 62.26,42.17 62.26,39.43 58.69,35.85 56.57,35.85 55.98,36.45 55.98,37.27 55.64,37.61 55.24,37.61 v4(54.96,37.9)
QSFPDD1_RX6_N: length 64.2
  L16_SIG6 w0.079: v1(52.03,39.1) 52.32,39.39 52.86,39.39 55.46,36.79 60.81,36.79 63.79,39.76 63.79,41.61 65.39,43.21 65.39,44.38 66.56,45.54 68.21,45.54 69.22,46.56 69.22,47.96 70.52,49.25 77.83,49.25 78.04,49.46 86.99,49.46 87.06,49.54 87.94,49.54 89.17,48.31 89.83,48.31 arc(90.11,48.39) 90.31,48.59 90.35,48.66 arc(90.48,48.77) 90.65,48.81 90.73,48.81 arc(90.86,48.78) 90.95,48.68 91,48.6 arc(91.21,48.39) 91.49,48.31 91.58,48.31 arc(91.85,48.39) 92.05,48.58 92.08,48.64 arc(92.21,48.77) 92.38,48.81 92.41,48.81 arc(92.58,48.77) 92.71,48.64 92.73,48.61 arc(92.94,48.39) 93.24,48.31 93.28,48.31 arc(93.57,48.39) 93.78,48.61 93.81,48.65 arc(93.93,48.77) 94.09,48.81 94.17,48.81 arc(94.44,48.89) 94.64,49.08 94.66,49.12 arc(94.8,49.26) 95,49.31 95.06,49.31 arc(95.31,49.38) 95.49,49.56 95.54,49.64 arc(95.67,49.77) 95.84,49.81 95.92,49.81 arc(96.19,49.89) 96.38,50.08 96.4,50.12 arc(96.55,50.26) 96.74,50.31 96.75,50.31 arc(97.03,50.39) 97.24,50.6 97.25,50.62 arc(97.39,50.76) 97.59,50.81 97.63,50.81 arc(97.89,50.89) 98.09,51.08 98.1,51.11 arc(98.26,51.26) 98.46,51.31 98.51,51.31 arc(98.79,51.39) 98.99,51.59 99.01,51.64 arc(99.14,51.77) 99.32,51.81 99.36,51.81 arc(99.55,51.85) 99.7,51.96 99.78,52.03 arc(99.89,52.19) 99.92,52.39 99.92,52.47 arc(99.91,52.58) 99.88,52.68 99.84,52.78 arc(99.82,52.84) 99.82,52.91 99.82,52.96 arc(99.82,53) 99.83,53.04 99.86,53.12 arc(99.91,53.27) 99.93,53.43 99.93,53.51 arc(99.9,53.67) 99.8,53.8 99.69,53.92 arc(99.56,54.01) 99.4,54.04 99.36,54.04 arc(99.2,54.07) 99.07,54.16 98.9,54.33 arc(98.71,54.46) 98.48,54.51 98.44,54.51 arc(98.3,54.53) 98.17,54.62 98.15,54.64 arc(98.12,54.67) 98.09,54.72 98.04,54.8 arc(98.02,54.87) 98.02,54.94 98.07,55.03 arc(98.14,55.08) 98.21,55.07 v1(98.46,54.93)
QSFPDD1_RX6_P: length 64.2
  L16_SIG6 w0.079: v1(97.59,55.43) 97.84,55.29 arc(97.89,55.22) 97.88,55.15 97.81,55.04 arc(97.79,54.86) 97.84,54.69 97.89,54.6 arc(97.94,54.54) 97.99,54.48 98.01,54.46 arc(98.21,54.32) 98.44,54.28 98.48,54.28 arc(98.62,54.25) 98.74,54.17 98.91,54 arc(99.12,53.86) 99.36,53.81 99.4,53.81 arc(99.47,53.8) 99.53,53.76 99.64,53.64 arc(99.68,53.58) 99.7,53.51 99.7,53.43 arc(99.69,53.32) 99.65,53.2 99.62,53.13 arc(99.6,53.04) 99.59,52.96 99.59,52.91 arc(99.6,52.8) 99.63,52.69 99.67,52.59 arc(99.69,52.53) 99.7,52.47 99.7,52.39 arc(99.67,52.28) 99.62,52.19 99.54,52.12 arc(99.46,52.06) 99.36,52.04 99.32,52.04 arc(99.03,51.96) 98.82,51.75 98.79,51.7 arc(98.67,51.59) 98.51,51.54 98.46,51.54 arc(98.14,51.46) 97.91,51.22 97.89,51.19 arc(97.78,51.08) 97.63,51.04 97.59,51.04 arc(97.28,50.96) 97.05,50.73 97.04,50.71 arc(96.92,50.59) 96.75,50.54 96.74,50.54 arc(96.43,50.46) 96.21,50.23 96.19,50.2 arc(96.07,50.08) 95.92,50.04 95.84,50.04 arc(95.55,49.96) 95.34,49.75 95.3,49.68 arc(95.2,49.58) 95.06,49.54 95,49.54 arc(94.69,49.46) 94.46,49.23 94.44,49.2 arc(94.33,49.08) 94.17,49.04 94.09,49.04 arc(93.81,48.97) 93.61,48.76 93.58,48.72 arc(93.45,48.59) 93.28,48.54 93.24,48.54 arc(93.06,48.59) 92.93,48.72 92.91,48.75 arc(92.7,48.96) 92.41,49.04 92.38,49.04 arc(92.09,48.96) 91.88,48.75 91.85,48.7 arc(91.74,48.58) 91.58,48.54 91.49,48.54 arc(91.32,48.59) 91.2,48.71 91.15,48.8 arc(90.97,48.98) 90.73,49.04 90.65,49.04 arc(90.37,48.97) 90.16,48.79 arc(90.16,48.78) 90.16,48.78 90.11,48.7 arc(90,48.59) 89.83,48.54 89.26,48.54 89.06,48.74 89.06,48.93 88.88,49.12 88.69,49.12 88.04,49.77 87.5,49.77 87.38,49.89 87.1,49.89 86.9,49.69 77.95,49.69 77.74,49.48 70.42,49.48 68.99,48.05 68.99,46.66 68.11,45.77 66.46,45.77 65.16,44.47 65.16,43.3 63.56,41.71 63.56,39.86 60.72,37.02 55.56,37.02 52.96,39.61 52.31,39.61 v1(52.03,39.9)
QSFPDD1_RX7_N: length 55.2
  L16_SIG6 w0.079: v1(54.96,39.5) 55.25,39.79 55.83,39.79 57.52,38.1 60.61,38.1 62.72,40.2 62.72,42.38 63.36,43.03 63.36,44.28 66.15,47.07 66.15,49.58 67.29,50.73 76.94,50.73 77.25,51.03 88.16,51.03 88.88,50.31 89.78,50.31 arc(90.1,50.4) 90.34,50.64 arc(90.47,50.77) 90.64,50.81 90.69,50.81 arc(90.86,50.77) 90.99,50.64 91.01,50.61 arc(91.22,50.39) 91.52,50.31 91.57,50.31 arc(91.84,50.39) 92.04,50.58 92.07,50.63 arc(92.2,50.76) 92.39,50.81 92.44,50.81 arc(92.6,50.77) 92.71,50.66 92.74,50.61 arc(92.95,50.39) 93.25,50.31 93.26,50.31 arc(93.57,50.4) 93.79,50.62 93.81,50.64 arc(93.94,50.77) 94.11,50.82 94.13,50.82 arc(94.43,50.9) 94.66,51.12 arc(94.8,51.26) 94.99,51.31 95.03,51.31 arc(95.31,51.39) 95.51,51.59 95.54,51.64 arc(95.67,51.77) 95.84,51.81 95.93,51.81 arc(96.19,51.88) 96.38,52.08 96.43,52.16 arc(96.54,52.27) 96.7,52.31 96.79,52.31 arc(96.88,52.32) 96.96,52.34 97.03,52.37 arc(97.13,52.42) 97.21,52.51 97.26,52.61 arc(97.38,52.73) 97.55,52.77 97.57,52.77 arc(97.73,52.79) 97.89,52.84 arc(98.07,52.91) 98.25,52.94 arc(98.35,52.94) v1(98.46,52.93)
QSFPDD1_RX7_P: length 55.1
  L16_SIG6 w0.079: v1(97.59,53.43) 97.84,53.29 arc(97.89,53.22) 97.88,53.15 97.85,53.1 arc(97.83,53.07) 97.8,53.05 arc(97.69,53.01) 97.57,53 97.55,53 arc(97.27,52.93) 97.06,52.72 97.01,52.63 arc(96.99,52.6) 96.96,52.58 96.89,52.56 arc(96.84,52.55) 96.79,52.54 96.7,52.54 arc(96.43,52.47) 96.23,52.27 96.18,52.19 arc(96.08,52.08) 95.93,52.04 95.84,52.04 arc(95.55,51.96) 95.34,51.75 95.31,51.7 arc(95.19,51.59) 95.03,51.54 94.99,51.54 arc(94.68,51.46) 94.46,51.24 arc(94.32,51.1) 94.13,51.05 94.11,51.05 arc(93.82,50.97) 93.61,50.76 93.6,50.73 arc(93.46,50.59) 93.26,50.54 93.25,50.54 arc(93.07,50.59) 92.94,50.72 92.91,50.77 arc(92.71,50.97) 92.44,51.04 92.39,51.04 arc(92.09,50.96) 91.87,50.74 91.84,50.7 arc(91.73,50.58) 91.57,50.54 91.52,50.54 arc(91.34,50.59) 91.21,50.72 91.19,50.75 arc(90.98,50.97) 90.69,51.04 90.64,51.04 arc(90.35,50.96) 90.14,50.75 arc(89.99,50.6) 89.78,50.54 88.97,50.54 88.26,51.26 77.15,51.26 76.85,50.96 67.2,50.96 65.92,49.68 65.92,47.16 63.13,44.37 63.13,43.12 62.49,42.48 62.49,40.3 60.52,38.33 57.61,38.33 55.92,40.02 55.23,40.02 v1(54.96,40.3)
QSFPDD1_TX0_N: length 48.5
  L03_SIG1 w0.079: v4(57.89,49.9) 58.15,49.63 58.34,49.63 58.37,49.64 arc(58.37,49.65) 58.37,49.66 arc(58.39,49.67) 58.4,49.68 arc(58.57,49.9) 58.63,50.18 58.63,55.5 arc(58.69,55.94) 58.86,56.36 arc(58.91,56.42) 58.96,56.48 60.59,58.11 arc(60.67,58.18) 60.76,58.23 62.61,59.08 arc(62.94,59.17) 63.28,59.17 arc(63.33,59.16) 63.39,59.16 76.03,59.16 arc(76.48,59.07) 76.87,58.81 arc(77.1,58.66) 77.38,58.6 85.78,58.6 arc(86.01,58.56) 86.2,58.43 86.92,57.71 arc(87.09,57.6) 87.3,57.55 87.84,57.55 arc(88.03,57.53) 88.21,57.47 arc(88.33,57.4) 88.43,57.31 88.54,57.2 arc(88.57,57.17) 88.6,57.15 arc(88.74,57.08) 88.89,57.05 88.97,57.05 arc(89.15,57.1) 89.28,57.23 89.29,57.25 arc(89.49,57.45) 89.75,57.52 89.9,57.52 arc(90.16,57.45) 90.35,57.26 90.37,57.23 arc(90.48,57.11) 90.64,57.07 90.77,57.07 arc(90.87,57.1) 90.95,57.17 91.01,57.28 arc(91.21,57.48) 91.48,57.55 91.52,57.55 arc(91.65,57.58) 91.76,57.65 91.76,57.65 arc(91.85,57.78) 91.88,57.94 91.88,58 arc(91.86,58.11) 91.79,58.2 91.77,58.23 arc(91.67,58.29) 91.57,58.31 91.52,58.31 arc(91.26,58.38) 91.07,58.57 91.01,58.68 arc(90.89,58.8) 90.73,58.84 90.62,58.84 arc(90.38,58.91) 90.2,59.09 90.16,59.15 arc(90.06,59.25) 89.92,59.29 89.75,59.29 arc(89.33,59.46) 89.16,59.88 89.16,59.94 arc(89.34,60.38) 89.79,60.57 89.9,60.57 arc(90,60.56) 90.09,60.53 arc(90.37,60.44) v4(90.67,60.43)
QSFPDD1_TX0_P: length 48.5
  L03_SIG1 w0.079: v4(89.8,59.93) 90.05,60.07 arc(90.09,60.13) 90.08,60.21 90.05,60.27 arc(90.02,60.3) 89.99,60.32 arc(89.95,60.33) 89.9,60.34 89.79,60.34 arc(89.51,60.22) 89.39,59.94 89.39,59.88 arc(89.5,59.62) 89.75,59.52 89.92,59.52 arc(90.17,59.45) 90.36,59.26 90.39,59.2 arc(90.49,59.1) 90.62,59.07 90.73,59.07 arc(91,58.99) 91.2,58.79 91.26,58.69 arc(91.37,58.58) 91.52,58.54 91.57,58.54 arc(91.76,58.5) 91.93,58.39 91.95,58.36 arc(92.07,58.19) 92.11,58 92.11,57.94 arc(92.06,57.7) 91.92,57.49 arc(91.74,57.37) 91.52,57.33 91.48,57.33 arc(91.32,57.28) 91.21,57.17 91.14,57.06 arc(90.99,56.9) 90.77,56.84 90.64,56.84 arc(90.37,56.91) 90.17,57.11 90.15,57.14 arc(90.05,57.25) 89.9,57.29 89.75,57.29 arc(89.6,57.25) 89.49,57.14 89.48,57.12 arc(89.27,56.9) 88.97,56.83 88.89,56.83 arc(88.74,56.84) 88.6,56.89 arc(88.48,56.95) 88.38,57.04 88.27,57.15 arc(88.24,57.18) 88.21,57.2 arc(88.03,57.29) 87.84,57.33 87.3,57.33 arc(87,57.38) 86.76,57.55 86.56,57.74 86.38,57.74 86.18,57.94 86.18,58.12 86.04,58.27 arc(85.92,58.34) 85.78,58.37 77.38,58.37 arc(77.01,58.44) 76.7,58.65 arc(76.39,58.86) 76.03,58.93 63.39,58.93 arc(63.31,58.93) 63.24,58.94 arc(62.97,58.95) 62.71,58.87 60.85,58.02 arc(60.8,57.99) 60.75,57.95 59.12,56.32 arc(59.09,56.28) 59.06,56.24 arc(58.91,55.88) 58.86,55.5 58.86,50.18 arc(58.78,49.8) 58.55,49.5 arc(58.45,49.43) 58.34,49.4 58.22,49.4 arc(58.2,49.4) 58.18,49.39 58.17,49.38 v4(57.89,49.1)
QSFPDD1_TX1_N: length 51.9
  L03_SIG1 w0.079: v4(49.1,49.5) 49.39,49.2 49.67,49.2 49.94,49.48 49.94,50.31 50.95,51.31 55.81,51.31 57.36,52.86 57.36,58.07 59.75,60.45 arc(61.11,61.42) 62.71,61.89 arc(62.77,61.9) 62.84,61.9 75.92,61.9 arc(76.42,61.8) 76.85,61.52 77.73,60.63 arc(78.15,60.35) 78.65,60.25 85.44,60.25 arc(85.5,60.25) 85.56,60.24 arc(85.63,60.23) 85.7,60.2 86.11,60 arc(86.17,59.97) 86.22,59.93 87.47,58.68 arc(87.5,58.64) 87.55,58.61 arc(87.64,58.57) 87.74,58.54 arc(87.8,58.54) 87.87,58.54 88.05,58.54 arc(88.15,58.56) 88.23,58.61 88.58,58.95 arc(88.68,59.01) 88.8,59.04 88.97,59.04 arc(89.25,58.96) 89.46,58.76 89.51,58.68 arc(89.59,58.59) 89.7,58.57 89.85,58.57 arc(89.98,58.55) 90.11,58.51 arc(90.38,58.42) v4(90.67,58.43)
QSFPDD1_TX1_P: length 51.8
  L03_SIG1 w0.079: v4(89.8,57.93) 90.05,58.07 arc(90.09,58.13) 90.08,58.21 90.06,58.25 arc(90.04,58.28) 90.01,58.3 arc(89.93,58.33) 89.85,58.34 89.7,58.34 arc(89.47,58.4) 89.31,58.56 89.26,58.64 arc(89.14,58.76) 88.97,58.81 88.84,58.81 arc(88.77,58.8) 88.71,58.76 88.39,58.45 arc(88.23,58.34) 88.05,58.31 87.87,58.31 arc(87.79,58.31) 87.71,58.32 arc(87.63,58.33) 87.55,58.36 arc(87.42,58.42) 87.31,58.51 86.05,59.77 arc(86.03,59.78) 86.01,59.8 85.6,59.99 arc(85.57,60.01) 85.53,60.02 arc(85.48,60.02) 85.44,60.02 78.65,60.02 arc(78.07,60.14) 77.57,60.47 76.69,61.35 arc(76.33,61.59) 75.92,61.67 62.84,61.67 arc(62.78,61.67) 62.73,61.67 arc(61.21,61.22) 59.91,60.29 57.59,57.97 57.59,52.77 55.91,51.08 51.04,51.08 50.17,50.21 50.17,49.38 49.77,48.97 49.37,48.97 v4(49.1,48.7)
QSFPDD1_TX2_N: length 47.6
  L16_SIG6 w0.079: v1(57.89,47.5) 57.46,47.07 57.26,47.07 57.13,47.2 57.13,52.74 57.69,53.3 57.69,55.32 60.09,57.72 60.23,57.72 60.33,57.62 60.33,57.53 60.46,57.41 60.67,57.41 60.79,57.53 60.79,57.69 60.92,57.81 61.32,57.81 62.3,58.79 76.17,58.79 76.18,58.78 86.81,58.78 87.21,58.37 88.09,58.37 88.54,58.81 89.04,58.81 89.4,58.46 arc(89.51,58.38) 89.65,58.36 91.66,58.36 arc(91.79,58.38) 91.91,58.46 92.13,58.68 arc(92.24,58.75) 92.36,58.78 92.5,58.78 arc(92.67,58.81) 92.82,58.92 92.88,59.03 arc(92.94,59.08) 93.02,59.07 v1(93.26,58.93)
QSFPDD1_TX2_P: length 47.6
  L16_SIG6 w0.079: v1(92.4,59.43) 92.64,59.29 arc(92.69,59.22) 92.68,59.15 92.63,59.06 arc(92.57,59.02) 92.5,59 92.36,59 arc(92.15,58.96) 91.97,58.84 91.75,58.62 arc(91.71,58.59) 91.66,58.58 89.65,58.58 arc(89.6,58.59) 89.56,58.62 89.14,59.04 88.44,59.04 88,58.6 87.31,58.6 86.9,59.01 76.28,59.01 76.27,59.02 62.2,59.02 61.23,58.04 60.34,58.04 60.25,57.95 59.99,57.95 57.46,55.42 57.46,53.39 56.9,52.83 56.9,47.1 57.16,46.84 57.74,46.84 v1(57.89,46.7)
QSFPDD1_TX3_N: length 60.3
  L16_SIG6 w0.079: v1(49.1,47.1) 49.38,46.81 49.61,46.81 51.89,49.1 55.4,49.1 56.04,48.47 56.04,46.54 57.08,45.49 58.1,45.49 58.63,46.03 58.63,53.11 58.94,53.41 58.94,55.11 59.93,56.11 61.88,56.11 62.36,56.59 68.97,56.59 70.15,57.78 78.4,57.78 79.15,57.03 82.58,57.03 83.06,57.51 86.18,57.51 86.64,57.06 88.94,57.06 arc(89.04,57.07) 89.13,57.11 arc(89.16,57.14) 89.19,57.16 89.43,57.4 arc(89.57,57.5) 89.74,57.53 89.85,57.53 arc(90.12,57.46) 90.32,57.26 arc(90.32,57.26) 90.32,57.26 90.35,57.21 arc(90.48,57.08) 90.66,57.03 90.71,57.03 arc(90.84,57.06) 90.95,57.15 arc(90.97,57.17) 90.98,57.19 91.01,57.24 arc(91.07,57.32) 91.13,57.38 arc(91.31,57.49) 91.52,57.53 91.58,57.53 arc(91.71,57.57) 91.79,57.67 arc(91.82,57.73) 91.85,57.78 arc(91.87,57.8) 91.88,57.82 91.9,57.85 arc(92,57.95) 92.11,58.02 arc(92.24,58.07) 92.38,58.08 92.47,58.08 arc(92.59,58.06) 92.71,58.01 92.78,57.96 arc(92.87,57.88) 92.95,57.78 92.97,57.74 arc(93.03,57.6) 93.05,57.44 arc(93.11,57.17) v1(93.26,56.93)
QSFPDD1_TX3_P: length 60.3
  L16_SIG6 w0.079: v1(92.4,57.43) 92.64,57.29 arc(92.72,57.28) 92.78,57.32 92.81,57.37 arc(92.82,57.4) 92.83,57.43 arc(92.81,57.53) 92.77,57.63 92.75,57.66 arc(92.71,57.72) 92.65,57.77 92.58,57.82 arc(92.52,57.84) 92.47,57.85 92.38,57.85 arc(92.3,57.84) 92.22,57.81 92.21,57.81 arc(92.14,57.77) 92.08,57.71 92.06,57.68 arc(92.05,57.67) 92.04,57.65 arc(92.02,57.62) 92.01,57.59 arc(91.84,57.38) 91.58,57.3 91.52,57.3 arc(91.34,57.26) 91.21,57.13 91.18,57.07 arc(91.16,57.04) 91.13,57 arc(90.94,56.85) 90.71,56.8 90.66,56.8 arc(90.48,56.83) 90.32,56.91 arc(90.23,56.99) 90.15,57.09 90.12,57.15 arc(90.01,57.26) 89.85,57.3 89.74,57.3 arc(89.66,57.29) 89.59,57.24 89.35,57 arc(89.31,56.96) 89.26,56.92 arc(89.11,56.85) 88.94,56.83 88.34,56.83 88.22,56.7 87.94,56.7 87.81,56.83 87.53,56.83 87.4,56.7 87.13,56.7 87,56.83 86.54,56.83 86.09,57.28 85.51,57.28 85.34,57.12 85.13,57.12 84.97,57.28 83.15,57.28 82.67,56.8 79.06,56.8 78.31,57.55 70.25,57.55 69.06,56.37 62.46,56.37 61.98,55.88 60.03,55.88 59.16,55.02 59.16,53.32 58.86,53.01 58.86,45.93 58.19,45.26 56.99,45.26 55.81,46.44 55.81,48.37 55.31,48.87 51.99,48.87 49.7,46.59 49.39,46.59 v1(49.1,46.3)
QSFPDD1_TX4_N: length 46.4
  L03_SIG1 w0.079: v4(54.96,49.9) 55.14,49.71 55.6,49.71 55.91,49.4 55.91,46.38 56.83,45.47 58.03,45.47 58.31,45.75 59.3,45.75 61.43,47.88 arc(61.95,48.66) 62.14,49.58 62.14,52.47 arc(62.14,52.55) 62.15,52.63 62.22,52.92 arc(62.25,53) 62.29,53.08 arc(62.87,53.74) 63.62,54.2 arc(63.93,54.36) 64.22,54.56 arc(65.09,55.05) 66.07,55.22 77.15,55.22 arc(77.29,55.25) 77.42,55.33 arc(77.66,55.49) 77.94,55.55 84.83,55.55 arc(85.31,55.64) 85.72,55.92 85.83,56.03 arc(86.49,56.47) 87.26,56.62 87.89,56.62 arc(88.28,56.52) 88.56,56.23 88.57,56.21 arc(88.69,56.1) 88.84,56.06 88.97,56.06 arc(89.11,56.1) 89.22,56.2 89.27,56.29 arc(89.47,56.49) 89.74,56.57 89.85,56.57 arc(89.98,56.55) 90.11,56.51 arc(90.38,56.42) v4(90.67,56.43)
QSFPDD1_TX4_P: length 46.4
  L03_SIG1 w0.079: v4(89.8,55.93) 90.05,56.07 arc(90.09,56.13) 90.08,56.21 90.06,56.25 arc(90.04,56.28) 90.01,56.3 arc(89.93,56.33) 89.85,56.34 89.74,56.34 arc(89.58,56.29) 89.47,56.18 89.42,56.09 arc(89.23,55.9) 88.97,55.83 88.84,55.83 arc(88.57,55.9) 88.38,56.1 88.37,56.12 arc(88.16,56.32) 87.89,56.39 87.26,56.39 arc(86.58,56.26) 85.99,55.87 85.88,55.76 arc(85.4,55.43) 84.83,55.32 77.94,55.32 arc(77.74,55.28) 77.58,55.17 arc(77.38,55.04) 77.15,54.99 66.07,54.99 arc(65.16,54.84) 64.37,54.39 arc(64.05,54.16) 63.7,53.99 arc(63.01,53.57) 62.48,52.96 arc(62.46,52.91) 62.44,52.87 62.38,52.58 arc(62.37,52.52) 62.36,52.47 62.36,49.58 arc(62.16,48.57) 61.59,47.72 59.39,45.52 58.4,45.52 58.12,45.24 56.73,45.24 55.68,46.29 55.68,49.3 55.51,49.48 55.34,49.48 v4(54.96,49.1)
QSFPDD1_TX5_N: length 50.3
  L03_SIG1 w0.079: v4(52.03,49.5) 52.31,49.21 52.66,49.21 53.14,48.73 53.14,45.67 53.65,45.16 55.2,45.16 57.44,42.93 58.07,42.93 63.33,48.19 63.33,51.25 arc(63.46,51.92) 63.84,52.48 64.73,53.37 arc(65.57,53.93) 66.56,54.13 85.26,54.13 arc(85.76,54.23) 86.18,54.51 86.22,54.55 arc(86.41,54.68) 86.64,54.73 88.02,54.73 arc(88.14,54.75) 88.24,54.82 88.3,54.88 arc(88.48,55) 88.69,55.04 88.97,55.04 arc(89.25,54.96) 89.46,54.76 89.48,54.72 arc(89.59,54.61) 89.75,54.57 89.85,54.57 arc(89.98,54.55) 90.11,54.51 arc(90.38,54.42) v4(90.67,54.43)
QSFPDD1_TX5_P: length 50.3
  L03_SIG1 w0.079: v4(89.8,53.93) 90.05,54.07 arc(90.09,54.13) 90.08,54.21 90.06,54.25 arc(90.04,54.28) 90.01,54.3 arc(89.93,54.33) 89.85,54.34 89.75,54.34 arc(89.48,54.41) 89.28,54.61 89.26,54.64 arc(89.14,54.76) 88.97,54.81 88.69,54.81 arc(88.66,54.81) 88.63,54.8 arc(88.54,54.77) 88.46,54.72 88.41,54.66 arc(88.23,54.54) 88.02,54.5 87.41,54.5 87.29,54.37 87.01,54.37 86.88,54.5 86.64,54.5 arc(86.5,54.47) 86.38,54.39 86.34,54.35 arc(85.84,54.02) 85.26,53.9 66.56,53.9 arc(65.66,53.72) 64.89,53.21 64,52.32 arc(63.67,51.83) 63.56,51.25 63.56,48.09 58.17,42.7 57.34,42.7 55.11,44.94 53.56,44.94 52.92,45.58 52.92,48.63 52.57,48.98 52.31,48.98 v4(52.03,48.7)
QSFPDD1_TX6_N: length 54
  L16_SIG6 w0.079: v1(54.96,47.5) 54.67,47.21 54.23,47.21 54,46.98 54,45.9 55.41,44.48 55.41,43.74 56.29,42.86 58.42,42.86 58.59,43.03 59.95,44.39 59.95,46.19 61.45,47.69 61.45,50.72 61.07,51.1 61.07,53.02 61.77,53.72 63.06,53.72 63.29,53.95 64.35,53.95 65.5,55.1 78.13,55.1 78.35,55.32 88.15,55.32 88.63,55.8 89.21,55.8 arc(89.45,55.75) 89.65,55.62 90.68,54.59 arc(90.97,54.39) 91.31,54.33 91.49,54.33 arc(91.76,54.38) 91.99,54.53 92.13,54.67 arc(92.25,54.75) 92.38,54.78 92.41,54.78 arc(92.57,54.8) 92.71,54.85 arc(92.98,54.94) v1(93.26,54.93)
QSFPDD1_TX6_P: length 54
  L16_SIG6 w0.079: v1(92.4,55.43) 92.64,55.29 arc(92.69,55.22) 92.68,55.15 92.65,55.1 arc(92.63,55.07) 92.61,55.05 arc(92.51,55.02) 92.41,55.01 92.38,55.01 arc(92.16,54.96) 91.97,54.83 91.83,54.69 arc(91.67,54.59) 91.49,54.55 91.31,54.55 arc(91.06,54.61) 90.84,54.75 89.81,55.78 arc(89.53,55.96) 89.21,56.03 88.53,56.03 88.05,55.55 87.42,55.55 87.28,55.69 87.03,55.69 86.89,55.55 86.61,55.55 86.47,55.68 86.21,55.68 86.07,55.55 85.79,55.55 85.66,55.68 85.39,55.68 85.26,55.55 78.25,55.55 78.04,55.33 65.4,55.33 64.25,54.18 63.2,54.18 62.97,53.95 61.67,53.95 60.84,53.12 60.84,51.01 61.22,50.62 61.22,47.78 59.72,46.28 59.72,44.49 59.38,44.14 59.2,44.14 59,43.95 59,43.77 58.8,43.57 58.62,43.57 58.43,43.37 58.43,43.19 58.32,43.09 56.38,43.09 56.15,43.32 56.15,43.5 55.95,43.7 55.77,43.7 55.64,43.83 55.64,44.57 55.08,45.14 55.08,45.32 54.88,45.51 54.7,45.51 54.22,45.99 54.22,46.21 54.33,46.32 54.33,46.55 54.22,46.66 54.22,46.88 54.33,46.98 54.67,46.98 v1(54.96,46.7)
QSFPDD1_TX7_N: length 56.4
  L16_SIG6 w0.079: v1(52.03,47.1) 52,47.1 51.73,46.83 51.43,46.83 51.06,46.46 51.06,44.71 51.67,44.1 52.05,44.1 52.15,44 52.15,43.65 53.33,42.47 55.16,42.47 55.84,41.79 58.86,41.79 58.98,41.91 61.02,43.95 61.02,44.96 61.22,45.16 61.22,45.9 62.54,47.22 62.54,50.64 65.81,53.9 84.57,53.9 84.8,54.14 84.89,54.14 85.02,54.01 85.49,54.01 85.62,54.14 85.71,54.14 85.83,54.01 86.3,54.01 86.44,54.15 86.51,54.15 86.75,53.9 87.1,53.9 87.49,54.3 88.06,54.3 88.54,53.82 89.2,53.82 arc(89.43,53.77) 89.62,53.64 90.06,53.2 arc(90.09,53.17) 90.11,53.14 90.14,53.08 arc(90.34,52.89) 90.61,52.81 90.7,52.81 arc(90.72,52.81) 90.75,52.82 arc(90.76,52.82) 90.78,52.82 arc(91.02,52.91) 91.2,53.11 91.23,53.16 arc(91.35,53.27) 91.5,53.31 91.52,53.31 arc(91.68,53.27) 91.8,53.15 91.86,53.06 arc(92.06,52.85) 92.34,52.78 92.5,52.78 arc(92.65,52.81) 92.78,52.89 arc(92.8,52.91) 92.82,52.94 arc(92.83,52.94) 92.83,52.95 92.88,53.03 arc(92.94,53.08) 93.02,53.07 v1(93.26,52.93)
