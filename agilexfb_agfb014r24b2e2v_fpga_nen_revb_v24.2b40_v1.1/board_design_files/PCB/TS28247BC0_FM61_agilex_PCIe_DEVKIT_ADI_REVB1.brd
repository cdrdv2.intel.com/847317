# Allegro board TS28247BC0_FM61_agilex_PCIe_DEVKIT_ADI_REVB1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
QSFPDD0_1V2_INT_L: length 138.2
  L05_SIG2 w0.081: v1(37.47,31.19) 37.47,32.08 37.13,32.42 33.23,32.42 32.33,31.52 32.33,29.12 32.03,28.82 32.03,26.26 31.12,25.36 31.12,24.52 30.43,23.82 30.43,23.38 29.63,22.58 29.63,21.86 29.39,21.62 29.07,21.62 28.84,21.39 28.84,20.03 v1(28.43,19.62)
  L12_SIG4 w0.089: v1(115.78,79.93) 116.16,79.54 116.16,78.72 115.87,78.42 115.74,78.42 115.33,78.01 115.33,77.23 115.04,76.93 114.74,76.93 114.11,76.3 113.71,76.3 113.32,75.91 112.88,75.91 112.52,75.55 111.99,75.55 111.74,75.8 111.18,75.8 110.92,75.55 110.29,75.55 110.04,75.8 109.55,75.8 109.29,75.55 108.46,75.55 108.21,75.8 107.56,75.8 107.31,75.55 106.8,75.55 106.55,75.8 106.09,75.8 105.59,75.3 105.22,75.3 104.72,74.8 104.07,74.8 103.8,74.52 103.38,74.52 103.1,74.8 102.43,74.8 102.18,74.55 101.62,74.55 101.35,74.81 99.17,74.81 98.66,74.3 98.25,74.3 97.75,74.8 97.32,74.8 97.06,74.54 96.54,74.54 96.16,74.92 95.79,74.92 94.85,75.85 93.36,75.85 92.56,75.05 92.22,75.05 91.97,75.3 91.39,75.3 90.88,75.81 90.3,75.81 90.04,75.55 89.4,75.55 88.45,76.51 86.75,76.51 85.82,75.58 79.24,75.58 78.67,76.15 72.98,76.15 69.88,73.05 68.54,73.05 66.81,71.33 65.69,71.33 62.24,67.87 62.24,62.79 57.56,58.12 51.29,58.12 49.37,56.2 49.37,54.86 46.91,52.39 46.91,49.49 46.39,48.97 44.84,48.97 42.98,47.11 42.98,46.48 37.73,41.23 37.73,37.54 39.5,35.77 39.5,33.66 37.47,31.63 v1(37.47,31.19)
QSFPDD0_1V2_LPMODE: length 143
  L05_SIG2 w0.081: v1(30.03,21.22) 30.27,21.22 30.67,21.62 30.99,21.62 31.23,21.86 31.23,22.18 31.47,22.42 31.79,22.42 32.03,22.66 32.03,22.98 32.27,23.22 32.59,23.22 33.63,24.26 33.63,25.38 33.87,25.62 34.19,25.62 34.43,25.86 34.43,28.66 34.63,28.86 34.63,30.48 34.17,30.94 34.17,31.45 34.42,31.7 36.08,31.7 36.33,31.45 v1(36.33,31.19)
  L12_SIG4 w0.089: v1(36.33,31.19) 35.44,32.08 33.66,32.08 32.52,33.23 32.52,34.75 36.96,39.19 36.96,41.02 42.55,46.61 42.55,47.32 44.97,49.74 45.73,49.74 46.67,50.68 46.67,52.49 49.13,54.96 49.13,56.3 51.19,58.36 57.46,58.36 61.98,62.88 61.98,69.83 62.49,70.34 64.35,70.34 65.59,71.58 66.71,71.58 67.67,72.55 67.67,73.36 68.18,73.87 69.5,73.87 72.12,76.48 78.75,76.48 79.21,76.02 84.99,76.02 85.58,76.61 86.44,76.61 86.86,77.03 88.72,77.03 89.45,76.3 90.8,76.3 91.3,75.8 92.84,75.8 93.29,76.26 95.7,76.26 96.49,75.47 97.01,75.47 97.43,75.05 97.8,75.05 98.3,74.55 98.56,74.55 98.56,74.55 98.61,74.55 99.11,75.05 101.32,75.05 101.58,75.32 102.19,75.32 102.46,75.05 103.15,75.05 103.44,75.34 103.92,75.34 104.21,75.05 104.68,75.05 105.18,75.55 105.5,75.55 105.5,75.55 105.54,75.55 106.04,76.05 106.49,76.05 106.74,76.3 107.34,76.3 107.59,76.05 108.31,76.05 108.56,76.3 109.05,76.3 109.3,76.05 109.95,76.05 110.2,76.3 110.83,76.3 111.08,76.05 111.69,76.05 112.06,76.43 112.49,76.43 112.89,76.83 113.41,76.83 114.12,77.54 114.39,77.54 114.83,77.98 114.99,77.98 115.33,78.32 115.33,78.48 v1(115.78,78.93)
  BOTTOM w0.149: v1(115.78,78.93) 115.78,79.21 116.54,79.96 116.84,79.96 117.3,80.43 117.7,80.43 118.2,80.93 118.52,80.93 118.8,81.21 118.8,83.1 R43.2 R42.1
QSFPDD0_1V2_MODPRS_L: length 135.4
  L05_SIG2 w0.081: v1(34.55,31.19) 35.03,30.72 35.03,28.92 35.23,28.72 35.23,25.86 34.99,25.62 34.67,25.62 34.43,25.38 34.43,24.26 34.19,24.02 33.87,24.02 32.83,22.98 32.83,22.66 32.59,22.42 32.27,22.42 32.03,22.18 32.03,20.99 31.86,20.82 29.63,20.82 v1(29.23,20.42)
  L12_SIG4 w0.089: v1(114.91,79.43) 114.4,78.92 114.2,78.92 113.24,77.96 112.92,77.96 112.51,77.55 112.11,77.55 111.61,77.05 111.24,77.05 110.99,77.3 110.29,77.3 110.03,77.05 109.44,77.05 109.19,77.3 108.55,77.3 108.3,77.05 107.77,77.05 107.51,77.3 106.89,77.3 106.63,77.05 106.04,77.05 105.54,76.55 105.18,76.55 104.67,76.05 99.11,76.05 98.61,75.55 98.3,75.55 97.83,76.02 97.48,76.02 97.36,76.13 96.56,76.13 95.88,76.8 92,76.8 91.72,76.53 91.4,76.53 90.9,77.03 90.51,77.03 90.21,77.33 89.47,77.33 88.52,78.28 85.58,78.28 85.33,78.03 85.33,77.57 84.29,76.54 79.45,76.54 78.9,77.09 70.55,77.09 70,76.54 69.48,76.33 69.48,76.02 68.72,75.26 63.18,75.26 62.52,74.6 62.52,72.04 61.48,71 61.48,63.05 57.26,58.84 50.99,58.84 48.65,56.5 48.65,55.16 44.84,51.35 44.84,50.76 41.85,47.77 41.85,47.03 36.2,41.38 36.2,39.45 31.76,35 31.76,32.84 33.41,31.19 v1(34.55,31.19)
QSFPDD0_1V2_MODSEL_L: length 145.7
  L12_SIG4 w0.089: v1(111.45,81.43) 111.32,81.3 110.42,81.3 109.92,80.8 109.39,80.8 109.14,80.55 108.55,80.55 108.23,80.87 107.87,80.87 107.55,80.55 106.74,80.55 106.49,80.8 106.1,80.8 105.6,80.3 105.22,80.3 104.72,79.8 104.07,79.8 103.82,79.55 103.38,79.55 103.13,79.8 102.55,79.8 102.3,79.55 101.72,79.55 101.47,79.8 100.9,79.8 100.4,79.3 99.93,79.3 99.68,79.05 98.96,79.05 98.71,79.3 93.43,79.3 92.68,80.05 92.07,80.05 91.81,80.3 91.13,80.3 90.88,80.05 90.51,80.05 90.01,80.55 89.57,80.55 88.81,81.31 85.04,81.31 83.62,79.89 79.53,79.89 77.81,81.61 68.46,81.61 65.29,78.44 61.48,78.44 56.34,73.31 56.34,70.89 55.38,69.93 55.38,67.9 53.6,66.12 53.6,64.09 52.08,62.56 50.51,62.56 49.5,61.55 49.28,61.55 48.58,60.85 48.58,60.13 42.11,53.65 42.11,52.09 38.74,48.72 34.3,48.72 32.27,46.69 28.96,46.69 27.95,45.67 27.06,45.67 23.5,42.12 23.5,31.96 24.26,31.19 24.26,27.76 23.88,27.38 23.88,23.57 24.4,23.06 24.4,20.29 24.69,20 29.45,20 29.63,19.82 29.63,19.22 v1(30.03,18.82)
  BOTTOM w0.149: v1(111.45,81.43) 111.45,81.81 R40.1
QSFPDD0_1V2_RESET_L: length 146.8
  L05_SIG2 w0.081: v1(29.23,21.22) 29.47,21.22 29.87,21.62 30.19,21.62 30.43,21.86 30.43,22.18 30.67,22.42 30.99,22.42 31.23,22.66 31.23,22.98 31.47,23.22 31.79,23.22 32.03,23.46 32.03,23.78 32.27,24.02 32.59,24.02 32.83,24.26 32.83,25.38 33.63,26.18 33.63,28.75 34.17,29.29 34.17,30.43 33.66,30.94 33.66,31.83 33.92,32.08 36.33,32.08 36.96,31.45 36.96,30.81 36.84,30.69 36.2,30.69 35.69,31.19 v1(35.44,31.19)
  L12_SIG4 w0.089: v1(35.44,31.19) 34.93,31.7 33.54,31.7 32.14,33.1 32.14,34.88 36.58,39.32 36.58,41.18 42.23,46.83 42.23,47.51 45.6,50.88 45.6,51.77 48.89,55.06 48.89,56.4 51.09,58.6 57.36,58.6 61.73,62.97 61.73,70.54 62.75,71.55 63.86,71.55 65.01,72.7 65.67,72.7 67.22,74.25 68.59,74.25 71.08,76.74 78.85,76.74 79.28,76.3 84.52,76.3 85.68,77.46 88.71,77.46 89.62,76.55 91.01,76.55 91.51,76.05 92.7,76.05 93.16,76.51 95.79,76.51 96.5,75.81 97.75,75.81 98.25,75.3 98.66,75.3 99.18,75.82 104.75,75.82 105.23,76.3 105.6,76.3 106.1,76.8 106.11,76.8 106.12,76.8 106.56,76.8 106.81,76.55 107.45,76.55 107.7,76.8 108.37,76.8 108.62,76.55 109.19,76.55 109.44,76.8 109.95,76.8 110.2,76.55 110.89,76.55 111.14,76.8 111.66,76.8 112.16,77.3 112.75,77.3 113,77.05 113.33,77.05 113.63,77.35 113.63,78.04 114.02,78.43 v1(114.91,78.43)
  BOTTOM w0.149: v1(114.91,78.43) 115.9,78.43 116.4,78.93 116.8,78.93 117.3,79.43 117.7,79.43 118.19,79.91 118.49,79.91 119,80.43 119.4,80.43 119.7,80.73 119.7,82.63 120,82.93 120.36,82.93 R38.1
QSFPDD0_3V3_INT_L: length 65
  TOP w0.149: J5.28 v1(58.5,67.49)
  L03_SIG1 w0.081: v1(46.3,62.69) 45.77,62.16 44.99,62.16 44.71,62.44 43.92,62.44 43.31,61.83 v1(43.31,39.19)
  L07_SIG3 w0.089: v1(46.3,62.69) 55.25,62.69 56.27,63.71 56.27,65.77 57.99,67.49 v1(58.5,67.49)
  L12_SIG4 w0.089: v1(43.31,39.19) 42.3,38.18 42.12,38.18 41.03,37.09 41.03,32.61 38.87,30.45 38.87,28.73 38.02,27.88 38.02,26.09 37.57,25.64 35.47,25.64 35.23,25.4 35.23,25.07 34.99,24.82 34.68,24.82 34.43,24.57 34.43,24.27 33.85,23.69 33.57,23.69 33.23,23.35 v1(33.23,22.82)
QSFPDD0_3V3_LPMODE: length 87.7
  TOP w0.149: J5.31 v1(58.55,69.89)
  L05_SIG2 w0.081: v1(45.22,31.32) 44.09,30.2 44.09,24.59 43.73,24.22 42.83,24.22 39.43,20.82 36.83,20.82 v1(36.43,20.42)
  L07_SIG3 w0.089: v1(58.55,69.89) 53.78,69.89 52.25,68.36 48.17,68.36 47.48,67.67 43.54,67.67 42.93,68.28 35.69,68.28 33.7,66.28 33.7,63.92 34.04,63.58 34.6,63.58 35.89,62.29 37.95,62.29 38.02,62.22 38.03,62.22 40.02,60.23 40.02,60.22 40.04,60.2 40.04,55.96 43.97,52.03 43.97,45.43 43.64,45.11 43.64,40.53 44.86,39.31 44.86,36.63 43.13,34.9 43.13,33.41 v1(45.22,31.32)
QSFPDD0_3V3_MODPRS_L: length 67.5
  TOP w0.149: J5.27 v1(58.55,66.69)
  L03_SIG1 w0.081: v1(44.39,62.05) 46.24,60.21 46.24,55.68 44.76,54.21 44.76,39.63 v1(44.33,39.19)
  L07_SIG3 w0.089: v1(44.39,62.05) 55.25,62.05 56.78,63.58 56.78,65.61 57.85,66.69 v1(58.55,66.69)
  L12_SIG4 w0.089: v1(44.33,39.19) 43.82,38.69 43.82,37.92 43.44,37.54 43.44,36.65 43.82,36.27 43.82,35.51 42.93,34.62 42.93,30.56 41.16,28.78 41.16,22.55 39.81,21.21 38.02,21.21 37.61,21.63 37.07,21.63 36.67,21.22 v1(36.43,21.22)
  BOTTOM w0.149: R91.2 v1(44.39,62.05)
QSFPDD0_3V3_MODSEL_L: length 67.9
  TOP w0.149: v1(49.66,69.17) 49.34,69.49 J5.8
  L07_SIG3 w0.089: v1(49.66,69.17) 48.18,69.17 47.67,68.66 35.44,68.66 32.66,65.88 32.66,64.21 33.54,63.32 34.45,63.32 35.8,61.98 37.93,61.98 39.78,60.13 39.78,55.72 43.46,52.03 43.46,45.55 42.3,44.38 v1(42.3,39.19)
  L12_SIG4 w0.089: v1(36.43,26.82) 36.43,27.05 38.01,28.63 38.01,30.08 40.65,32.72 40.65,37.11 41.41,37.87 41.41,38.31 v1(42.3,39.19)
QSFPDD0_3V3_RESET_L: length 78.4
  TOP w0.149: J5.9 47.6,68.69 v1(47.25,69.04)
  L07_SIG3 w0.089: v1(47.25,69.04) 35.44,69.04 32.14,65.74 32.14,64.13 33.32,62.94 34.47,62.94 35.72,61.69 37.81,61.69 39.49,60.02 39.49,55.6 43.18,51.91 43.18,45.96 41.66,44.44 41.66,39.31 42.33,38.63 43.88,38.63 v1(44.33,38.18)
  L12_SIG4 w0.089: v1(35.63,21.22) 35.88,21.22 36.28,20.82 40.02,20.82 41.54,22.34 41.54,28.78 43.31,30.56 43.31,34.37 44.46,35.51 44.46,38.05 v1(44.33,38.18)
QSFPDD0_FPGA_LED0: length 41
  L14_SIG5 w0.081: v1(105.39,78.93) 104.4,78.93 103.86,79.47 103.52,79.47 102.96,80.03 102.54,80.03 102.04,80.52 102.04,81.28 100.13,83.18 100.13,84.6 98.6,86.13 98.6,87.74 96.5,89.84 85.13,89.84 84.46,90.5 82.98,90.5 80.44,93.04 79.94,93.04 78.69,94.29 75.49,94.29 v1(74.94,93.74)
  BOTTOM w0.149: U67.2 74.97,93.77 v1(74.94,93.74)
QSFPDD0_FPGA_LED1: length 42.4
  L14_SIG5 w0.081: v1(105.39,79.93) 105.1,80.22 105.1,80.38 104.68,80.8 104.01,80.8 101.71,83.1 101.71,84.71 99.99,86.43 99.99,87.83 96.92,90.9 87.8,90.9 86.81,91.89 85.93,91.89 84.57,93.25 82.49,93.25 82.1,93.64 82.1,94.01 81.25,94.86 74.78,94.86 v1(73.67,93.74)
  BOTTOM w0.149: v1(73.67,93.74) 74.32,94.39 U67.3
QSFPDD0_FPGA_LED2: length 46
  L14_SIG5 w0.081: v1(72.4,93.74) 72.97,93.74 73.94,92.77 74.94,92.77 75.33,92.38 75.79,92.38 76.05,92.64 78.5,92.64 81.02,90.12 84.33,90.12 85.6,88.85 96.24,88.85 97.07,88.02 97.91,88.02 98.32,87.61 98.32,86.05 99.72,84.65 99.72,82.99 101.48,81.23 101.48,79.79 101.87,79.4 102.15,79.4 102.58,78.97 102.99,78.97 103.55,78.41 103.82,78.41 104.25,77.99 104.83,77.99 105.15,78.31 106.14,78.31 v1(106.25,78.43)
  BOTTOM w0.149: v1(72.4,93.74) 72.84,94.19 73.29,94.19 73.67,94.57 U67.4
QSFPDD0_LED0: length 90.3
  L12_SIG4 w0.089: v1(74.56,103.08) 74.56,102.95 72.27,100.66 67.7,100.66 67.15,100.12 67.15,99.67 66.38,98.91 65.71,98.91 63.76,96.96 63.76,93.58 60.81,90.63 59.44,90.63 54.87,86.06 52.71,86.06 51.82,85.17 51.82,84.03 50.68,82.88 42.43,82.88 41.54,81.99 41.54,75.52 40.01,73.99 40.01,68.28 39.28,67.54 39.28,63.83 38.77,63.32 27.44,63.32 25.66,65.1 21.6,65.1 20.33,63.83 17.05,63.83 v1(16.46,64.42)
  BOTTOM w0.149: v1(74.56,103.08) 74.97,102.66 U67.13
QSFPDD0_LED1: length 82.1
  L12_SIG4 w0.089: v1(74.32,101.33) 73.27,100.28 68.08,100.28 67.47,99.67 67.47,98.78 67.14,98.45 64.27,95.58 64.27,93.55 60.97,90.25 59.7,90.25 55.51,86.06 55.51,85.04 53.73,83.26 51.95,83.26 51.19,82.5 42.55,82.5 41.92,81.87 41.92,74.91 41,73.99 41,66.04 40.27,65.31 40.27,64.29 38.97,62.99 26.5,62.99 25.07,64.42 v1(23.82,64.42)
  BOTTOM w0.149: R716.2 73.67,103.39 73.67,102.95 74.32,102.3 v1(74.32,101.33)
QSFPDD0_LED2: length 89.3
  L12_SIG4 w0.089: v1(73.03,103.08) 73.03,102.69 72.14,101.81 68.21,101.81 66.43,100.03 65.97,100.03 63.25,97.31 63.25,93.61 60.65,91.01 58.94,91.01 54.49,86.57 50.55,86.57 49.28,85.3 49.28,84.03 48.65,83.39 42.43,83.39 38.22,79.18 36.25,79.18 34.42,77.36 34.42,72.85 35.92,71.36 35.92,70.28 38.89,67.3 38.89,64.87 38.23,64.21 35.59,64.21 34.96,63.58 27.69,63.58 25.79,65.48 21.2,65.48 v1(20.14,64.42)
  BOTTOM w0.149: U67.11 73.67,102.44 v1(73.03,103.08)
QSFPDD0_RX0_N: length 78.6
  L03_SIG1 w0.079: v4(95.86,68.43) 95.61,68.29 arc(95.57,68.23) 95.57,68.17 arc(95.58,68.15) 95.59,68.14 arc(95.65,68.08) 95.71,68.04 arc(95.75,68.03) 95.79,68.02 arc(95.88,68.02) 95.97,68.02 arc(96.05,68.04) 96.13,68.09 arc(96.16,68.12) 96.18,68.16 96.23,68.25 arc(96.27,68.32) 96.28,68.4 96.28,68.41 arc(96.27,68.5) 96.24,68.59 96.16,68.78 arc(96.13,68.88) 96.12,68.99 96.12,69.03 arc(96.13,69.12) 96.17,69.21 arc(96.17,69.21) 96.18,69.22 96.2,69.25 arc(96.23,69.33) 96.24,69.42 96.24,69.45 arc(96.24,69.45) 96.24,69.46 arc(96.24,69.51) 96.22,69.56 arc(96.2,69.6) 96.18,69.64 96.14,69.69 arc(96.04,69.78) 95.9,69.81 95.82,69.81 arc(95.56,69.88) 95.37,70.07 95.32,70.15 arc(95.2,70.27) 95.04,70.31 94.96,70.31 arc(94.67,70.39) 94.46,70.6 94.43,70.65 arc(94.32,70.77) 94.16,70.81 94.12,70.81 arc(93.83,70.89) 93.61,71.1 93.58,71.15 arc(93.46,71.27) 93.29,71.32 93.24,71.32 arc(92.95,71.39) 92.75,71.6 92.72,71.65 arc(92.6,71.77) 92.44,71.81 92.37,71.81 arc(92.09,71.89) 91.88,72.1 91.85,72.15 arc(91.72,72.28) 91.54,72.33 91.48,72.33 arc(91.21,72.4) 91.01,72.6 90.98,72.65 arc(90.86,72.77) 90.7,72.81 90.64,72.81 arc(90.35,72.89) 90.14,73.1 90.11,73.15 arc(90.01,73.26) 89.86,73.3 89.44,73.3 arc(89.17,73.35) 88.95,73.5 88.29,74.16 arc(88.1,74.29) 87.88,74.33 84.71,74.33 arc(84.36,74.47) 84.21,74.81 arc(84.21,74.82) 84.21,74.83 84.21,74.84 arc(84.21,74.85) 84.21,74.86 arc(84.22,74.94) 84.21,75.02 arc(84.21,75.03) 84.21,75.04 arc(84.17,75.16) 84.1,75.25 arc(83.87,75.41) 83.59,75.46 79.46,75.46 arc(79.36,75.47) 79.26,75.49 arc(78.94,75.63) 78.63,75.8 76.48,77.24 74.84,77.84 73.76,77.84 73.55,78.05 69.2,78.05 68.79,78.05 arc(68.58,78.07) 68.36,78.11 67.87,78.25 arc(67.85,78.26) 67.82,78.26 67.53,78.39 67.22,78.39 66.73,78.88 66.22,79.25 arc(65.89,79.41) 65.51,79.47 59.89,79.47 arc(59.8,79.46) 59.71,79.41 arc(59.63,79.36) 59.54,79.34 59.37,79.34 59.24,79.47 48.02,79.47 47.57,79.02 47.57,78.84 47.37,78.64 47.19,78.64 44.59,76.05 44.59,75.69 44.72,75.56 44.72,75.29 44.59,75.16 44.59,68.79 44.81,68.57 44.99,68.57 45.19,68.37 45.19,68.19 45.94,67.44 48.35,67.44 50.07,65.71 50.07,62.05 49.79,61.77 49.38,61.77 v4(49.1,61.49)
QSFPDD0_RX0_P: length 79
  L03_SIG1 w0.079: v4(49.1,62.29) 49.38,62 49.69,62 49.84,62.15 49.84,65.62 48.25,67.21 45.85,67.21 44.37,68.69 44.37,76.14 47.92,79.7 65.51,79.7 arc(65.96,79.63) 66.35,79.43 66.87,79.06 67.32,78.62 67.57,78.62 67.91,78.47 arc(67.92,78.47) 67.93,78.47 68.42,78.33 arc(68.61,78.29) 68.79,78.28 69.2,78.28 73.64,78.28 73.86,78.06 74.88,78.06 76.59,77.44 78.76,75.99 arc(79.04,75.83) 79.33,75.71 arc(79.4,75.7) 79.46,75.69 83.59,75.69 arc(83.95,75.62) 84.26,75.42 arc(84.37,75.26) 84.43,75.07 arc(84.43,75.07) 84.43,75.07 84.43,75.06 arc(84.45,74.94) 84.44,74.82 arc(84.52,74.64) 84.71,74.56 87.88,74.56 arc(88.19,74.5) 88.45,74.32 89.11,73.66 arc(89.26,73.56) 89.44,73.53 89.86,73.53 arc(90.12,73.46) 90.31,73.26 90.34,73.21 arc(90.47,73.09) 90.64,73.04 90.7,73.04 arc(90.98,72.97) 91.18,72.77 91.21,72.71 arc(91.33,72.6) 91.48,72.56 91.54,72.56 arc(91.83,72.48) 92.05,72.26 92.08,72.21 arc(92.2,72.09) 92.37,72.04 92.44,72.04 arc(92.71,71.97) 92.91,71.77 92.94,71.72 arc(93.07,71.59) 93.24,71.55 93.29,71.55 arc(93.58,71.47) 93.78,71.26 93.81,71.21 arc(93.94,71.08) 94.12,71.04 94.16,71.04 arc(94.43,70.96) 94.63,70.76 94.66,70.71 arc(94.79,70.59) 94.96,70.54 95.04,70.54 arc(95.32,70.47) 95.52,70.26 95.56,70.18 arc(95.67,70.08) 95.82,70.04 95.9,70.04 arc(96.14,69.98) 96.32,69.83 96.36,69.77 arc(96.44,69.63) 96.47,69.47 arc(96.47,69.46) 96.47,69.45 96.47,69.42 arc(96.45,69.27) 96.39,69.13 96.37,69.1 96.37,69.09 arc(96.36,69.09) 96.36,69.09 arc(96.35,69.06) 96.35,69.03 96.35,68.99 arc(96.35,68.93) 96.37,68.87 96.45,68.68 arc(96.49,68.55) 96.5,68.41 96.5,68.4 arc(96.49,68.26) 96.43,68.13 96.38,68.04 arc(96.34,67.98) 96.28,67.92 arc(96.14,67.83) 95.99,67.79 arc(95.87,67.79) 95.76,67.8 arc(95.64,67.82) 95.52,67.84 95.43,67.87 arc(95.22,67.91) v4(95,67.93)
QSFPDD0_RX1_N: length 78.6
  L03_SIG1 w0.079: v4(57.89,61.89) 58.17,62.17 58.46,62.17 58.81,62.52 58.81,65.81 58.05,66.58 54.01,66.58 arc(53.96,66.59) 53.92,66.61 50.74,69.79 arc(50.63,69.87) 50.49,69.9 48.07,69.9 arc(47.83,69.95) 47.64,70.09 arc(47.5,70.29) 47.45,70.52 47.45,74.87 arc(47.46,74.92) 47.48,74.96 arc(47.51,75.02) 47.56,75.07 48.45,75.96 arc(49.54,76.68) 50.82,76.94 59.03,76.94 arc(59.1,76.93) 59.15,76.91 63.54,74.28 arc(63.6,74.24) 63.65,74.2 arc(63.92,74.05) 64.23,73.99 76.04,73.99 arc(76.08,73.99) 76.12,73.96 79.19,70.89 arc(79.24,70.85) 79.29,70.82 arc(79.32,70.8) 79.35,70.79 arc(79.44,70.74) 79.53,70.71 arc(79.56,70.71) 79.6,70.69 arc(80.04,70.58) 80.49,70.54 89.18,70.54 arc(89.25,70.52) 89.31,70.48 89.32,70.47 arc(89.5,70.35) 89.7,70.31 89.82,70.31 arc(90.11,70.39) 90.32,70.61 90.35,70.66 arc(90.47,70.77) 90.62,70.81 90.68,70.81 arc(90.86,70.77) 90.99,70.64 91.02,70.58 arc(91.22,70.39) 91.49,70.31 91.55,70.31 arc(91.73,70.27) 91.86,70.14 91.89,70.08 arc(92.08,69.89) 92.36,69.81 92.42,69.81 arc(92.59,69.77) 92.72,69.64 92.75,69.58 arc(92.95,69.39) 93.22,69.31 93.26,69.31 arc(93.54,69.2) 93.65,68.92 93.65,68.84 arc(93.64,68.81) 93.63,68.79 93.61,68.76 arc(93.55,68.63) 93.52,68.48 93.52,68.39 arc(93.53,68.3) 93.56,68.22 93.62,68.08 arc(93.63,68.05) 93.63,68.01 93.63,67.96 arc(93.62,67.87) 93.6,67.78 93.55,67.63 arc(93.53,67.5) 93.54,67.38 arc(93.54,67.36) 93.55,67.34 arc(93.59,67.19) 93.66,67.06 arc(93.68,67.03) 93.7,66.99 arc(93.7,66.96) 93.7,66.93 arc(93.69,66.84) 93.66,66.76 93.62,66.7 arc(93.57,66.58) 93.55,66.44 93.55,66.35 arc(93.56,66.24) 93.59,66.14 arc(93.6,66.11) 93.62,66.08 arc(93.82,65.89) 94.09,65.81 94.15,65.81 arc(94.3,65.77) 94.41,65.66 94.46,65.57 arc(94.69,65.35) 95,65.28 arc(95.22,65.31) 95.4,65.43 95.44,65.47 arc(95.51,65.54) 95.56,65.63 95.58,65.67 arc(95.61,65.72) 95.63,65.78 95.69,66.02 arc(95.76,66.23) v4(95.86,66.43)
QSFPDD0_RX1_P: length 78.2
  L03_SIG1 w0.079: v4(94.99,65.93) 95.24,66.07 arc(95.32,66.08) 95.38,66.03 95.38,66.03 arc(95.42,65.9) 95.39,65.78 95.37,65.74 arc(95.33,65.68) 95.28,65.63 95.24,65.59 arc(95.13,65.53) 95.01,65.51 arc(94.81,65.55) 94.66,65.69 94.61,65.78 arc(94.41,65.97) 94.15,66.04 94.09,66.04 arc(93.93,66.08) 93.82,66.2 93.82,66.2 arc(93.81,66.21) 93.8,66.23 arc(93.78,66.29) 93.78,66.35 93.78,66.44 arc(93.79,66.51) 93.82,66.58 93.85,66.64 arc(93.91,66.78) 93.93,66.93 arc(93.93,66.98) 93.92,67.04 arc(93.89,67.12) 93.84,67.2 arc(93.8,67.28) 93.77,67.37 arc(93.77,67.4) 93.76,67.42 arc(93.76,67.49) 93.77,67.56 93.82,67.71 arc(93.85,67.83) 93.86,67.96 93.86,68.01 arc(93.85,68.09) 93.83,68.17 93.77,68.31 arc(93.76,68.35) 93.75,68.39 93.75,68.48 arc(93.75,68.49) 93.75,68.5 arc(93.77,68.57) 93.8,68.63 93.81,68.65 arc(93.86,68.74) 93.88,68.83 93.88,68.92 arc(93.7,69.36) 93.26,69.54 93.22,69.54 arc(93.07,69.58) 92.95,69.7 92.92,69.75 arc(92.71,69.96) 92.42,70.04 92.36,70.04 arc(92.2,70.08) 92.08,70.2 92.05,70.25 arc(91.84,70.46) 91.55,70.54 91.49,70.54 arc(91.33,70.58) 91.22,70.7 91.19,70.75 arc(90.98,70.96) 90.68,71.04 90.62,71.04 arc(90.35,70.97) 90.15,70.77 90.12,70.72 arc(89.99,70.59) 89.82,70.54 89.7,70.54 arc(89.58,70.57) 89.49,70.63 89.47,70.65 arc(89.34,70.74) 89.18,70.77 80.49,70.77 arc(80.07,70.8) 79.68,70.91 arc(79.63,70.92) 79.58,70.94 arc(79.52,70.96) 79.47,70.98 arc(79.43,71.01) 79.38,71.03 arc(79.37,71.04) 79.35,71.05 76.28,74.12 arc(76.17,74.2) 76.04,74.22 64.23,74.22 arc(64,74.26) 63.79,74.38 arc(63.73,74.43) 63.66,74.47 59.27,77.1 arc(59.16,77.15) 59.03,77.17 50.82,77.17 arc(49.45,76.89) 48.28,76.12 47.4,75.23 arc(47.34,75.16) 47.28,75.08 arc(47.24,74.98) 47.22,74.87 47.22,70.52 arc(47.29,70.2) 47.48,69.93 arc(47.75,69.74) 48.07,69.67 50.49,69.67 arc(50.54,69.66) 50.58,69.63 53.87,66.35 57.95,66.35 58.58,65.72 58.58,62.61 58.37,62.4 58.17,62.4 v4(57.89,62.69)
QSFPDD0_RX2_N: length 75
  L16_SIG6 w0.079: v1(49.1,63.89) 49.38,64.17 49.77,64.17 50.12,64.53 50.12,65.93 49.14,66.91 48.35,66.91 45.68,69.58 45.68,74.46 47.86,76.63 52.43,76.63 54.08,78.29 64.15,78.29 65.8,76.63 66.43,76.63 67.05,76.01 67.06,76.01 67.52,75.55 67.52,75.01 68.67,73.86 69.61,73.86 70.75,72.72 76.21,72.72 76.82,72.11 77.29,72.11 77.42,71.99 88.85,71.99 89.36,71.47 arc(89.54,71.36) 89.75,71.31 89.9,71.31 arc(90,71.29) 90.08,71.21 90.17,71.05 arc(90.35,70.88) 90.58,70.81 90.7,70.81 arc(90.98,70.89) 91.18,71.09 91.21,71.14 arc(91.34,71.27) 91.51,71.31 91.57,71.31 arc(91.73,71.27) 91.84,71.16 91.87,71.11 arc(92.09,70.89) 92.38,70.81 92.44,70.81 arc(92.71,70.89) 92.91,71.08 92.94,71.14 arc(93.07,71.27) 93.25,71.31 93.28,71.31 arc(93.46,71.26) 93.59,71.13 93.62,71.08 arc(93.82,70.88) 94.08,70.81 94.17,70.81 arc(94.33,70.77) 94.45,70.65 94.47,70.61 arc(94.69,70.39) 94.98,70.31 94.99,70.31 arc(95.19,70.26) 95.33,70.12 95.37,70.05 arc(95.54,69.88) 95.78,69.81 95.87,69.81 arc(96.06,69.76) 96.19,69.63 96.21,69.61 arc(96.42,69.39) 96.71,69.31 96.76,69.31 arc(96.88,69.29) 96.99,69.22 97.02,69.18 arc(97.08,69.1) 97.1,69.01 97.1,68.91 arc(97.09,68.82) 97.06,68.74 97.04,68.67 arc(97,68.55) 96.99,68.42 arc(97,68.31) 97.03,68.21 97.07,68.11 arc(97.09,67.97) 97.06,67.84 96.99,67.66 arc(96.95,67.56) 96.94,67.46 96.94,67.4 arc(96.99,67.18) 97.12,66.98 97.17,66.93 arc(97.34,66.82) 97.55,66.78 97.6,66.78 arc(97.76,66.8) 97.91,66.85 arc(98.18,66.94) v1(98.46,66.93)
QSFPDD0_RX2_P: length 74.9
  L16_SIG6 w0.079: v1(97.59,67.43) 97.84,67.29 arc(97.89,67.22) 97.88,67.15 97.85,67.1 arc(97.83,67.07) 97.8,67.05 arc(97.71,67.02) 97.6,67.01 97.55,67.01 arc(97.43,67.03) 97.33,67.1 97.28,67.15 arc(97.2,67.26) 97.17,67.4 97.17,67.46 arc(97.18,67.51) 97.2,67.57 97.27,67.74 arc(97.32,67.94) 97.3,68.15 arc(97.29,68.17) 97.28,68.2 97.24,68.3 arc(97.22,68.36) 97.21,68.42 arc(97.22,68.5) 97.25,68.58 97.28,68.65 arc(97.31,68.78) 97.33,68.91 97.33,69.01 arc(97.29,69.19) 97.19,69.35 97.15,69.38 arc(96.97,69.5) 96.76,69.54 96.71,69.54 arc(96.53,69.59) 96.4,69.72 96.39,69.74 arc(96.17,69.96) 95.87,70.04 95.78,70.04 arc(95.66,70.07) 95.57,70.16 95.53,70.23 arc(95.3,70.46) 94.99,70.54 94.98,70.54 arc(94.8,70.59) 94.67,70.72 94.65,70.77 arc(94.44,70.97) 94.17,71.04 94.08,71.04 arc(93.93,71.08) 93.82,71.19 93.79,71.25 arc(93.57,71.46) 93.28,71.54 93.25,71.54 arc(92.96,71.46) 92.74,71.25 92.71,71.2 arc(92.6,71.08) 92.44,71.04 92.38,71.04 arc(92.2,71.09) 92.07,71.22 92.04,71.27 arc(91.84,71.47) 91.57,71.54 91.51,71.54 arc(91.22,71.47) 91.01,71.26 90.98,71.21 arc(90.86,71.09) 90.7,71.04 90.58,71.04 arc(90.46,71.08) 90.37,71.16 90.28,71.32 arc(90.12,71.48) 89.9,71.54 89.75,71.54 arc(89.63,71.57) 89.52,71.64 88.94,72.21 77.51,72.21 77.39,72.34 76.91,72.34 76.3,72.95 70.84,72.95 69.7,74.09 68.76,74.09 67.75,75.1 67.75,75.65 67.16,76.24 67.15,76.24 66.52,76.86 65.89,76.86 64.24,78.51 53.99,78.51 52.34,76.86 47.77,76.86 45.46,74.55 45.46,69.48 48.25,66.68 49.05,66.68 49.89,65.84 49.89,64.62 49.68,64.4 49.38,64.4 v1(49.1,64.69)
QSFPDD0_RX3_N: length 75.3
  L16_SIG6 w0.079: v1(57.89,64.29) 58.17,64.57 58.45,64.57 58.78,64.91 58.78,65.86 57.88,66.76 54.16,66.76 51.08,69.84 49,69.84 48.44,70.39 48.44,72.56 50.1,74.21 53.09,74.21 54.8,75.92 61.75,75.92 62.69,74.98 62.69,74.48 63.06,74.12 63.55,74.12 63.91,73.76 63.91,73 64.29,72.62 66.02,72.62 67.72,70.92 67.72,70.59 68.23,70.08 68.56,70.08 68.82,69.83 68.82,69.5 69.4,68.91 89.06,68.91 89.15,69.01 arc(89.29,69.03) 89.41,69.12 89.5,69.2 arc(89.62,69.29) 89.77,69.31 89.85,69.31 arc(90.01,69.27) 90.12,69.16 90.15,69.11 arc(90.37,68.89) 90.66,68.81 90.7,68.81 arc(90.97,68.89) 91.17,69.08 91.2,69.14 arc(91.33,69.27) 91.51,69.31 91.57,69.31 arc(91.72,69.27) 91.84,69.16 91.87,69.11 arc(92.08,68.89) 92.37,68.81 92.43,68.81 arc(92.71,68.89) 92.91,69.09 92.94,69.14 arc(93.07,69.27) 93.24,69.31 93.31,69.31 arc(93.47,69.27) 93.58,69.16 93.61,69.11 arc(93.82,68.89) 94.11,68.81 94.17,68.81 arc(94.32,68.77) 94.44,68.66 94.51,68.54 arc(94.56,68.45) 94.63,68.38 95.12,67.89 arc(95.2,67.77) 95.23,67.63 95.23,67.54 arc(95.25,67.37) 95.3,67.2 95.34,67.1 arc(95.36,67.02) 95.37,66.94 95.37,66.82 arc(95.43,66.55) 95.58,66.32 96.04,65.86 arc(96.06,65.84) 96.08,65.81 arc(96.09,65.8) 96.1,65.78 96.21,65.58 arc(96.41,65.39) 96.68,65.31 96.79,65.31 arc(96.91,65.28) 96.99,65.18 97.01,65.13 arc(97.09,65.01) 97.19,64.91 97.25,64.87 arc(97.33,64.83) 97.42,64.8 arc(97.51,64.78) 97.61,64.78 arc(97.72,64.8) 97.82,64.82 arc(97.87,64.84) 97.92,64.85 arc(98.18,64.92) v1(98.46,64.93)
QSFPDD0_RX3_P: length 75.2
  L16_SIG6 w0.079: v1(57.89,65.09) 58.17,64.8 58.36,64.8 58.55,65 58.55,65.76 57.79,66.53 54.06,66.53 50.98,69.61 48.9,69.61 48.22,70.29 48.22,72.65 50,74.44 53,74.44 54.71,76.15 61.84,76.15 62.92,75.07 62.92,74.58 63.15,74.35 63.65,74.35 64.14,73.85 64.14,73.1 64.39,72.85 66.12,72.85 67.95,71.01 67.95,70.68 68.33,70.31 68.66,70.31 69.04,69.92 69.04,69.59 69.49,69.14 88.96,69.14 89.06,69.24 89.15,69.24 arc(89.2,69.25) 89.25,69.28 89.34,69.36 arc(89.54,69.5) 89.77,69.54 89.85,69.54 arc(90.12,69.47) 90.32,69.27 90.35,69.22 arc(90.48,69.09) 90.66,69.04 90.7,69.04 arc(90.86,69.08) 90.97,69.2 91,69.25 arc(91.22,69.46) 91.51,69.54 91.57,69.54 arc(91.84,69.47) 92.04,69.27 92.07,69.22 arc(92.2,69.09) 92.37,69.04 92.43,69.04 arc(92.59,69.09) 92.71,69.21 92.74,69.26 arc(92.95,69.47) 93.24,69.54 93.31,69.54 arc(93.58,69.47) 93.78,69.27 93.81,69.22 arc(93.94,69.09) 94.11,69.04 94.17,69.04 arc(94.44,68.97) 94.64,68.77 94.71,68.65 arc(94.75,68.59) 94.79,68.54 95.28,68.05 arc(95.41,67.86) 95.46,67.63 95.46,67.54 arc(95.47,67.41) 95.51,67.29 95.55,67.19 arc(95.59,67.07) 95.6,66.94 95.6,66.82 arc(95.64,66.64) 95.74,66.48 96.2,66.02 arc(96.25,65.96) 96.3,65.9 96.41,65.7 arc(96.52,65.58) 96.68,65.54 96.79,65.54 arc(97.04,65.47) 97.2,65.27 97.22,65.22 arc(97.26,65.16) 97.32,65.1 97.38,65.06 arc(97.43,65.03) 97.48,65.02 arc(97.53,65.01) 97.58,65.01 arc(97.67,65.03) 97.77,65.05 arc(97.82,65.07) 97.86,65.12 97.88,65.15 arc(97.89,65.22) 97.84,65.29 v1(97.59,65.43)
QSFPDD0_RX4_N: length 81.4
  L03_SIG1 w0.079: v4(52.03,61.49) 52.31,61.77 52.68,61.77 53.02,62.11 53.02,65.48 51.75,66.75 51.32,66.75 49.52,68.55 46.68,68.55 46.46,68.76 46.46,68.94 46.26,69.14 46.08,69.14 45.67,69.55 45.67,73.28 45.8,73.4 45.8,73.68 45.67,73.81 45.67,74.71 49.08,78.11 arc(49.13,78.15) 49.19,78.16 49.4,78.16 49.53,78.03 49.81,78.03 49.94,78.16 63.39,78.16 arc(63.46,78.17) 63.53,78.19 arc(63.6,78.22) 63.67,78.22 63.84,78.22 arc(63.92,78.21) 63.99,78.16 arc(64.07,78.11) 64.15,78.07 66.21,77.38 arc(66.25,77.36) 66.3,77.33 arc(66.36,77.29) 66.43,77.25 arc(66.84,77.01) 67.27,76.8 arc(67.37,76.77) 67.48,76.76 74.13,76.76 74.86,76.69 75.94,76.29 76.2,76.14 76.28,76.09 76.39,76 76.72,75.67 arc(78.49,74.48) 80.58,74.07 82.24,74.07 arc(82.65,73.99) 83,73.75 83.06,73.7 arc(83.27,73.38) 83.34,73 83.34,72.65 arc(83.52,72.24) 83.93,72.07 84.17,72.07 84.27,71.98 84.62,71.98 84.71,72.07 84.99,72.07 85.11,71.94 85.39,71.94 85.52,72.07 85.8,72.07 85.93,71.94 86.21,71.94 86.33,72.07 86.61,72.07 86.74,71.94 87.02,71.94 87.15,72.07 87.43,72.07 87.55,71.94 87.83,71.94 87.96,72.07 88.24,72.07 arc(88.75,71.97) 89.18,71.68 89.39,71.48 arc(89.57,71.36) 89.78,71.31 89.84,71.31 arc(90.11,71.39) 90.31,71.58 90.34,71.64 arc(90.47,71.77) 90.65,71.81 90.71,71.81 arc(90.86,71.77) 90.97,71.66 91,71.61 arc(91.22,71.39) 91.52,71.31 91.57,71.31 arc(91.73,71.27) 91.84,71.16 91.87,71.11 arc(92.09,70.89) 92.38,70.81 92.45,70.81 arc(92.59,70.78) 92.7,70.67 92.73,70.62 arc(92.95,70.4) 93.26,70.31 93.3,70.31 arc(93.47,70.27) 93.59,70.15 93.62,70.09 arc(93.83,69.89) 94.11,69.81 94.18,69.81 arc(94.29,69.79) 94.38,69.73 94.4,69.71 arc(94.49,69.58) 94.52,69.42 arc(94.51,69.37) 94.5,69.32 94.44,69.19 arc(94.41,69.06) 94.39,68.93 94.39,68.91 arc(94.4,68.8) 94.44,68.68 94.48,68.59 arc(94.5,68.51) 94.51,68.44 arc(94.51,68.42) 94.5,68.4 94.4,68.15 arc(94.36,68.03) 94.35,67.9 arc(94.39,67.69) 94.51,67.51 94.59,67.43 arc(94.75,67.33) 94.94,67.29 95.09,67.29 arc(95.22,67.25) 95.31,67.16 95.34,67.11 arc(95.53,66.92) 95.79,66.85 95.86,66.85 arc(96.01,66.82) 96.13,66.73 96.16,66.71 arc(96.2,66.65) 96.24,66.59 96.25,66.55 arc(96.27,66.51) 96.27,66.47 96.27,66.44 arc(96.26,66.34) 96.23,66.25 96.16,66.07 arc(96.13,65.99) 96.13,65.91 arc(96.14,65.8) 96.17,65.7 96.21,65.59 arc(96.23,65.52) 96.24,65.44 96.24,65.41 arc(96.24,65.35) 96.22,65.29 96.19,65.23 arc(96.16,65.11) 96.14,64.99 96.14,64.96 arc(96.16,64.83) 96.19,64.71 96.23,64.64 arc(96.26,64.52) 96.27,64.41 96.27,64.34 arc(96.26,64.26) 96.21,64.2 96.13,64.12 arc(96.02,64.04) 95.89,64.02 95.81,64.02 arc(95.73,64.03) 95.65,64.06 arc(95.62,64.07) 95.6,64.1 95.58,64.15 arc(95.57,64.22) 95.61,64.29 v4(95.86,64.43)
QSFPDD0_RX4_P: length 81.4
  L03_SIG1 w0.079: v4(52.03,62.29) 52.31,62 52.58,62 52.79,62.21 52.79,65.39 51.65,66.53 51.22,66.53 49.43,68.32 46.58,68.32 45.44,69.46 45.44,74.8 48.98,78.34 arc(49.03,78.37) 49.09,78.39 63.39,78.39 arc(63.42,78.39) 63.46,78.42 arc(63.5,78.44) 63.54,78.45 63.98,78.45 arc(64.03,78.44) 64.07,78.41 64.14,78.34 arc(64.14,78.34) 64.15,78.33 arc(64.18,78.31) 64.23,78.29 66.3,77.59 arc(66.34,77.57) 66.39,77.55 arc(66.47,77.5) 66.56,77.44 arc(66.95,77.21) 67.36,77.01 arc(67.42,77) 67.48,76.99 74.14,76.99 74.91,76.91 76.04,76.5 76.33,76.33 76.42,76.27 76.54,76.17 76.88,75.83 arc(78.57,74.7) 80.58,74.3 82.24,74.3 arc(82.74,74.2) 83.16,73.91 83.22,73.86 arc(83.48,73.47) 83.57,73 83.57,72.65 arc(83.68,72.4) 83.93,72.3 88.24,72.3 arc(88.84,72.18) 89.35,71.84 89.55,71.64 arc(89.65,71.57) 89.78,71.54 89.84,71.54 arc(90,71.58) 90.11,71.7 90.14,71.75 arc(90.36,71.96) 90.65,72.04 90.71,72.04 arc(90.98,71.97) 91.17,71.78 91.2,71.72 arc(91.33,71.59) 91.52,71.54 91.57,71.54 arc(91.84,71.47) 92.04,71.27 92.07,71.22 arc(92.2,71.09) 92.38,71.04 92.45,71.04 arc(92.71,70.97) 92.89,70.79 92.92,70.74 arc(93.07,70.59) 93.26,70.54 93.3,70.54 arc(93.58,70.47) 93.79,70.26 93.82,70.21 arc(93.94,70.09) 94.11,70.04 94.18,70.04 arc(94.37,70) 94.54,69.89 94.56,69.88 arc(94.7,69.67) 94.75,69.42 arc(94.74,69.32) 94.71,69.23 94.65,69.1 arc(94.63,69.02) 94.62,68.93 94.62,68.91 arc(94.63,68.84) 94.65,68.77 94.69,68.68 arc(94.72,68.56) 94.74,68.44 arc(94.73,68.37) 94.71,68.31 94.61,68.07 arc(94.58,67.98) 94.58,67.9 arc(94.6,67.78) 94.67,67.68 94.75,67.6 arc(94.83,67.54) 94.94,67.52 95.09,67.52 arc(95.33,67.45) 95.51,67.27 95.54,67.22 arc(95.65,67.11) 95.79,67.08 95.86,67.08 arc(96.1,67.03) 96.29,66.9 96.32,66.87 arc(96.39,66.78) 96.45,66.68 96.46,66.64 arc(96.49,66.55) 96.5,66.47 96.5,66.44 arc(96.48,66.3) 96.44,66.16 96.37,65.99 arc(96.36,65.95) 96.36,65.91 arc(96.36,65.85) 96.38,65.79 96.42,65.68 arc(96.46,65.56) 96.47,65.44 96.47,65.41 arc(96.46,65.3) 96.43,65.2 96.4,65.14 arc(96.38,65.07) 96.37,64.99 96.37,64.96 arc(96.38,64.88) 96.41,64.8 96.44,64.72 arc(96.48,64.57) 96.5,64.41 96.5,64.34 arc(96.47,64.18) 96.37,64.04 96.29,63.96 arc(96.11,63.83) 95.89,63.79 95.81,63.79 arc(95.68,63.81) 95.55,63.85 arc(95.28,63.93) v4(95,63.93)
QSFPDD0_RX5_N: length 45.9
  L03_SIG1 w0.079: v4(54.96,61.89) 55.24,62.17 55.51,62.17 55.76,61.93 55.76,61.03 56.4,60.4 57.91,60.4 arc(58.18,60.45) 58.4,60.6 60.5,62.7 arc(60.55,62.73) 60.6,62.74 82.68,62.74 arc(82.83,62.71) 82.96,62.63 83.16,62.43 arc(83.29,62.34) 83.44,62.31 86.97,62.31 arc(87.11,62.28) 87.23,62.2 88.62,60.81 89.03,60.81 89.27,60.92 89.57,61.22 arc(89.65,61.27) 89.74,61.29 89.86,61.29 arc(90.01,61.25) 90.12,61.14 90.14,61.11 arc(90.34,60.91) 90.61,60.84 90.69,60.84 arc(90.99,60.92) 91.21,61.14 91.22,61.16 arc(91.33,61.27) 91.49,61.31 91.55,61.31 arc(91.81,61.38) 91.99,61.57 92.05,61.67 arc(92.18,61.8) 92.37,61.85 92.48,61.85 arc(92.73,61.92) 92.92,62.11 arc(93.05,62.23) 93.22,62.28 93.33,62.28 arc(93.48,62.24) 93.59,62.13 93.64,62.04 arc(93.81,61.87) 94.04,61.81 94.17,61.81 arc(94.3,61.78) 94.4,61.68 94.45,61.59 arc(94.67,61.37) 94.97,61.29 95.06,61.29 arc(95.23,61.32) 95.37,61.42 arc(95.46,61.52) 95.53,61.63 95.59,61.73 arc(95.59,61.73) 95.59,61.73 95.61,61.76 arc(95.63,61.8) 95.64,61.85 arc(95.73,62.14) v4(95.86,62.43)
QSFPDD0_RX5_P: length 45.6
  L03_SIG1 w0.079: v4(54.96,62.69) 55.24,62.4 55.61,62.4 55.99,62.02 55.99,61.13 56.49,60.63 57.91,60.63 arc(58.09,60.66) 58.24,60.76 60.34,62.86 arc(60.46,62.94) 60.6,62.97 82.68,62.97 arc(82.92,62.92) 83.12,62.79 83.32,62.59 arc(83.38,62.55) 83.44,62.54 86.97,62.54 arc(87.2,62.49) 87.39,62.36 88.71,61.04 88.98,61.04 89.14,61.11 89.41,61.38 arc(89.56,61.48) 89.74,61.52 89.86,61.52 arc(90.13,61.45) 90.32,61.25 90.34,61.23 arc(90.45,61.11) 90.61,61.07 90.69,61.07 arc(90.87,61.12) 91.01,61.25 91.02,61.27 arc(91.22,61.47) 91.49,61.54 91.55,61.54 arc(91.69,61.58) 91.79,61.68 91.85,61.78 arc(92.07,62) 92.37,62.08 92.48,62.08 arc(92.62,62.12) 92.72,62.22 arc(92.93,62.43) 93.22,62.51 93.33,62.51 arc(93.6,62.44) 93.79,62.24 93.84,62.15 arc(93.92,62.07) 94.04,62.04 94.17,62.04 arc(94.41,61.98) 94.6,61.79 94.64,61.71 arc(94.78,61.57) 94.97,61.52 95.06,61.52 arc(95.14,61.53) 95.21,61.58 arc(95.28,61.66) 95.33,61.74 95.41,61.87 arc(95.41,61.89) 95.42,61.9 arc(95.42,61.94) 95.41,61.99 95.38,62.03 arc(95.32,62.08) 95.24,62.07 v4(94.99,61.93)
QSFPDD0_RX6_N: length 80.6
  L16_SIG6 w0.079: v1(52.03,63.89) 52.31,64.17 52.72,64.17 53.19,64.65 53.19,66.19 52.02,67.36 50.7,67.36 49.5,68.57 48.66,68.57 47.38,69.86 47.38,73.92 48.99,75.54 52.87,75.54 54.35,77.02 62.82,77.02 65.08,74.75 65.08,74.61 65.7,73.99 66.99,73.99 67.67,73.31 67.67,73.03 68,72.7 68.62,72.7 68.87,72.45 68.87,71.82 70.6,70.08 76.63,70.08 77.24,70.69 78.55,70.69 78.89,70.35 89.05,70.35 89.09,70.31 89.85,70.31 arc(90,70.27) 90.12,70.16 90.15,70.11 arc(90.36,69.89) 90.65,69.81 90.7,69.81 arc(90.97,69.89) 91.17,70.09 91.2,70.14 arc(91.33,70.27) 91.5,70.31 91.59,70.31 arc(91.75,70.27) 91.86,70.16 91.89,70.11 arc(92.1,69.89) 92.4,69.81 arc(92.69,69.89) 92.91,70.11 92.94,70.16 arc(93.05,70.27) 93.2,70.31 93.29,70.31 arc(93.47,70.27) 93.6,70.14 93.63,70.08 arc(93.83,69.89) 94.09,69.81 94.18,69.81 arc(94.33,69.78) 94.44,69.67 94.5,69.56 arc(94.68,69.38) 94.93,69.31 95.08,69.31 arc(95.2,69.28) 95.29,69.19 95.41,68.99 arc(95.51,68.83) 95.64,68.69 95.7,68.63 arc(95.84,68.46) 95.94,68.26 96.22,67.59 arc(96.24,67.53) 96.24,67.46 arc(96.24,67.36) 96.21,67.27 96.2,67.24 arc(96.14,67.06) 96.12,66.88 arc(96.16,66.68) 96.28,66.52 96.32,66.47 arc(96.49,66.35) 96.7,66.31 96.75,66.31 arc(96.91,66.27) 97.03,66.16 97.06,66.11 arc(97.24,65.92) 97.5,65.85 97.71,65.85 arc(97.95,65.91) 98.12,66.09 98.15,66.14 arc(98.25,66.24) 98.39,66.28 98.56,66.28 arc(98.63,66.27) 98.69,66.23 98.76,66.15 arc(98.81,66.08) 98.83,65.99 98.83,65.93 arc(98.82,65.87) 98.81,65.82 98.76,65.7 arc(98.72,65.42) 98.82,65.16 98.83,65.14 arc(98.89,64.99) 98.87,64.83 98.86,64.78 arc(98.81,64.69) 98.75,64.62 98.7,64.58 arc(98.61,64.52) 98.51,64.5 98.36,64.5 arc(98.1,64.43) 97.92,64.25 97.89,64.2 arc(97.8,64.11) 97.68,64.08 97.55,64.08 arc(97.34,64.04) 97.16,63.92 97.11,63.87 arc(96.99,63.68) 96.94,63.45 96.94,63.41 arc(96.99,63.18) 97.13,62.97 97.16,62.94 arc(97.34,62.82) 97.55,62.78 97.59,62.78 arc(97.73,62.79) 97.86,62.83 97.88,62.84 arc(97.88,62.84) 97.89,62.84 arc(98.17,62.92) v1(98.46,62.93)
QSFPDD0_RX6_P: length 80.5
  L16_SIG6 w0.079: v1(52.03,64.69) 52.31,64.4 52.63,64.4 52.97,64.74 52.97,66.09 51.92,67.13 50.61,67.13 49.4,68.34 48.57,68.34 47.15,69.76 47.15,74.02 48.89,75.76 52.78,75.76 54.26,77.24 62.92,77.24 65.31,74.85 65.31,74.7 65.79,74.22 67.09,74.22 67.9,73.41 67.9,73.12 68.1,72.93 68.71,72.93 69.1,72.55 69.1,71.91 70.7,70.31 76.54,70.31 77.15,70.92 78.65,70.92 78.99,70.58 89.15,70.58 89.18,70.54 89.85,70.54 arc(90.12,70.47) 90.32,70.27 90.35,70.22 arc(90.48,70.09) 90.65,70.04 90.7,70.04 arc(90.85,70.09) 90.97,70.2 91,70.25 arc(91.21,70.47) 91.5,70.54 91.59,70.54 arc(91.86,70.47) 92.06,70.27 92.09,70.22 arc(92.22,70.09) 92.4,70.04 arc(92.58,70.09) 92.71,70.23 92.74,70.28 arc(92.93,70.47) 93.2,70.54 93.29,70.54 arc(93.58,70.46) 93.8,70.25 93.83,70.19 arc(93.94,70.08) 94.09,70.04 94.18,70.04 arc(94.44,69.97) 94.64,69.78 94.7,69.68 arc(94.79,69.58) 94.93,69.54 95.08,69.54 arc(95.31,69.48) 95.49,69.31 95.61,69.1 arc(95.69,68.97) 95.8,68.85 95.86,68.79 arc(96.03,68.59) 96.15,68.35 96.43,67.68 arc(96.46,67.57) 96.47,67.46 arc(96.46,67.32) 96.42,67.18 96.41,67.15 arc(96.37,67.02) 96.35,66.88 arc(96.37,66.77) 96.44,66.68 96.48,66.63 arc(96.58,66.57) 96.7,66.54 96.75,66.54 arc(97.03,66.47) 97.22,66.27 97.25,66.22 arc(97.36,66.12) 97.5,66.08 97.71,66.08 arc(97.83,66.11) 97.92,66.2 97.95,66.25 arc(98.14,66.44) 98.39,66.51 98.56,66.51 arc(98.72,66.48) 98.85,66.39 98.92,66.32 arc(99.02,66.16) 99.06,65.99 99.06,65.93 arc(99.05,65.83) 99.02,65.73 98.97,65.62 arc(98.95,65.45) 99,65.29 99.02,65.26 arc(99.11,65.02) 99.09,64.75 99.07,64.71 arc(99,64.57) 98.9,64.45 98.86,64.41 arc(98.69,64.31) 98.51,64.27 98.36,64.27 arc(98.22,64.24) 98.12,64.14 98.09,64.08 arc(97.92,63.91) 97.68,63.85 97.55,63.85 arc(97.43,63.83) 97.32,63.76 97.28,63.71 arc(97.2,63.59) 97.17,63.45 97.17,63.41 arc(97.2,63.26) 97.29,63.14 97.32,63.1 arc(97.43,63.03) 97.55,63.01 97.59,63.01 arc(97.68,63.02) 97.77,63.04 97.8,63.05 arc(97.83,63.07) 97.85,63.1 97.88,63.15 arc(97.89,63.22) 97.84,63.29 v1(97.59,63.43)
QSFPDD0_RX7_N: length 47
  L16_SIG6 w0.079: v1(54.96,64.29) 55.24,64.57 55.53,64.57 58.59,61.52 64.45,61.52 64.63,61.34 79.23,61.34 79.48,61.59 82.87,61.59 84.37,60.09 86.08,60.09 86.52,60.52 88.07,60.52 88.35,60.81 89.08,60.81 89.59,60.3 91.55,60.3 arc(91.67,60.28) 91.78,60.21 91.97,60.02 arc(92.15,59.89) 92.37,59.85 92.51,59.85 arc(92.75,59.91) 92.92,60.08 92.95,60.14 arc(93.05,60.24) 93.18,60.27 93.33,60.27 arc(93.5,60.23) 93.62,60.11 arc(93.83,59.89) 94.12,59.81 94.94,59.81 arc(95.24,59.87) 95.5,60.05 95.62,60.17 arc(95.79,60.29) 96,60.33 96.71,60.33 arc(96.93,60.37) 97.13,60.5 97.33,60.7 arc(97.41,60.76) 97.51,60.78 97.6,60.78 arc(97.76,60.8) 97.91,60.85 arc(98.18,60.94) v1(98.46,60.93)
QSFPDD0_RX7_P: length 47
  L16_SIG6 w0.079: v1(54.96,65.09) 55.24,64.8 55.63,64.8 58.68,61.75 64.55,61.75 64.73,61.57 79.14,61.57 79.42,61.85 82.93,61.85 84.47,60.32 85.99,60.32 86.42,60.75 87.97,60.75 88.26,61.03 89.18,61.03 89.68,60.53 90.69,60.53 90.82,60.66 91.1,60.66 91.22,60.53 91.55,60.53 arc(91.76,60.49) 91.94,60.37 92.13,60.18 arc(92.24,60.11) 92.37,60.08 92.51,60.08 arc(92.63,60.11) 92.72,60.2 92.75,60.25 arc(92.93,60.43) 93.18,60.5 93.33,60.5 arc(93.61,60.43) 93.82,60.22 arc(93.95,60.09) 94.12,60.04 94.94,60.04 arc(95.15,60.09) 95.34,60.21 95.46,60.33 arc(95.71,60.5) 96,60.55 96.71,60.55 arc(96.85,60.58) 96.96,60.66 97.17,60.87 arc(97.32,60.97) 97.51,61.01 97.6,61.01 arc(97.71,61.02) 97.8,61.05 arc(97.83,61.07) 97.85,61.1 97.88,61.15 arc(97.89,61.22) 97.84,61.29 v1(97.59,61.43)
QSFPDD0_TX0_N: length 36.9
  L03_SIG1 w0.079: v4(57.89,74.69) 58.17,74.4 58.58,74.4 58.88,74.09 58.88,73.11 arc(59.05,72.25) 59.54,71.53 61.42,69.64 arc(61.47,69.6) 61.52,69.56 arc(62.1,69.25) 62.73,69.06 arc(62.79,69.05) 62.86,69.05 arc(63.35,68.93) 63.76,68.65 63.82,68.59 arc(63.95,68.43) 64.05,68.24 arc(64.25,67.99) 64.56,67.9 77.88,67.9 77.93,67.95 78.09,67.95 78.27,67.76 78.55,67.69 87.97,67.69 arc(88.12,67.72) 88.25,67.81 88.33,67.88 arc(88.52,68.01) 88.74,68.06 88.98,68.06 arc(89.11,68.09) 89.2,68.18 89.23,68.24 arc(89.28,68.3) 89.33,68.36 arc(89.45,68.45) 89.58,68.53 arc(89.67,68.56) 89.77,68.57 89.87,68.57 arc(89.92,68.57) 89.97,68.56 arc(89.98,68.56) 89.99,68.55 90.23,68.49 arc(90.44,68.44) v4(90.67,68.43)
QSFPDD0_TX0_P: length 36.8
  L03_SIG1 w0.079: v4(57.89,73.89) 58.17,74.17 58.48,74.17 58.66,74 58.66,73.11 arc(58.84,72.17) 59.38,71.37 61.26,69.48 arc(61.32,69.43) 61.39,69.37 arc(62.01,69.04) 62.68,68.84 arc(62.77,68.82) 62.85,68.82 arc(63.26,68.72) 63.6,68.49 63.66,68.43 arc(63.76,68.31) 63.83,68.16 arc(64.12,67.8) 64.56,67.67 77.89,67.67 arc(77.99,67.65) 78.09,67.61 arc(78.31,67.5) 78.55,67.46 87.1,67.46 arc(87.15,67.45) 87.19,67.43 87.28,67.34 87.56,67.34 87.69,67.46 87.97,67.46 arc(88.21,67.51) 88.41,67.65 88.49,67.72 arc(88.6,67.8) 88.74,67.83 88.98,67.83 arc(89.22,67.89) 89.39,68.06 arc(89.4,68.07) 89.4,68.07 89.43,68.12 arc(89.45,68.16) 89.48,68.19 arc(89.58,68.26) 89.68,68.32 arc(89.72,68.34) 89.77,68.34 89.86,68.34 arc(89.99,68.31) 90.08,68.22 90.08,68.21 arc(90.09,68.13) 90.05,68.07 v4(89.8,67.93)
QSFPDD0_TX1_N: length 53
  L03_SIG1 w0.079: v4(49.1,74.29) 49.38,74 49.6,74 49.85,74.25 49.85,75.07 50.87,76.09 58.22,76.09 58.26,76.08 59.62,75.52 arc(59.69,75.48) 59.76,75.42 61.62,73.56 arc(61.94,73.07) 62.06,72.5 62.06,72.2 arc(62.19,71.39) 62.58,70.67 arc(62.59,70.66) 62.61,70.65 arc(62.82,70.51) 63.07,70.46 75.67,70.46 arc(76.24,70.35) 76.72,70.03 76.79,69.96 arc(77.54,69.46) 78.42,69.28 88.87,69.28 arc(88.95,69.3) 89.02,69.34 89.05,69.38 arc(89.23,69.5) 89.45,69.54 89.82,69.54 arc(89.99,69.59) 90.12,69.72 90.15,69.77 arc(90.35,69.97) 90.62,70.04 90.71,70.04 arc(90.98,69.97) 91.18,69.77 91.21,69.72 arc(91.34,69.59) 91.51,69.54 91.55,69.54 arc(91.76,69.5) 91.94,69.38 91.98,69.34 arc(92.05,69.25) 92.11,69.15 arc(92.14,69.04) 92.15,68.93 92.15,68.93 arc(92.14,68.83) 92.11,68.73 92.04,68.55 arc(92.02,68.49) 92.02,68.44 arc(92.02,68.37) 92.04,68.31 92.11,68.13 arc(92.13,68.07) 92.13,68.01 arc(92.13,67.99) 92.13,67.96 arc(92.07,67.71) 91.92,67.49 91.87,67.45 arc(91.71,67.34) 91.51,67.3 91.5,67.3 arc(91.32,67.25) 91.19,67.12 91.19,67.11 arc(90.97,66.9) 90.67,66.82 90.62,66.82 arc(90.49,66.8) 90.38,66.72 90.33,66.67 arc(90.25,66.52) 90.26,66.36 arc(90.27,66.34) 90.28,66.32 arc(90.34,66.28) 90.42,66.29 v4(90.67,66.43)
QSFPDD0_TX1_P: length 52.8
  L03_SIG1 w0.079: v4(89.8,65.93) 90.05,66.07 arc(90.09,66.13) 90.08,66.21 arc(90.06,66.24) 90.05,66.28 arc(90.02,66.57) 90.16,66.83 90.22,66.88 arc(90.4,67.01) 90.62,67.05 90.67,67.05 arc(90.86,67.1) 90.99,67.23 arc(90.99,67.23) 90.99,67.23 arc(91.21,67.45) 91.5,67.53 91.51,67.53 arc(91.62,67.55) 91.71,67.61 91.76,67.66 arc(91.86,67.8) 91.91,67.98 arc(91.91,68) 91.91,68.01 arc(91.9,68.03) 91.9,68.05 91.83,68.23 arc(91.8,68.33) 91.79,68.44 arc(91.8,68.54) 91.83,68.64 91.9,68.82 arc(91.92,68.87) 91.92,68.93 91.92,68.93 arc(91.92,69) 91.9,69.06 91.9,69.07 arc(91.86,69.12) 91.82,69.18 91.78,69.22 arc(91.67,69.29) 91.55,69.31 91.51,69.31 arc(91.22,69.39) 91.01,69.61 90.98,69.66 arc(90.86,69.77) 90.71,69.81 90.62,69.81 arc(90.47,69.77) 90.35,69.66 90.32,69.61 arc(90.11,69.39) 89.82,69.31 89.45,69.31 arc(89.32,69.29) 89.22,69.22 89.18,69.18 arc(89.04,69.09) 88.87,69.05 78.42,69.05 arc(77.45,69.25) 76.63,69.8 76.55,69.87 arc(76.15,70.14) 75.67,70.23 63.07,70.23 arc(62.74,70.3) 62.45,70.48 arc(62.42,70.5) 62.4,70.53 arc(61.98,71.32) 61.83,72.2 61.83,72.5 arc(61.73,72.98) 61.46,73.4 59.59,75.26 arc(59.56,75.29) 59.53,75.3 58.18,75.86 50.97,75.86 50.07,74.97 50.07,74.15 49.7,73.77 49.38,73.77 v4(49.1,73.49)
QSFPDD0_TX2_N: length 43.2
  L16_SIG6 w0.079: v1(93.26,66.93) 93.02,67.07 arc(92.94,67.08) 92.88,67.03 92.85,66.98 arc(92.7,66.83) 92.49,66.78 92.31,66.78 arc(92.18,66.74) 92.09,66.65 92.06,66.6 arc(91.97,66.49) 91.86,66.4 arc(91.73,66.34) 91.59,66.33 91.31,66.33 91.18,66.2 90.9,66.2 90.78,66.33 90.5,66.33 90.37,66.2 90.09,66.2 89.96,66.33 89.8,66.33 89.28,65.8 88.51,65.8 88.26,66.06 78.72,66.06 78.64,66.14 65.49,66.14 63.94,67.7 63.94,67.92 61.4,70.46 61.2,70.46 61.07,70.59 61.07,70.79 60.66,71.2 59.88,71.2 59.36,71.72 59.23,71.72 58.97,71.97 58.97,72.11 58.68,72.4 58.68,73.29 58.48,73.48 57.31,73.48 57.15,73.32 57.15,73 57.35,72.81 57.35,72.66 57.15,72.47 57.15,72.19 57.34,72 57.6,72 v1(57.89,72.29)
QSFPDD0_TX2_P: length 43.2
  L16_SIG6 w0.079: v1(57.89,71.49) 57.6,71.77 57.24,71.77 56.92,72.09 56.92,73.42 57.29,73.79 58.5,73.79 58.91,73.38 58.91,72.49 59.98,71.43 60.76,71.43 64.17,68.02 64.17,67.82 65.59,66.4 65.59,66.37 78.74,66.37 78.82,66.29 88.35,66.29 88.61,66.03 89.18,66.03 89.7,66.55 91.59,66.55 arc(91.67,66.57) 91.75,66.6 arc(91.81,66.65) 91.86,66.71 91.89,66.76 arc(92.07,66.94) 92.31,67.01 92.49,67.01 arc(92.58,67.03) 92.65,67.1 92.68,67.15 arc(92.69,67.22) 92.64,67.29 v1(92.4,67.43)
QSFPDD0_TX3_N: length 56.3
  L16_SIG6 w0.079: v1(49.1,71.89) 49.38,71.6 50.1,71.6 51.86,73.37 54.08,73.37 55.57,74.86 60.55,74.86 62.85,72.56 62.85,71.99 63.13,71.71 63.63,71.71 65.41,69.93 65.41,68.15 65.82,67.74 77.84,67.74 77.85,67.74 arc(77.87,67.74) 77.89,67.75 arc(78.05,67.8) 78.23,67.82 88.26,67.82 arc(88.44,67.85) 88.6,67.94 arc(88.76,68.03) 88.93,68.06 arc(88.98,68.06) 89.03,68.07 arc(89.14,68.09) 89.25,68.1 90.35,68.1 arc(90.47,68.12) 90.57,68.19 90.69,68.31 arc(90.94,68.47) 91.23,68.53 91.51,68.53 arc(91.71,68.5) 91.89,68.41 arc(91.9,68.4) 91.92,68.39 arc(91.98,68.34) 92.04,68.29 92.19,68.13 arc(92.4,68.05) 92.61,68.13 92.89,68.41 arc(92.99,68.48) 93.12,68.51 93.4,68.51 arc(93.63,68.43) 93.77,68.23 arc(93.78,68.2) 93.8,68.18 93.88,68.12 arc(93.89,68.11) 93.91,68.11 arc(93.93,68.1) 93.95,68.09 arc(94,68.07) 94.06,68.06 94.36,67.98 arc(94.44,67.95) 94.52,67.9 94.63,67.82 arc(94.65,67.81) 94.67,67.79 arc(94.74,67.69) 94.77,67.57 94.78,67.45 arc(94.76,67.32) 94.7,67.2 arc(94.64,67.09) 94.62,66.96 arc(94.63,66.94) 94.63,66.92 arc(94.63,66.84) 94.66,66.77 arc(94.72,66.6) 94.74,66.41 94.74,66.37 arc(94.7,66.16) 94.58,65.98 arc(94.38,65.85) 94.15,65.8 94.07,65.8 arc(94.02,65.8) 93.98,65.79 arc(93.95,65.78) 93.91,65.76 arc(93.86,65.72) 93.82,65.67 arc(93.73,65.57) 93.63,65.49 arc(93.63,65.49) 93.62,65.48 arc(93.47,65.39) 93.3,65.36 arc(93.28,65.36) 93.27,65.35 93.21,65.35 arc(93.21,65.35) 93.2,65.35 arc(93.17,65.34) 93.14,65.34 93.09,65.32 arc(93.07,65.31) 93.06,65.3 93.06,65.3 93.02,65.25 93.02,65.2 arc(93.02,65.18) 93.02,65.16 arc(93.03,65.14) 93.04,65.13 93.07,65.09 arc(93.14,65.01) 93.23,64.95 v1(93.26,64.93)
QSFPDD0_TX3_P: length 56.2
  L16_SIG6 w0.079: v1(92.4,65.43) 92.52,65.36 arc(92.66,65.32) 92.79,65.36 arc(92.82,65.39) 92.85,65.42 arc(92.91,65.48) 92.97,65.52 arc(93,65.53) 93.02,65.54 93.07,65.55 arc(93.12,65.57) 93.17,65.58 93.18,65.58 arc(93.19,65.58) 93.2,65.58 93.25,65.58 arc(93.27,65.58) 93.28,65.58 arc(93.39,65.61) 93.48,65.66 arc(93.49,65.67) 93.5,65.68 arc(93.57,65.74) 93.63,65.8 arc(93.76,65.93) 93.91,66.01 arc(93.99,66.02) 94.07,66.03 94.15,66.03 arc(94.3,66.06) 94.42,66.14 arc(94.49,66.24) 94.51,66.37 94.51,66.41 arc(94.5,66.55) 94.46,66.67 arc(94.39,66.96) 94.46,67.24 arc(94.49,67.29) 94.52,67.34 arc(94.54,67.39) 94.55,67.44 94.54,67.56 arc(94.53,67.59) 94.51,67.63 arc(94.5,67.63) 94.49,67.64 94.39,67.72 arc(94.35,67.74) 94.3,67.76 94.01,67.84 arc(93.96,67.85) 93.91,67.86 arc(93.89,67.87) 93.88,67.87 arc(93.84,67.89) 93.8,67.91 arc(93.8,67.9) 93.8,67.9 arc(93.8,67.9) 93.8,67.9 93.67,68 arc(93.6,68.07) 93.55,68.17 arc(93.5,68.25) 93.4,68.28 93.12,68.28 arc(93.08,68.27) 93.05,68.25 92.77,67.97 arc(92.4,67.82) 92.03,67.97 91.88,68.13 arc(91.87,68.14) 91.86,68.14 arc(91.83,68.17) 91.79,68.2 arc(91.78,68.2) 91.77,68.21 arc(91.76,68.22) 91.75,68.22 arc(91.64,68.28) 91.51,68.3 91.23,68.3 arc(91.02,68.26) 90.85,68.15 90.73,68.03 arc(90.72,68.01) 90.7,68 arc(90.54,67.9) 90.35,67.87 89.25,67.87 arc(89.17,67.87) 89.09,67.85 arc(89.01,67.84) 88.94,67.83 arc(88.83,67.81) 88.74,67.76 arc(88.52,67.64) 88.26,67.59 78.23,67.59 78.1,67.58 78.04,67.52 77.99,67.52 77.99,67.49 77.81,67.49 77.78,67.52 65.72,67.52 65.59,67.64 65.59,67.65 65.18,68.06 65.18,69.83 63.54,71.48 63.03,71.48 62.62,71.89 62.62,72.47 60.46,74.63 55.66,74.63 54.18,73.14 53.49,73.14 53.37,73.02 53.37,72.95 53.24,72.82 53.03,72.82 52.91,72.95 52.91,73.02 52.78,73.14 51.96,73.14 50.19,71.37 49.38,71.37 v1(49.1,71.09)
QSFPDD0_TX4_N: length 41.9
  L03_SIG1 w0.079: v4(54.96,74.69) 55.24,74.4 55.65,74.4 55.99,74.07 55.99,70.93 56.64,70.28 58.01,70.28 58.27,70.55 59.01,70.55 62.92,66.63 77.65,66.63 78.06,66.22 87.09,66.22 arc(87.44,66.15) 87.75,65.95 88.62,65.08 arc(88.66,65.05) 88.71,65.04 88.97,65.04 arc(89.25,64.96) 89.46,64.76 89.51,64.67 arc(89.59,64.6) 89.69,64.57 89.85,64.57 arc(89.98,64.55) 90.11,64.51 arc(90.38,64.42) v4(90.67,64.43)
QSFPDD0_TX4_P: length 41.9
  L03_SIG1 w0.079: v4(54.96,73.89) 55.24,74.17 55.56,74.17 55.76,73.97 55.76,70.84 56.54,70.06 58.1,70.06 58.36,70.32 58.91,70.32 62.83,66.4 77.55,66.4 77.97,65.99 87.09,65.99 arc(87.36,65.94) 87.58,65.79 87.8,65.57 87.8,65.39 87.99,65.2 88.17,65.2 88.46,64.92 arc(88.57,64.84) 88.71,64.81 88.97,64.81 arc(89.14,64.76) 89.26,64.64 89.31,64.56 arc(89.47,64.4) 89.69,64.34 89.85,64.34 arc(89.93,64.33) 90.01,64.3 arc(90.04,64.28) 90.06,64.25 90.08,64.21 arc(90.09,64.13) 90.05,64.07 v4(89.8,63.93)
QSFPDD0_TX5_N: length 45.8
  L03_SIG1 w0.079: v4(52.03,74.29) 52.31,74 52.64,74 53.19,73.45 53.19,70.66 53.95,69.9 55.06,69.9 55.77,69.2 55.77,68.41 56.36,67.82 57.85,67.82 58.18,68.15 59.8,68.15 62.33,65.62 arc(62.68,65.39) 63.09,65.31 67.8,65.31 67.83,65.33 68.28,65.33 68.31,65.36 68.36,65.36 68.41,65.31 76,65.31 76.33,64.98 76.72,64.98 76.97,64.72 86.06,64.72 arc(86.56,64.62) 86.98,64.34 87.95,63.37 arc(88.32,63.12) 88.75,63.04 88.97,63.04 arc(89.25,62.96) 89.46,62.76 89.51,62.67 arc(89.59,62.59) 89.7,62.56 89.86,62.56 arc(89.99,62.55) 90.11,62.51 arc(90.38,62.42) v4(90.67,62.43)
QSFPDD0_TX5_P: length 45.7
  L03_SIG1 w0.079: v4(52.03,73.49) 52.31,73.77 52.55,73.77 52.97,73.36 52.97,70.56 53.86,69.67 54.97,69.67 55.54,69.1 55.54,68.31 56.26,67.59 57.94,67.59 58.27,67.92 59.7,67.92 62.16,65.46 arc(62.59,65.18) 63.09,65.08 67.9,65.08 67.93,65.1 68.28,65.1 68.31,65.08 75.54,65.08 arc(75.88,65.01) 76.17,64.81 arc(76.53,64.58) 76.95,64.49 86.06,64.49 arc(86.47,64.41) 86.82,64.18 87.22,63.78 87.22,63.6 87.41,63.4 87.59,63.4 87.79,63.21 arc(88.23,62.91) 88.75,62.81 88.97,62.81 arc(89.14,62.76) 89.26,62.64 89.31,62.56 arc(89.47,62.39) 89.7,62.33 89.86,62.33 arc(89.94,62.33) 90.01,62.3 arc(90.04,62.28) 90.06,62.25 90.08,62.21 arc(90.09,62.13) 90.05,62.07 v4(89.8,61.93)
QSFPDD0_TX6_N: length 43.3
  L16_SIG6 w0.079: v1(54.96,72.29) 55.24,72 55.62,72 58.17,69.45 60.96,69.45 62.87,67.53 62.87,66.34 63.93,65.28 76.69,65.28 77.16,64.81 87.06,64.81 87.3,65.04 89.2,65.04 89.69,64.54 91.58,64.54 arc(91.85,64.47) 92.05,64.27 92.08,64.23 92.1,64.19 arc(92.19,64.11) 92.3,64.08 92.44,64.08 arc(92.65,64.04) 92.83,63.92 92.92,63.83 92.96,63.76 arc(93.03,63.61) 93.05,63.44 arc(93.11,63.19) 93.23,62.96 arc(93.24,62.95) 93.25,62.95 arc(93.26,62.94) v1(93.26,62.93)
QSFPDD0_TX6_P: length 43.3
  L16_SIG6 w0.079: v1(92.4,63.43) 92.64,63.29 arc(92.72,63.28) 92.78,63.32 92.81,63.37 arc(92.82,63.4) 92.83,63.43 arc(92.81,63.54) 92.76,63.64 92.73,63.69 92.66,63.76 arc(92.56,63.83) 92.44,63.85 92.3,63.85 arc(92.08,63.91) 91.91,64.06 91.88,64.11 91.85,64.16 arc(91.74,64.27) 91.58,64.32 91.3,64.32 91.16,64.18 90.91,64.18 90.77,64.32 90.49,64.32 90.36,64.19 90.08,64.19 89.95,64.32 89.6,64.32 89.1,64.81 88.74,64.81 88.61,64.68 88.33,64.68 88.21,64.81 87.39,64.81 87.16,64.58 77.07,64.58 76.59,65.05 63.84,65.05 62.64,66.25 62.64,67.44 60.86,69.22 58.08,69.22 55.52,71.77 55.24,71.77 v1(54.96,71.49)
