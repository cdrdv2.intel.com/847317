# Allegro board TS28247BC0_FM61_agilex_PCIe_DEVKIT_ADI_REVB1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_DIMM_CH1_DQ55: length 80.6
  L07_SIG3 w0.089: v1(176.69,105.06) 176.69,105.37 175.64,106.43 174.61,106.43 172.3,105.47 172.01,105.18 172.01,104.84 171.55,104.37 169.51,103.01 166.49,100.53 165.23,99.27 165.23,98.91 163.51,97.18 162.95,96.95 159.9,96.95 156.66,93.72 152.15,93.72 151.32,92.9 150.19,92.9 149.52,92.23 149.26,92.23 148.92,91.9 147.92,91.9 147.71,91.81 147.44,91.54 147.34,91.29 146.28,90.24 144.53,89.51 142.57,88.92 140.17,87.92 134.31,87.92 132.37,87.54 128.3,87.54 127.12,87.05 125.24,87.05 124.02,87.55 123.06,87.55 122.4,86.9 121.67,86.9 121.39,86.62 120.45,85.22 120.32,85.08 119.39,84.7 118.95,84.41 118.66,84.12 117.9,83.8 116.92,82.82 116.14,82.82 115.13,81.81 114.76,81.81 114.26,81.31 113.89,81.31 113.41,80.82 113.04,80.82 112.53,80.31 112.17,80.31 111.67,79.81 111.3,79.81 111.02,79.53 111.02,78.83 110.83,78.64 110.83,78.22 110.96,78.09 110.96,77.77 110.83,77.64 110.83,77.22 111.09,76.95 111.09,76.78 v1(111.45,76.43)
DDR4_DIMM_CH1_DQ56: length 93.9
  L05_SIG2 w0.081: v1(180.94,99.06) 180.57,98.69 179.4,98.69 179.3,98.59 179.3,98.42 179.4,98.32 181.95,98.32 182.06,98.22 182.06,98.02 181.95,97.91 179.85,97.91 179.71,97.77 179.71,96.75 179.15,96.18 178.93,96.18 177.95,95.21 177.81,95.21 177.72,95.31 177.72,95.44 178,95.73 178,95.87 177.91,95.97 177.77,95.97 177.02,95.22 172.42,95.22 169.09,91.9 163.63,91.9 163.48,91.75 162.8,91.75 162.57,91.98 157.16,91.98 156.93,91.75 151.62,91.75 151.55,91.81 149.12,91.81 148.21,91.2 145.38,89.69 141.5,88.08 140.37,86.95 138.9,86.95 137.87,85.92 123.04,85.92 122.02,84.9 121.16,84.9 120.31,84.05 119.44,84.05 118.3,82.91 117.84,82.91 116.84,81.92 116.47,81.92 116.07,81.51 115.68,81.51 115.29,81.13 115.29,80.24 115.02,79.96 114.86,79.96 114.46,79.56 114.46,78.69 114.1,78.34 113.8,78.34 113.32,77.85 113.07,77.85 112.78,77.56 112.78,77.3 112.92,77.16 112.92,76.7 112.8,76.59 112.8,76.27 112.96,76.12 112.96,75.73 112.78,75.55 112.78,73.29 113.02,73.04 113.33,73.04 113.84,73.56 114.21,73.56 114.69,74.04 115.16,74.04 115.35,74.23 115.35,74.5 v1(115.78,74.93)
DDR4_DIMM_CH1_DQ57: length 94.6
  L05_SIG2 w0.081: v1(181.79,105.06) 180.71,103.98 180.58,103.98 180.2,104.36 180.06,104.36 179.96,104.26 179.96,104.12 180.34,103.75 180.34,103.61 180.24,103.51 180.1,103.51 179.72,103.89 179.58,103.89 179.48,103.79 179.48,103.65 179.86,103.27 179.86,103.13 179.77,103.03 179.63,103.03 179.43,103.24 179.29,103.24 179.19,103.14 179.19,103 179.39,102.8 179.39,102.66 179.09,102.36 177.96,102.36 175.41,100.04 174.77,99.41 174.58,99.12 174.48,98.86 174.34,98.73 174.09,98.52 172.97,97.78 171.32,96.84 169.54,95.83 165.63,93.98 151.68,93.98 150.76,93.8 150.11,93.8 149.74,93.95 147.51,93.95 146.11,93.37 143.37,92.39 142.62,92.08 142.07,91.97 141.75,91.84 141.05,91.37 140.21,90.53 139.87,90.28 137.33,89.9 129.37,89.9 128.16,89.78 126.84,89.72 126.63,89.69 123.49,89.03 123.23,88.99 122.59,88.93 121.7,88.8 121.4,88.67 120.33,88.1 120.06,88.03 118.36,87.82 118.13,87.74 116.9,87.09 116.33,86.66 115.42,85.44 115.27,85.26 115.09,85.07 114.65,84.71 114.56,84.6 113.91,83.22 113.5,82.21 113.44,82.15 112.66,81.63 112.2,81.35 112,81.15 111.95,81.05 111.88,80.79 111.88,80.65 111.81,80.32 111.78,80.26 111.73,80.18 111.63,80.08 111.29,79.8 111.12,79.63 111.08,79.52 111.08,79.34 111.16,79.13 111.16,78.72 111.07,78.51 111.07,78.35 111.16,78.13 111.16,77.73 111.07,77.52 111.07,77.35 111.16,77.14 111.16,76.71 111.07,76.5 111.07,76.35 111.16,76.13 111.16,75.73 111.08,75.52 111.08,75.27 111.17,75.17 111.17,74.69 111.04,74.56 111.04,74.26 111.32,73.98 111.46,73.98 112.12,73.32 112.45,73.32 112.94,72.83 113.42,72.83 113.88,73.3 114.25,73.3 114.75,73.8 115.65,73.8 v1(115.78,73.93)
DDR4_DIMM_CH1_DQ58: length 93.1
  L05_SIG2 w0.081: v1(114.91,74.43) 115.32,74.84 115.32,76.1 115.68,76.46 115.98,76.46 116.39,76.86 116.77,76.86 117.02,77.12 117.02,78.08 117.3,78.36 117.63,78.36 117.94,78.67 117.94,79.66 118.22,79.94 118.45,79.94 118.91,80.4 119.37,80.4 119.88,80.91 120.26,80.91 120.75,81.4 121.07,81.4 121.59,81.93 122.1,81.93 122.51,82.33 122.91,82.33 123.46,82.89 134.28,82.89 134.38,82.79 134.38,82.4 134.48,82.3 134.62,82.3 134.72,82.4 134.72,82.79 134.81,82.89 134.95,82.89 135.05,82.79 135.05,82.4 135.15,82.3 135.29,82.3 135.39,82.4 135.39,82.79 135.48,82.89 135.62,82.89 135.72,82.79 135.72,82.4 135.82,82.3 135.96,82.3 136.06,82.4 136.06,82.79 136.15,82.89 136.29,82.89 136.39,82.79 136.39,82.4 136.49,82.3 136.63,82.3 136.73,82.4 136.73,82.79 136.83,82.89 136.96,82.89 137.06,82.79 137.06,82.4 137.16,82.3 137.3,82.3 137.4,82.4 137.4,82.79 137.5,82.89 137.63,82.89 137.73,82.79 137.73,82.16 137.83,82.06 137.97,82.06 138.07,82.16 138.07,82.79 138.17,82.89 138.31,82.89 138.4,82.79 138.4,82.27 138.5,82.17 138.64,82.17 138.74,82.27 138.74,82.79 138.84,82.89 139.51,82.89 140.65,84.03 142.8,84.92 143.99,84.92 145.75,86.69 148.27,88.37 149.33,88.81 150.23,88.99 156.2,88.99 156.84,88.72 173.09,88.72 173.19,88.83 173.19,89.04 173.09,89.14 172.67,89.14 172.57,89.25 172.57,89.44 172.67,89.54 173,89.54 173.23,89.77 175.78,90.82 177.16,90.82 178.66,92.32 180.94,93.27 182.07,94.4 183.25,94.88 184.63,94.88 185.17,95.43 185.17,95.99 186.44,97.26 186.44,98.61 v1(186.89,99.06)
DDR4_DIMM_CH1_DQ59: length 93.3
  L05_SIG2 w0.081: v1(114.91,73.43) 114.97,73.48 115.96,73.48 116.19,73.72 116.19,75.62 116.54,75.97 116.88,75.97 117.32,76.42 117.67,76.42 117.89,76.63 117.89,77.55 118.17,77.83 118.4,77.83 118.75,78.18 118.75,79.02 119.13,79.4 119.35,79.4 119.89,79.95 120.29,79.95 120.74,80.4 121.1,80.4 121.67,80.98 122.18,80.98 122.56,81.36 122.94,81.36 123.45,81.87 123.82,81.87 124.2,81.49 124.63,81.49 124.96,81.81 125.6,81.81 125.91,81.5 126.42,81.5 126.72,81.8 127.29,81.8 127.55,81.54 128.27,81.54 128.53,81.81 129.03,81.81 129.3,81.54 129.96,81.54 130.24,81.81 130.83,81.81 131.11,81.54 131.65,81.54 131.92,81.81 132.56,81.81 132.86,81.51 133.35,81.51 133.67,81.82 134.3,81.82 134.57,81.56 138.2,81.56 139.55,82.12 140.38,82.95 142.81,83.96 144.01,83.96 147.39,87.33 148.54,88.1 149.47,88.49 150.26,88.64 155.88,88.64 156.6,88.34 174.5,88.34 175.68,88.58 176.13,88.76 176.58,89.06 176.88,89.37 178.66,90.55 179.09,90.73 179.58,91.22 179.76,91.66 180.36,92.26 184.22,93.86 184.5,93.86 185.1,94.11 185.78,94.79 186.17,95.72 186.74,96.58 187.15,96.98 187.27,97.28 187.27,100.3 v1(187.74,105.06)
DDR4_DIMM_CH1_DQ60: length 92
  L05_SIG2 w0.081: v1(179.24,99.06) 178.83,98.65 178.83,96.81 178.73,96.71 178.59,96.71 178.49,96.81 178.49,98.27 178.39,98.37 178.25,98.37 178.15,98.27 178.15,97.18 177.9,96.92 176.39,96.92 176.3,96.82 176.3,96.68 176.39,96.59 177.3,96.59 177.4,96.49 177.4,96.35 177.3,96.25 174.92,96.25 174.82,96.15 174.82,96.01 174.92,95.92 176.67,95.92 176.77,95.82 176.77,95.68 176.67,95.58 172.24,95.58 169.22,92.56 151.85,92.56 151.57,92.29 150.65,92.29 150.51,92.15 148.94,92.15 148.8,92.01 148.22,92.01 147.73,91.81 147.33,91.54 145.75,90.89 144.88,90.3 141.13,88.75 140.3,87.92 138.76,87.92 137.73,86.89 126.07,86.89 125.97,86.8 125.97,86.5 125.87,86.4 125.73,86.4 125.64,86.5 125.64,86.8 125.54,86.89 125.4,86.89 125.3,86.8 125.3,86.5 125.2,86.4 125.06,86.4 124.96,86.5 124.96,86.8 124.87,86.89 124.73,86.89 124.63,86.8 124.63,86.5 124.53,86.4 124.39,86.4 124.29,86.5 124.29,86.8 124.2,86.89 123.26,86.89 122.41,86.04 121.47,86.04 120.38,84.95 119.58,84.95 118.3,83.67 117.82,83.67 117.07,82.92 116.07,82.92 115.05,81.89 114.85,81.89 114.54,81.58 114.54,80.81 114.21,80.47 114.04,80.47 113.67,80.09 113.67,79.27 113.27,78.87 113.09,78.87 112.71,78.49 112.71,77.79 112.56,77.64 112.56,77.22 112.7,77.08 112.7,76.79 112.55,76.64 112.55,76.22 112.7,76.06 112.7,75.79 112.32,75.4 v1(112.32,74.93)
DDR4_DIMM_CH1_DQ61: length 90
  L05_SIG2 w0.081: v1(180.09,105.06) 178.92,103.89 177.48,103.89 172.88,99.29 172.88,98.88 172.35,98.35 171.38,98.35 169.96,96.93 169.22,96.93 167.56,95.27 166.56,95.27 165.68,94.38 150.89,94.38 150.64,94.14 150.19,94.14 149.95,94.38 147.23,94.38 147.02,94.18 146.65,94.02 144.35,94.02 143.29,92.96 142.01,92.96 141.04,91.99 140.06,91.99 139.73,91.65 139.73,91.34 139.37,90.98 138.67,90.98 138.15,90.46 137.59,90.46 137.37,90.25 136.49,90.25 136.18,90.55 130.42,90.55 130.2,90.34 121.66,90.34 120.19,88.88 119.64,88.88 119.44,88.67 118.89,88.67 118.68,88.88 117.94,88.88 114.97,85.91 114.51,85.91 114.03,85.42 114.03,84.65 113.16,83.78 113.16,82.96 112.71,82.51 112.2,82.51 111.63,81.94 111.29,81.94 111.03,81.68 111.03,80.85 110.8,80.62 110.8,80.23 110.95,80.08 110.95,79.77 110.8,79.62 110.8,79.23 110.95,79.08 110.95,78.77 110.8,78.62 110.8,78.23 110.95,78.08 110.95,77.77 110.8,77.62 110.8,77.23 110.95,77.08 110.95,76.77 110.8,76.62 110.8,76.23 110.95,76.08 110.95,75.77 110.8,75.62 110.8,75.38 110.95,75.01 110.95,74.77 110.8,74.62 110.8,74.08 v1(111.45,73.43)
DDR4_DIMM_CH1_DQ62: length 91.7
  L05_SIG2 w0.081: v1(112.32,73.93) 112.32,74.38 111.94,74.76 111.94,75.09 112.07,75.22 112.07,75.65 111.94,75.78 111.94,76.08 112.09,76.23 112.09,76.62 111.94,76.77 111.94,77.08 112.04,77.18 112.04,77.67 111.91,77.8 111.91,78.06 112.07,78.21 112.07,78.64 111.93,78.78 111.93,79.08 112.18,79.33 112.38,79.33 113.08,80.03 113.3,80.03 113.57,80.29 113.57,80.98 113.93,81.34 114.16,81.34 114.27,81.45 114.27,81.61 114.5,81.84 114.5,82.62 114.77,82.88 115.3,82.88 115.82,83.41 116.42,83.41 117.96,84.96 118.71,84.96 119.63,85.88 120.3,85.88 121.66,87.24 122.19,87.24 122.78,87.83 127.72,87.83 127.82,87.73 127.82,87.45 127.91,87.35 128.05,87.35 128.15,87.45 128.15,87.73 128.25,87.83 128.39,87.83 128.49,87.73 128.49,87.45 128.58,87.35 128.72,87.35 128.82,87.45 128.82,87.73 128.92,87.83 129.06,87.83 129.16,87.73 129.16,87.45 129.26,87.35 129.39,87.35 129.49,87.45 129.49,87.73 129.59,87.83 137.74,87.83 138.85,88.93 139.55,88.93 144.51,90.99 144.85,91.33 145.39,91.33 146.04,91.98 147.06,91.98 147.65,92.22 148.51,93.09 148.76,93.09 149.21,92.64 149.88,92.64 150.15,92.9 151.47,92.9 151.77,93.21 168.8,93.21 171.25,95.65 171.79,95.65 172.07,95.93 173.68,95.93 175.98,98.22 177.27,98.22 177.98,98.94 177.98,99.34 179.05,100.41 183.6,100.41 184.94,99.06 v1(185.19,99.06)
DDR4_DIMM_CH1_DQ63: length 90.2
  L05_SIG2 w0.081: v1(111.45,74.43) 111.45,74.49 111.68,74.72 111.68,75.13 111.82,75.27 111.82,75.58 111.72,75.69 111.72,76.15 111.82,76.26 111.82,76.59 111.73,76.68 111.73,77.17 111.82,77.26 111.82,77.6 111.7,77.72 111.7,78.16 111.82,78.27 111.82,78.58 111.72,78.68 111.72,79.17 111.84,79.29 111.84,79.8 111.98,80.12 112.37,80.51 112.46,80.51 112.94,80.99 113.27,80.99 113.67,81.39 113.67,82.08 114.18,82.59 114.18,82.81 114.98,83.61 114.98,83.93 115.98,84.93 115.98,85.34 116.63,85.99 117.21,85.99 118.2,86.98 120.26,86.98 120.89,87.61 121.97,87.61 122.76,88.41 123.33,88.64 123.51,88.68 124.75,88.68 125.05,88.98 137.89,88.98 140.21,89.94 141.31,91.04 142.54,91.04 143.41,91.91 145.32,91.91 145.85,92.43 147.24,92.43 148.25,93.44 148.98,93.44 149.38,93.04 149.79,93.04 150.01,93.26 151.33,93.26 151.65,93.58 165.7,93.58 168.74,94.84 171.25,96.18 172.29,96.88 174.35,97.98 176.54,98.89 178.99,101.33 179.09,101.43 181.67,103.54 184.15,104.29 185.2,104.5 v1(186.04,105.06)
DDR4_DIMM_CH1_DQ64: length 58.6
  L07_SIG3 w0.089: v1(97.59,74.43) 97.59,74.09 96.91,73.41 96.55,73.41 96.19,73.05 95.71,73.05 95.21,73.54 94.85,73.54 94.52,73.87 94.52,75.61 93.66,76.47 93.66,78.7 93.57,78.8 93.35,78.8 93.25,78.89 93.25,79.03 93.35,79.13 93.57,79.13 93.66,79.23 93.66,79.37 93.57,79.47 93.35,79.47 93.25,79.57 93.25,79.7 93.35,79.8 93.57,79.8 93.66,79.9 93.66,80.04 93.57,80.14 93.35,80.14 93.25,80.24 93.25,80.37 93.35,80.47 93.57,80.47 93.66,80.57 93.66,82.78 92.59,83.85 92.59,85.93 92.49,86.03 92.36,86.03 92.26,85.93 92.26,84.48 92.16,84.39 92.02,84.39 91.92,84.48 91.92,87.04 91.82,87.14 91.68,87.14 91.59,87.04 91.59,85.17 91.49,85.07 91.32,85.07 91.22,85.17 91.22,92.35 93.76,94.89 93.76,95.03 93.66,95.13 93.52,95.13 91.74,93.35 91.6,93.35 91.5,93.45 91.5,93.58 93.75,95.83 94.18,95.83 95.48,97.13 95.48,97.58 95.74,97.84 98.57,97.84 99.4,98.68 106.59,98.68 v1(106.99,99.09)
DDR4_DIMM_CH1_DQ65: length 58.5
  L07_SIG3 w0.089: v1(107.84,105.06) 106.73,103.94 106.73,101.95 107.05,101.62 108.72,101.62 108.86,101.49 108.86,101.19 108.72,101.06 106.13,101.06 105.52,101.67 105.08,101.67 104.01,100.61 98.15,100.61 97,99.45 94.05,99.45 92.48,97.88 91.51,97.88 91.25,97.62 91.25,96.74 88.95,94.44 88.95,93.38 88.73,93.16 88.73,91.32 89.75,90.3 89.75,88.59 89.4,88.24 89.4,84.33 91.1,82.62 91.1,76.52 91.72,75.89 91.72,75.21 92.04,74.89 92.57,74.89 92.98,74.48 93.38,74.48 93.91,73.94 94.15,73.94 94.78,73.31 95.14,73.31 95.65,72.81 96.06,72.81 96.48,72.39 96.93,72.39 97.59,73.05 v1(97.59,73.43)
DDR4_DIMM_CH1_DQ66: length 57.5
  L07_SIG3 w0.089: v1(112.94,99.06) 112.94,98.76 112.01,97.83 110.33,97.83 110.17,97.76 110.06,97.65 109.98,97.46 109.98,96.89 109.87,96.77 109.67,96.77 109.38,97.06 109.24,97.06 109.12,96.94 109.12,96.79 109.42,96.49 109.42,96.32 109.28,96.18 102.94,96.18 102.3,95.54 101.42,95.54 98.93,93.04 98.79,93.04 98.69,93.14 98.69,93.28 100.67,95.25 100.67,95.39 100.57,95.49 100.43,95.49 97.63,92.7 97.63,92.01 97.18,91.56 97.18,91.01 96.17,90.01 96.03,90.01 95.94,90.11 95.94,90.25 96.74,91.05 96.74,91.19 96.65,91.29 96.51,91.29 95.45,90.24 95.45,85.66 95.55,85.56 96.61,85.56 96.71,85.46 96.71,85.32 96.61,85.23 95.57,85.23 95.47,85.13 95.47,84.99 95.57,84.89 96.71,84.89 96.82,84.78 96.82,84.58 96.72,84.48 96.38,84.48 96.28,84.39 96.28,84.25 96.38,84.15 96.72,84.15 96.82,84.05 96.82,83.91 96.72,83.81 96.38,83.81 96.28,83.72 96.28,83.58 96.38,83.48 96.72,83.48 96.82,83.38 96.82,83.24 96.72,83.14 96.38,83.14 96.28,83.04 96.28,82.91 96.38,82.81 96.72,82.81 96.82,82.71 96.82,82.57 96.72,82.47 96.38,82.47 96.28,82.37 96.28,81.82 96.51,81.59 96.51,81.27 96.28,81.05 96.28,80.53 96.38,80.43 96.73,80.43 96.83,80.33 96.83,80.19 96.73,80.1 96.38,80.1 96.28,80 96.28,79.86 96.38,79.76 96.73,79.76 96.83,79.66 96.83,79.52 96.73,79.43 96.38,79.43 96.28,79.33 96.28,79.19 96.38,79.09 96.73,79.09 96.83,78.99 96.83,78.85 96.73,78.76 96.38,78.76 96.28,78.66 96.28,77.72 96.5,77.51 96.5,77.29 96.28,77.08 96.28,76.74 96.93,76.09 96.93,75.13 v1(96.73,74.93)
DDR4_DIMM_CH1_DQ67: length 57.3
  L07_SIG3 w0.089: v1(96.73,73.93) 97.09,74.29 97.09,74.58 97.2,74.69 97.2,85.56 96.48,86.28 96.48,87.67 96.78,87.97 96.78,89.84 98.08,91.14 98.08,92.35 98.33,92.61 98.99,92.61 101.53,95.15 102.44,95.15 103.12,95.84 109.48,95.84 110.89,97.25 111.65,97.25 111.87,97.03 112.1,97.03 112.31,97.12 112.56,97.37 112.56,97.85 113.33,98.62 113.33,104.14 112.56,104.91 112.56,105.61 110.46,107.71 110.46,107.84 110.57,107.95 110.71,107.95 111.44,107.21 111.95,107.21 112.05,107.11 112.05,106.66 112.15,106.56 112.35,106.56 112.45,106.66 112.45,107.16 112.55,107.26 112.69,107.26 112.79,107.16 112.79,106.07 112.89,105.98 113.02,105.98 113.12,106.07 113.12,107.15 113.22,107.25 113.36,107.25 113.46,107.15 113.46,105.39 v1(113.79,105.06)
DDR4_DIMM_CH1_DQ68: length 55.8
  L07_SIG3 w0.089: v1(94.13,74.43) 94.13,74.82 92.83,76.11 92.83,82.93 91.03,84.73 90.89,84.73 90.79,84.63 90.79,84.5 92.16,83.13 92.16,82.99 92.06,82.89 91.92,82.89 90.28,84.53 90.28,85.41 90.39,85.51 90.74,85.51 90.86,85.63 90.86,85.83 90.74,85.95 90.4,85.95 90.28,86.07 90.28,87.67 90.78,88.17 90.78,90.87 90.43,91.22 90.43,91.57 90.17,91.82 90.17,93.23 90.27,93.33 90.41,93.33 90.51,93.23 90.51,92.1 90.61,92.01 90.75,92.01 90.84,92.1 90.84,93.18 91.06,93.39 91.06,93.68 92.09,94.72 92.09,94.86 92,94.96 91.86,94.96 90.93,94.03 90.79,94.03 90.7,94.13 90.7,94.27 93.05,96.63 93.19,96.63 93.29,96.53 93.29,96.39 92.43,95.53 92.43,95.39 92.53,95.29 92.67,95.29 93.78,96.41 93.78,96.89 94.13,97.24 94.28,97.24 94.54,96.98 94.69,96.98 94.79,97.08 94.79,97.22 94.52,97.49 94.52,97.63 95.16,98.27 98.36,98.27 99.58,99.49 99.9,99.49 100.03,99.36 100.03,99.22 100.13,99.12 100.31,99.12 100.41,99.22 100.41,99.38 100.52,99.49 101.44,99.49 101.76,99.16 103.43,99.16 103.75,99.48 104.88,99.48 v1(105.29,99.06)
DDR4_DIMM_CH1_DQ69: length 55.8
  L07_SIG3 w0.089: v1(94.13,73.43) 93.09,73.43 92.71,73.81 91.89,73.81 90.81,74.88 90.56,74.88 90.05,75.39 89.67,75.39 89.33,75.73 89.33,83.29 89.23,83.39 89.09,83.39 88.99,83.29 88.99,82 88.89,81.9 88.75,81.9 88.66,82 88.66,83.89 88.46,84.09 88.46,87.37 87.85,87.97 87.54,87.97 87.4,88.12 87.4,91.38 87,91.78 87,92.99 87.2,93.2 87.2,93.92 89.56,96.28 89.56,96.42 89.46,96.52 89.33,96.52 88.66,95.85 88.52,95.85 88.42,95.95 88.42,96.09 89.54,97.21 89.54,97.61 90.43,98.5 90.43,99.44 91.5,100.52 96.83,100.52 97.71,101.4 100.9,101.4 101.51,102.01 103.17,102.01 v1(106.23,105.07)
DDR4_DIMM_CH1_DQ70: length 53.8
  L07_SIG3 w0.089: v1(93.26,74.93) 92.79,75.4 92.79,75.66 92.53,75.93 92.3,75.93 91.97,76.25 91.97,82.25 89.87,84.35 89.87,87.95 90.31,88.39 90.31,90.39 89.51,91.19 89.51,91.67 89.74,91.91 89.74,94.48 93.91,98.65 96.96,98.65 98.47,100.15 104.71,100.15 104.98,100.43 106.6,100.43 106.69,100.33 106.69,100.19 106.6,100.09 105.62,100.09 105.52,99.99 105.52,99.85 105.62,99.75 108.44,99.75 108.54,99.85 108.54,99.99 108.44,100.09 107.39,100.09 107.3,100.19 107.3,100.33 107.39,100.43 109.82,100.43 109.92,100.33 109.92,100.19 109.82,100.09 109.16,100.09 109.06,99.99 109.06,99.85 109.16,99.75 110.58,99.75 v1(111.24,99.09)
DDR4_DIMM_CH1_DQ71: length 54.6
  L07_SIG3 w0.089: v1(112.09,105.06) 112.09,105.47 111.11,106.45 109.81,106.45 108.87,105.52 106.87,105.52 106.61,105.26 106.61,104.7 103.49,101.58 101.66,101.58 101.07,100.99 97.93,100.99 97.09,100.15 92.03,100.15 91.22,99.34 91.22,98.4 90.46,97.64 90.46,96.5 88.06,94.11 88.06,93.25 87.86,93.05 87.86,91.13 88.27,90.73 88.27,88.35 88.9,87.73 88.9,84.23 90.21,82.92 90.21,76.8 91.19,75.83 91.19,74.96 92.1,74.05 93.14,74.05 v1(93.26,73.93)
DDR4_DIMM_CH1_DQS_N0: length 51.8
  L05_SIG2 w0.079: v1(72.14,104.93) 72.4,104.67 72.4,104.27 75.22,101.46 75.22,99.56 74.98,99.32 74.98,98.3 75.46,97.83 77.2,97.83 77.71,98.34 77.71,102.21 77.93,102.44 81.61,102.44 81.74,102.31 81.74,101.98 81.61,101.85 80.04,101.85 79.78,101.59 79.78,101.07 80.04,100.81 81.3,100.81 81.62,100.48 81.62,98.58 80.88,97.84 80.88,97.17 82.58,95.47 83.58,95.47 86,93.04 87.23,93.04 90.27,90 90.65,90 93.84,86.81 94.3,86.81 94.61,86.51 94.61,85.65 95.2,85.06 95.2,84.04 95.41,83.83 95.41,82.85 95.24,82.68 95.24,82.31 95.37,81.99 95.55,81.81 95.71,81.81 95.86,81.66 v1(95.86,81.43)
DDR4_DIMM_CH1_DQS_N1: length 41.6
  L03_SIG1 w0.079: 81.8,105.61 81.8,105.37 v4(81.49,105.06) ; 86.86,103.27 86.86,100.98 86,100.13 85.31,100.13 83.55,98.37 83.55,97.35 84.03,96.87 87.29,96.87 90.04,94.12 90.04,92.04 89.61,91.61 89.61,91.24 93.03,87.83 93.03,86.12 95.48,83.67 95.48,82.35 95.54,82.21 95.63,82.12 95.82,82.04 95.95,82.04 96.21,81.94 96.37,81.78 96.46,81.55 96.46,81.3 96.33,80.99 96.33,80.88 96.47,80.55 96.47,80.29 96.35,80.01 96.35,79.85 96.46,79.6 96.46,79.18 96.18,78.9 v4(95.86,78.43)
  L03_SIG1 w0.081: 86.86,103.27 84.24,105.9 82.09,105.9 81.8,105.61
DDR4_DIMM_CH1_DQS_N2: length 41.7
  L05_SIG2 w0.079: v1(101.92,78.93) 102.2,79.28 102.41,79.48 102.53,79.79 102.53,80.05 102.41,80.34 102.41,82.44 102.49,82.63 102.49,84.82 103.41,85.74 103.41,90.81 102.34,91.88 102.34,92.29 102.68,92.62 102.68,94.89 100.59,96.98 100.11,96.98 99.03,98.06 94.38,98.06 93.8,98.64 93.8,99.26 94.01,99.47 94.01,101.18 93.49,101.7 93.49,102.07 93.6,102.18 94.43,102.18 94.72,102.48 94.72,102.94 94.43,103.23 92.31,103.23 92.17,103.37 92.17,103.67 92.31,103.81 93.23,103.81 93.48,104.06 93.48,104.44 92.1,105.82 91.39,105.82 91.14,105.58 91.14,105.36 v1(90.84,105.06)
DDR4_DIMM_CH1_DQS_N3: length 32.3
  L03_SIG1 w0.079: v4(101.92,80.93) 102.22,81.37 102.46,81.61 102.55,81.83 102.55,82.02 102.42,82.35 102.42,82.54 102.49,82.72 102.49,85.56 102.21,85.84 101.9,85.84 101.76,85.98 101.76,86.33 102.01,86.58 102.01,86.91 101.76,87.16 101.76,87.34 102.36,87.94 102.36,89.18 100.83,90.71 100.83,91.77 100.66,91.94 100.66,95.88 100.87,96.4 101.66,97.19 101.66,97.77 102.57,98.68 102.57,99.34 101.56,100.36 101.56,102.1 101.81,102.35 101.81,103.13 103.44,104.76 103.44,105.34 102.87,105.9 100.73,105.9 100.48,105.65 100.48,105.34 v4(100.19,105.06)
DDR4_DIMM_CH1_DQS_N4: length 75.2
  L07_SIG3 w0.085: v1(155.44,105.06) 155.76,105.38 155.76,105.64 156.02,105.89 156.62,105.89 158.64,103.87 158.64,99.56 155.01,95.93 150.23,95.93 149.2,94.9 148.8,94.9 147.94,94.04 147.26,94.04 147.07,93.85 146.49,93.85 145.55,92.91 142.38,92.91 141.36,91.88 136.46,91.88 135.86,91.28 132.46,91.28 132.07,90.88 130.7,90.88 129.74,89.93 121.01,89.93 118.91,87.82 118.24,87.82 117.28,86.86 117.28,86.21 116.88,85.81 114.77,85.81 114.12,85.17 114.12,84.3 112.15,82.33 111.9,82.01 arc(111.72,81.87) 111.5,81.82 111.41,81.82 arc(111.29,81.79) 111.19,81.71 111.04,81.52 arc(110.86,81.37) 110.63,81.32 110.55,81.32 arc(110.42,81.29) 110.32,81.21 110.17,81.02 arc(109.99,80.87) 109.76,80.82 109.67,80.82 arc(109.54,80.79) 109.44,80.71 109.29,80.52 arc(109.11,80.37) 108.89,80.32 108.86,80.32 arc(108.7,80.29) 108.56,80.19 arc(108.5,80.09) 108.47,79.97 108.47,79.85 108.59,79.55 108.59,79.29 108.47,78.99 108.47,78.86 108.59,78.57 108.59,78.31 108.46,77.99 108.46,77.88 108.6,77.54 108.6,77.31 108.47,77 108.47,76.87 108.59,76.58 108.59,76.28 108.48,76.01 108.48,75.84 108.6,75.55 108.6,75.31 108.47,74.99 108.47,74.88 108.61,74.54 108.61,74.35 108.47,74.01 108.27,73.81 108.09,73.81 107.99,73.71 v1(107.99,73.43)
DDR4_DIMM_CH1_DQS_N5: length 83.9
  L05_SIG2 w0.079: v1(107.99,76.43) 108.41,76.85 108.6,77.31 108.6,77.5 108.47,77.82 108.47,78.02 108.59,78.32 108.59,78.54 108.47,78.85 108.47,79.01 108.59,79.31 108.59,79.57 108.47,79.87 108.47,80 108.6,80.33 108.6,80.54 108.48,80.84 108.48,81.02 108.54,81.16 108.62,81.24 108.76,81.3 108.93,81.3 109.2,81.41 109.37,81.59 109.47,81.82 109.47,82.03 109.35,82.33 109.35,82.56 109.45,82.82 110.34,83.71 110.34,85.26 112.83,87.75 113.51,87.75 118.65,92.9 130.32,92.9 130.61,93.19 133.28,93.19 134.12,92.35 135.82,92.35 138.12,94.65 140.3,94.65 142.43,96.78 150.54,96.78 150.88,97.12 151.42,97.12 152.27,96.27 165.34,96.27 167.16,98.09 167.16,99.35 166.76,99.76 166.76,101.53 167.12,101.9 167.12,104.67 165.93,105.86 165.38,105.86 165.11,105.6 165.11,105.38 v1(164.79,105.06)
DDR4_DIMM_CH1_DQS_N6: length 83.3
  L07_SIG3 w0.085: v1(114.05,75.93) 114.05,76.22 114.14,76.31 114.35,76.31 114.52,76.49 114.65,76.81 114.65,77.05 114.53,77.35 114.53,77.47 arc(114.55,77.57) 114.61,77.66 114.68,77.73 arc(114.77,77.79) 114.88,77.81 114.96,77.81 arc(115.18,77.87) 115.36,78.01 115.52,78.2 arc(115.62,78.28) 115.74,78.31 115.82,78.31 arc(116.05,78.37) 116.23,78.51 116.38,78.7 arc(116.48,78.78) 116.61,78.81 116.69,78.81 arc(116.91,78.87) 117.09,79.01 117.25,79.2 arc(117.35,79.28) 117.47,79.31 117.55,79.31 arc(117.78,79.37) 117.96,79.51 118.11,79.7 arc(118.21,79.78) 118.34,79.81 118.42,79.81 arc(118.65,79.87) 118.83,80.01 118.98,80.2 arc(119.08,80.28) 119.2,80.31 119.28,80.31 arc(119.51,80.37) 119.69,80.51 119.84,80.7 arc(119.94,80.78) 120.06,80.81 120.15,80.81 arc(120.37,80.86) 120.55,81.01 120.7,81.2 arc(120.8,81.28) 120.93,81.31 121.02,81.31 arc(121.24,81.36) 121.42,81.51 121.58,81.7 arc(121.67,81.78) 121.8,81.81 121.87,81.81 arc(122.1,81.86) 122.28,82.01 122.4,82.16 123.05,82.81 141.41,82.81 142.41,83.82 144.15,83.82 148.36,88.03 149.73,88.6 153.44,88.6 156.78,89.98 161.9,89.98 164.55,92.63 172.49,92.63 176.94,97.08 176.94,99.05 177.35,99.47 177.35,103.85 175.41,105.79 174.71,105.79 174.47,105.56 174.47,105.39 v1(174.14,105.06)
DDR4_DIMM_CH1_DQS_N7: length 92.8
  L05_SIG2 w0.079: v1(183.5,105.06) 183.81,105.37 183.81,105.61 184.16,105.96 185.57,105.96 185.84,105.91 186.31,105.71 186.56,105.47 186.67,105.19 186.67,104.5 186.16,103.26 185.67,100.8 185.67,99.74 185.8,99.09 185.8,98.86 185.61,98.25 184.83,97.08 184.69,96.94 182.59,95.53 179.72,93.81 175.41,91.51 169.47,90.03 156.94,90.03 150.91,89.73 149.02,89.35 148.03,88.94 144.96,86.89 144.71,86.81 143.62,86.81 143.33,86.73 141.18,85.29 138.55,84.2 137.5,83.99 133.68,83.81 123.51,83.81 123.31,83.72 122.93,83.34 122.41,83 122.08,82.86 121.63,82.77 121.4,82.67 120.75,82.24 120.66,82.14 120.55,82.01 arc(120.37,81.86) 120.14,81.81 120.05,81.81 arc(119.92,81.78) 119.83,81.7 119.67,81.51 arc(119.49,81.36) 119.27,81.31 119.21,81.31 arc(119.08,81.28) 118.98,81.2 118.83,81.01 arc(118.65,80.86) 118.42,80.81 118.33,80.81 arc(118.2,80.78) 118.1,80.7 117.95,80.51 arc(117.77,80.36) 117.55,80.31 117.48,80.31 arc(117.37,80.29) 117.28,80.23 117.22,80.17 arc(117.15,80.07) 117.13,79.94 arc(117.14,79.86) 117.16,79.79 117.2,79.7 arc(117.24,79.55) 117.26,79.4 117.26,79.36 arc(117.22,79.19) 117.12,79.05 117.04,78.96 arc(116.86,78.84) 116.65,78.8 arc(116.51,78.77) 116.39,78.69 116.34,78.65 arc(116.29,78.57) 116.27,78.48 116.27,78.45 arc(116.28,78.36) 116.31,78.27 116.33,78.2 arc(116.38,78.04) 116.4,77.88 arc(116.36,77.7) 116.26,77.55 116.17,77.46 arc(116,77.34) 115.8,77.3 115.73,77.3 arc(115.61,77.27) 115.51,77.19 115.36,77 arc(115.18,76.85) 114.95,76.8 114.9,76.8 arc(114.76,76.78) 114.65,76.7 114.63,76.68 arc(114.56,76.58) 114.54,76.46 114.54,76.39 arc(114.54,76.34) 114.56,76.3 114.62,76.15 arc(114.65,76.06) 114.65,75.96 114.65,75.92 arc(114.65,75.82) 114.62,75.72 114.58,75.63 arc(114.55,75.53) 114.54,75.43 arc(114.55,75.34) 114.57,75.26 114.61,75.16 arc(114.64,75.06) 114.65,74.96 114.65,74.91 arc(114.64,74.79) 114.61,74.68 114.53,74.49 114.35,74.31 v1(114.05,73.93)
DDR4_DIMM_CH1_DQS_N8: length 57.4
  L07_SIG3 w0.085: v1(95.86,73.43) 96.18,73.84 96.35,74.01 96.46,74.28 96.46,74.57 96.34,74.86 96.34,75.01 96.54,75.48 96.54,75.85 95.76,76.63 95.76,79.77 95.48,80.05 95.48,80.51 95.6,80.79 95.6,81.07 95.48,81.35 95.48,81.5 95.61,81.81 95.61,82.05 95.49,82.34 95.49,84.03 94.85,84.67 94.85,90.91 100.16,96.23 102.12,96.23 102.7,96.81 108.11,96.81 109.43,98.13 110.18,98.45 111.32,98.45 112.04,98.74 112.08,98.76 112.7,99.38 112.7,100.24 111.93,101.02 111.93,102.53 111.52,102.93 108.98,102.93 108.63,102.58 108.03,102.58 107.7,102.9 107.7,103.57 108.25,104.11 109.12,104.11 109.42,103.81 111.81,103.81 112.09,104.08 112.09,104.52 110.77,105.84 110.08,105.84 109.84,105.6 109.84,105.36 v1(109.54,105.06)
DDR4_DIMM_CH1_DQS_P0: length 51.5
  L05_SIG2 w0.079: v1(95.86,82.43) 95.86,82.14 95.76,82.04 95.65,82.04 95.57,82.12 95.47,82.35 95.47,82.59 95.64,82.75 95.64,83.93 95.43,84.14 95.43,85.15 94.84,85.74 94.84,86.6 94.4,87.04 93.93,87.04 90.74,90.23 90.37,90.23 87.33,93.27 86.1,93.27 83.67,95.7 82.68,95.7 81.1,97.27 81.1,97.74 81.85,98.49 81.85,100.58 81.39,101.03 80.14,101.03 80.01,101.16 80.01,101.49 80.14,101.62 81.71,101.62 81.97,101.88 81.97,102.4 81.71,102.67 77.84,102.67 77.48,102.31 77.48,98.43 77.1,98.05 75.55,98.05 75.21,98.39 75.21,99.23 75.45,99.46 75.45,101.55 72.63,104.37 72.63,104.57 v1(72.99,104.93)
DDR4_DIMM_CH1_DQS_P1: length 41.4
  L03_SIG1 w0.079: v4(82.34,105.06) 82.03,105.37 82.03,105.51 82.13,105.62 82.56,105.62 82.66,105.51 82.66,105.41 82.76,105.31 82.89,105.31 82.99,105.41 82.99,105.51 83.09,105.62 84.19,105.62 86.63,103.18 86.63,101.08 85.9,100.36 85.21,100.36 83.32,98.46 83.32,97.26 83.94,96.64 87.2,96.64 89.81,94.02 89.81,92.13 89.38,91.7 89.38,91.15 92.8,87.73 92.8,86.03 95.25,83.57 95.25,82.31 95.35,82.08 95.5,81.93 95.77,81.82 95.9,81.82 96.08,81.74 96.17,81.65 96.23,81.5 96.23,81.35 96.1,81.03 96.1,80.83 96.24,80.5 96.24,80.33 96.13,80.06 96.13,79.8 96.23,79.55 96.23,79.28 95.89,78.94 95.75,78.94 95.63,79.06 95.63,79.2 v4(95.86,79.43)
DDR4_DIMM_CH1_DQS_P2: length 41.5
  L05_SIG2 w0.079: v1(91.69,105.06) 91.37,105.38 91.37,105.48 91.48,105.59 92,105.59 92.26,105.34 92.26,105.2 92.17,105.11 92.17,104.97 92.27,104.87 92.4,104.87 92.49,104.96 92.63,104.96 93.25,104.34 93.25,104.16 93.13,104.04 92.22,104.04 91.94,103.77 91.94,103.27 92.22,103 94.33,103 94.49,102.84 94.49,102.57 94.33,102.41 93.51,102.41 93.26,102.16 93.26,101.61 93.78,101.08 93.78,99.57 93.57,99.35 93.57,98.55 94.29,97.83 98.93,97.83 100.02,96.75 100.49,96.75 102.45,94.79 102.45,92.72 102.11,92.38 102.11,91.78 103.18,90.71 103.18,85.83 102.26,84.91 102.26,82.67 102.18,82.49 102.18,81.63 102.09,81.53 101.99,81.53 101.9,81.43 101.9,81.29 101.99,81.2 102.09,81.2 102.18,81.1 102.18,80.3 102.31,80 102.31,79.84 102.21,79.61 102.14,79.54 102.02,79.54 101.92,79.64 v1(101.92,79.93)
DDR4_DIMM_CH1_DQS_P3: length 32
  L03_SIG1 w0.079: v4(101.04,105.06) 100.71,105.4 100.71,105.56 100.82,105.68 101.3,105.68 101.4,105.58 101.4,105.46 101.5,105.36 101.64,105.36 101.73,105.46 101.73,105.58 101.83,105.68 102.78,105.68 103.21,105.24 103.21,104.85 101.58,103.23 101.58,102.44 101.33,102.19 101.33,100.26 102.35,99.24 102.35,98.77 101.43,97.86 101.43,97.28 100.68,96.53 100.43,95.93 100.43,91.84 100.6,91.67 100.6,90.61 102.13,89.08 102.13,88.04 101.53,87.44 101.53,87.07 101.78,86.82 101.78,86.67 101.53,86.42 101.53,85.88 101.8,85.61 102.12,85.61 102.26,85.47 102.26,82.76 102.19,82.59 102.19,82.31 102.33,81.97 102.33,81.88 102.27,81.74 102.02,81.49 101.85,81.49 101.75,81.59 101.75,81.75 v4(101.92,81.93)
DDR4_DIMM_CH1_DQS_P4: length 75
  L07_SIG3 w0.085: v1(107.99,74.43) 107.99,74.13 108.08,74.04 108.17,74.04 108.27,74.14 108.38,74.4 108.38,74.49 108.24,74.84 108.24,75.04 108.37,75.36 108.37,75.51 108.25,75.79 108.25,76.06 108.36,76.32 108.36,76.53 108.24,76.82 108.24,77.05 108.37,77.36 108.37,77.5 108.23,77.83 108.23,78.03 108.36,78.36 108.36,78.52 108.24,78.82 108.24,79.04 108.37,79.34 108.37,79.51 108.24,79.8 108.24,79.97 arc(108.29,80.18) 108.4,80.36 arc(108.61,80.5) 108.86,80.55 108.89,80.55 arc(109.01,80.58) 109.11,80.66 109.26,80.85 arc(109.44,80.99) 109.67,81.05 109.76,81.05 arc(109.89,81.08) 109.99,81.16 110.14,81.35 arc(110.32,81.49) 110.55,81.55 110.63,81.55 arc(110.76,81.58) 110.86,81.66 111.01,81.85 arc(111.19,81.99) 111.41,82.05 111.5,82.05 arc(111.62,82.07) 111.72,82.16 111.98,82.48 113.89,84.4 113.89,85.26 114.67,86.04 116.79,86.04 117.05,86.31 117.05,86.96 118.14,88.05 118.81,88.05 120.92,90.15 129.65,90.15 130.61,91.11 131.97,91.11 132.37,91.51 135.77,91.51 136.37,92.11 141.26,92.11 142.29,93.14 145.46,93.14 146.39,94.07 146.97,94.07 147.17,94.27 147.84,94.27 148.7,95.13 149.11,95.13 150.14,96.16 154.92,96.16 158.41,99.65 158.41,103.03 158.31,103.13 158.14,103.13 158.04,103.22 158.04,103.36 158.14,103.46 158.31,103.46 158.41,103.56 158.41,103.78 157.22,104.97 157.08,104.97 156.99,104.87 156.85,104.87 156.75,104.97 156.75,105.1 156.85,105.2 156.85,105.34 156.52,105.67 156.11,105.67 155.99,105.54 155.99,105.37 v1(156.29,105.06)
DDR4_DIMM_CH1_DQS_P5: length 83.8
  L05_SIG2 w0.079: v1(165.64,105.06) 165.34,105.36 165.34,105.5 165.47,105.63 165.83,105.63 166.23,105.24 166.23,105.1 166.12,105 166.12,104.86 166.22,104.76 166.36,104.76 166.46,104.87 166.6,104.87 166.9,104.57 166.9,104 166.8,103.9 166.7,103.9 166.6,103.8 166.6,103.67 166.7,103.57 166.8,103.57 166.9,103.47 166.9,101.99 166.53,101.63 166.53,99.66 166.94,99.26 166.94,98.18 165.25,96.5 152.36,96.5 151.52,97.35 150.79,97.35 150.45,97.01 142.34,97.01 140.2,94.87 138.02,94.87 135.72,92.58 134.21,92.58 133.37,93.41 130.51,93.41 130.23,93.13 118.56,93.13 113.41,87.98 112.73,87.98 110.12,85.36 110.12,83.8 109.26,82.95 109.12,82.6 109.12,82.29 109.24,81.99 109.24,81.87 109.18,81.72 109.07,81.61 108.89,81.53 108.72,81.53 108.49,81.44 108.35,81.29 108.25,81.06 108.25,80.79 108.38,80.49 108.38,80.37 108.24,80.05 108.24,79.82 108.36,79.53 108.36,79.35 108.24,79.05 108.24,78.8 108.37,78.5 108.37,78.37 108.24,78.07 108.24,77.78 108.37,77.46 108.37,77.36 108.26,77.09 108.19,77.02 108.07,77.02 107.99,77.11 v1(107.99,77.43)
DDR4_DIMM_CH1_DQS_P6: length 82.9
  L07_SIG3 w0.085: v1(174.99,105.06) 174.7,105.35 174.7,105.47 174.8,105.57 175.32,105.57 175.53,105.35 175.53,105.22 175.44,105.12 175.44,104.98 175.54,104.89 175.67,104.89 175.77,104.98 175.9,104.98 177.13,103.76 177.13,103.35 177.03,103.26 176.95,103.26 176.85,103.16 176.85,103.02 176.95,102.92 177.03,102.92 177.13,102.83 177.13,99.57 176.71,99.15 176.71,97.17 172.4,92.86 164.46,92.86 161.81,90.21 156.74,90.21 153.39,88.83 149.68,88.83 148.23,88.22 144.05,84.04 142.31,84.04 141.31,83.04 122.96,83.04 122.23,82.31 122.1,82.15 arc(122,82.07) 121.87,82.04 121.8,82.04 arc(121.57,81.99) 121.4,81.84 121.24,81.65 arc(121.14,81.57) 121.02,81.54 120.93,81.54 arc(120.7,81.49) 120.52,81.34 120.37,81.15 arc(120.27,81.07) 120.15,81.04 120.06,81.04 arc(119.84,80.99) 119.66,80.84 119.51,80.65 arc(119.41,80.57) 119.28,80.54 119.2,80.54 arc(118.98,80.49) 118.8,80.34 118.65,80.15 arc(118.55,80.07) 118.42,80.04 118.34,80.04 arc(118.11,79.99) 117.93,79.85 117.78,79.65 arc(117.68,79.57) 117.55,79.54 117.47,79.54 arc(117.25,79.49) 117.07,79.35 116.91,79.15 arc(116.81,79.07) 116.69,79.04 116.61,79.04 arc(116.38,78.99) 116.2,78.85 116.05,78.65 arc(115.95,78.57) 115.82,78.54 115.74,78.54 arc(115.52,78.49) 115.34,78.35 115.18,78.15 arc(115.08,78.07) 114.96,78.04 114.88,78.04 arc(114.69,78) 114.52,77.89 114.45,77.82 arc(114.34,77.66) 114.3,77.47 114.3,77.31 114.43,77.01 114.43,76.85 114.33,76.61 114.26,76.54 114.14,76.54 114.05,76.63 v1(114.05,76.93)
DDR4_DIMM_CH1_DQS_P7: length 92.7
  L05_SIG2 w0.079: v1(184.35,105.06) 184.04,105.37 184.04,105.51 184.25,105.73 184.47,105.73 184.57,105.63 184.57,105.52 184.67,105.42 184.81,105.42 184.9,105.52 184.9,105.63 185,105.73 185.55,105.73 185.77,105.69 186.18,105.52 186.36,105.34 186.44,105.14 186.44,104.54 185.94,103.33 185.44,100.82 185.44,100.58 185.34,100.48 185.22,100.48 185.12,100.38 185.12,100.25 185.22,100.15 185.34,100.15 185.44,100.05 185.44,99.71 185.57,99.07 185.57,98.9 185.4,98.35 184.65,97.23 184.54,97.11 182.47,95.73 179.6,94.01 175.33,91.73 169.45,90.25 156.93,90.25 150.88,89.96 148.95,89.57 147.92,89.15 144.86,87.1 144.68,87.04 143.58,87.04 143.23,86.94 141.07,85.49 138.48,84.42 137.48,84.22 133.67,84.03 123.46,84.03 123.18,83.92 122.78,83.52 122.3,83.2 122.01,83.08 121.57,82.99 121.29,82.88 120.61,82.42 120.49,82.3 120.37,82.15 arc(120.27,82.07) 120.14,82.04 120.05,82.04 arc(119.82,81.99) 119.65,81.84 119.49,81.65 arc(119.39,81.57) 119.27,81.54 119.21,81.54 arc(118.98,81.49) 118.8,81.34 118.65,81.15 arc(118.55,81.07) 118.42,81.04 118.33,81.04 arc(118.1,80.99) 117.92,80.84 117.77,80.65 arc(117.67,80.57) 117.55,80.54 117.48,80.54 arc(117.28,80.5) 117.12,80.39 117.06,80.33 arc(116.94,80.15) 116.9,79.94 arc(116.91,79.82) 116.95,79.7 116.98,79.62 arc(117.02,79.51) 117.03,79.4 117.03,79.36 arc(117.01,79.28) 116.96,79.21 116.88,79.13 arc(116.77,79.05) 116.65,79.03 arc(116.42,78.98) 116.22,78.85 116.18,78.81 arc(116.08,78.66) 116.04,78.48 116.04,78.45 arc(116.06,78.31) 116.09,78.18 116.12,78.12 arc(116.16,78) 116.17,77.88 arc(116.15,77.79) 116.1,77.71 116.01,77.62 arc(115.91,77.55) 115.8,77.53 115.73,77.53 arc(115.51,77.48) 115.33,77.33 115.18,77.14 arc(115.08,77.06) 114.95,77.03 114.9,77.03 arc(114.68,76.99) 114.49,76.86 114.47,76.84 arc(114.35,76.67) 114.31,76.46 114.31,76.39 arc(114.32,76.3) 114.34,76.21 114.41,76.06 arc(114.42,76.01) 114.43,75.96 114.43,75.92 arc(114.42,75.86) 114.41,75.81 114.37,75.72 arc(114.32,75.58) 114.31,75.43 arc(114.32,75.29) 114.36,75.17 114.4,75.07 arc(114.42,75.02) 114.42,74.96 114.42,74.91 arc(114.42,74.83) 114.39,74.76 114.33,74.62 114.26,74.54 114.15,74.54 114.05,74.64 v1(114.05,74.93)
DDR4_DIMM_CH1_DQS_P8: length 57.2
  L07_SIG3 w0.085: v1(110.39,105.06) 110.07,105.38 110.07,105.51 110.17,105.61 110.68,105.61 110.93,105.36 110.93,105.21 110.84,105.12 110.84,104.98 110.94,104.88 111.08,104.88 111.17,104.97 111.31,104.97 111.86,104.43 111.86,104.18 111.71,104.04 109.52,104.04 109.21,104.34 108.16,104.34 107.48,103.66 107.48,102.81 107.94,102.35 108.72,102.35 109.08,102.7 111.43,102.7 111.7,102.43 111.7,100.93 112.48,100.15 112.48,99.48 111.95,98.96 111.27,98.67 110.14,98.67 109.3,98.33 108.02,97.04 102.61,97.04 102.02,96.45 100.07,96.45 94.62,91.01 94.62,84.58 95.26,83.94 95.26,82.3 95.38,82.01 95.38,81.85 95.25,81.55 95.25,81.3 95.37,81.02 95.37,80.84 95.25,80.56 95.25,79.96 95.53,79.68 95.53,78.68 95.32,78.47 95.32,78.2 95.53,77.99 95.53,77.61 95.33,77.41 95.33,77.16 95.53,76.95 95.53,76.54 96.31,75.76 96.31,75.53 96.12,75.05 96.12,74.81 96.23,74.52 96.23,74.32 96.16,74.14 96.06,74.04 95.96,74.04 95.86,74.14 v1(95.86,74.43)
DDR4_DIMM_CH1_ODT0: length 85.4
  L07_SIG3 w0.089: v1(101.92,76.93) 102.3,77.31 102.3,78.02 102.18,78.33 102.18,78.54 102.3,78.85 102.3,79.04 102.18,79.33 102.18,79.55 102.3,79.85 102.3,79.99 102.08,80.53 102.08,80.89 102.39,81.2 102.39,83.59 102.63,83.83 103,83.83 103.43,84.26 103.43,84.97 103.87,85.41 103.87,86.35 104.46,86.93 104.61,86.93 105.13,87.45 105.13,89.81 105.03,89.91 104.89,89.91 104.79,89.81 104.79,88 104.69,87.9 104.55,87.9 104.45,88 104.45,90.22 104.55,90.32 110.36,90.32 112.22,91.09 112.55,91.42 112.64,91.63 113.92,92.91 113.97,93.02 114.89,93.94 115.56,93.94 117.71,96.09 118.3,96.09 118.49,96.28 118.49,96.69 118.32,96.86 118.32,99.32 118.46,99.46 120.08,99.46 122.87,102.25 123.46,102.25 123.94,102.73 123.94,103.16 124.36,103.58 125.88,103.58 126.25,103.96 127.53,103.96 127.85,104.29 129.2,104.29 130.72,105.81 136.08,105.81 136.3,105.59 136.3,104.85 136.49,104.66 139.6,104.66 139.95,105.02 139.95,108.56 140.55,109.15 145.79,109.15 146.15,108.8 146.15,105.05 145.21,104.11 145.21,102.15 144.39,101.32 v1(144.39,99.06)
DDR4_DIMM_CH1_ODT1: length 88.7
  L03_SIG1 w0.081: v4(101.92,75.93) 102.82,75.93 103.45,75.3 103.82,75.3 104.31,74.81 104.86,74.81 105.11,74.55 105.77,74.55 106.03,74.81 106.51,74.81 106.76,74.55 107.47,74.55 107.73,74.8 108.29,74.8 108.54,74.55 109.15,74.55 109.48,74.88 109.79,74.88 110.32,75.42 110.75,75.42 111.23,75.9 111.45,75.9 111.87,76.32 111.87,77.02 112.17,77.32 112.58,77.32 112.8,77.54 112.8,88.12 112.7,88.21 112.7,89.06 112.8,89.15 112.8,90.99 112.54,91.24 112.54,92.09 113.32,92.87 113.32,96.86 113.52,97.07 115.66,97.07 116.53,97.94 117.45,97.94 118.45,98.94 118.45,102.68 118.55,102.79 120.21,102.79 120.39,102.6 120.76,102.6 120.94,102.79 122.76,102.79 122.95,102.6 123.29,102.6 123.48,102.79 125.34,102.79 125.51,102.61 125.51,101.49 126.13,100.87 126.13,99.13 126.69,98.57 127.08,98.57 127.23,98.42 127.33,98.27 127.54,97.99 127.62,97.91 127.7,97.87 127.96,97.87 128.15,97.95 128.7,97.95 128.86,98.02 130.35,99.51 130.35,102.72 131.22,103.59 131.22,103.71 131.74,104.22 132.11,104.22 132.34,104.45 132.34,105.09 132.72,105.46 135.8,105.46 136.84,104.42 136.84,103.91 137.16,103.14 137.24,102.78 137.41,102.6 142.41,102.6 143.14,101.87 143.14,99.97 142.83,99.66 142.83,98.38 143.34,97.87 146.6,97.87 v4(147.79,99.06)
DDR4_DIMM_CH1_PAR: length 82.7
  L07_SIG3 w0.089: v1(136.74,105.06) 137.2,105.52 137.2,108.3 136.95,108.54 131.17,108.54 129.66,110.06 126.63,110.06 125.64,109.07 117.16,109.07 116.9,108.81 116.9,107 117.25,106.65 119.56,106.65 120,106.21 120.89,106.21 121.9,105.2 121.9,104.87 121.64,104.61 121.27,104.61 120.42,105.46 116.1,105.46 115.91,105.27 115.91,104.87 115.37,104.33 115.37,102.64 115,102.28 115,99.99 115.48,99.51 115.48,98.64 115.04,98.2 115.04,97.25 114.48,96.69 113.8,96.69 113.03,95.91 112.53,95.71 111.39,95.71 110.55,94.87 110.55,94.23 110.38,94.06 110.05,94.06 109.3,94.37 105.66,94.37 105.13,93.84 102.05,93.84 100.38,92.17 100.38,91.94 100.62,91.69 100.62,91.28 100.33,90.99 100,90.99 98.94,89.93 98.94,82.86 99.31,82.48 99.31,80.97 99.71,80.58 99.71,80.34 99.59,80.06 99.59,79.78 99.7,79.51 99.7,79.35 99.59,79.08 99.59,78.78 99.71,78.49 99.71,78.37 99.32,77.44 v1(99.32,76.43)
DDR4_DIMM_CH1_RESET_N: length 89
  L03_SIG1 w0.081: v4(103.66,75.93) 104.68,75.93 105.06,75.54 105.58,75.54 106.01,75.97 106.5,75.97 106.93,75.54 107.4,75.54 107.78,75.92 108.11,75.92 108.62,76.43 108.95,76.43 109.43,76.91 109.84,76.91 110.32,77.4 110.75,77.4 111.01,77.65 111.01,81.55 111.27,81.82 111.27,82.03 110.92,82.39 110.92,82.77 111.02,82.87 111.36,82.87 111.46,82.97 111.46,83.17 111.36,83.27 110.77,83.27 110.67,83.37 110.67,83.51 110.77,83.61 111.36,83.61 111.46,83.71 111.46,83.93 111.36,84.03 111.05,84.03 110.92,84.15 110.92,84.66 111.03,84.76 111.28,84.76 111.37,84.85 111.37,85.01 111.28,85.1 111.03,85.1 110.92,85.2 110.92,85.84 111.03,85.94 111.39,85.94 111.49,86.04 111.49,86.17 111.39,86.27 110.75,86.27 110.65,86.37 110.65,86.51 110.75,86.61 111.39,86.61 111.49,86.71 111.49,86.84 111.39,86.94 110.96,86.94 110.81,87.08 110.81,94.32 110.73,94.4 110.57,94.4 110.48,94.32 110.48,93.43 110.36,93.31 109.94,93.31 109.84,93.22 109.84,93.08 109.94,92.98 110.38,92.98 110.48,92.88 110.48,92.74 110.38,92.64 109.52,92.64 109.11,93.05 109.11,93.85 108.74,94.22 108.74,94.38 108.84,94.48 109.01,94.48 109.67,93.82 109.84,93.82 109.94,93.92 109.94,94.09 109.2,94.83 109.2,94.98 109.31,95.09 109.48,95.09 109.66,94.91 109.83,94.91 109.93,95.01 109.93,95.53 110.03,95.63 110.17,95.63 110.26,95.54 110.26,94.84 110.35,94.75 110.51,94.75 110.6,94.84 110.6,96.12 110.69,96.21 110.84,96.21 110.93,96.12 110.93,94.84 111.02,94.75 111.18,94.75 111.27,94.84 111.27,96.4 111.37,96.5 111.51,96.5 111.6,96.4 111.6,94.77 111.7,94.68 111.84,94.68 111.94,94.77 111.94,96.81 111.64,97.11 111.64,97.76 112.56,98.68 112.56,99.71 112.16,100.11 112.16,100.31 112.48,100.63 112.82,100.63 112.92,100.53 112.92,99.55 113.01,99.45 113.23,99.45 113.33,99.55 113.33,100.88 114.24,101.78 115.13,101.78 116.14,102.79 117.68,102.79 117.77,102.7 117.77,102.54 117.68,102.45 116.28,102.45 116.19,102.35 116.19,102.21 116.28,102.11 117.91,102.11 118.01,102.02 118.01,101.88 117.91,101.78 115.62,101.78 115.52,101.68 115.52,101.54 115.62,101.44 116.7,101.44 116.8,101.35 116.8,101.21 116.7,101.11 115.87,101.11 115.77,101.01 115.77,100.62 115.68,100.53 115.52,100.53 115.43,100.62 115.43,101.09 115.12,101.4 114.39,101.4 113.75,100.76 113.75,99.53 113.85,99.44 113.99,99.44 114.09,99.53 114.09,100.61 114.19,100.71 114.33,100.71 114.42,100.61 114.42,99.54 114.52,99.44 114.66,99.44 114.76,99.54 114.76,100.94 114.86,101.04 115,101.04 115.09,100.95 115.09,99.51 115.2,99.41 115.58,99.41 115.67,99.32 115.67,99.15 115.58,99.06 v1(114.64,99.06)
  BOTTOM w0.149: R27.2 114.68,99.6 114.64,99.65 R26.1
DDR4_DIMM_CH1_RZQ: length 6.7
  BOTTOM w0.149: v1(96.73,76.93) 96.73,76.93 96.73,76.43 97.23,75.93 97.83,75.93 98.33,75.43 98.63,75.43 99.13,74.93 99.57,74.93 100.17,74.32 100.17,73.61 R48.2
DDR4_DIMM_CH1_SA0: length 0.6
  BOTTOM w0.149: R23.1 v1(188.59,100.14)
DDR4_DIMM_CH1_SA1:
  vias: v1(189.44,99.06)
DDR4_DIMM_CH1_SA2: length 2.7
  TOP w0.149: J2.238 150.34,103.24 150.5,103.08 v1(151.14,103.08)
  BOTTOM w0.149: R25.2 v1(151.14,103.08)
DDR4_DIMM_CH1_TDQS_N9: length 51.7
  L05_SIG2 w0.079: v1(95,80.93) 95,81.21 94.89,81.31 94.7,81.31 94.51,81.5 94.38,81.84 94.38,82.04 94.52,82.39 94.52,83.22 94.26,83.48 94.26,84.74 93.98,85.02 93.62,85.02 93.43,84.83 92.9,84.83 92.42,85.31 92.42,85.81 92.93,86.32 92.93,86.51 92.62,86.82 91.89,86.82 91.45,87.26 91.45,87.97 90.69,88.73 90.1,88.73 87.92,90.91 87.68,90.91 86.69,91.91 85.94,91.91 84.74,93.1 83.65,93.1 83.22,93.54 83.22,94.3 82.98,94.54 82.24,94.54 81.63,95.15 77.02,95.15 76.7,95.46 76.7,95.88 77.02,96.19 79.82,96.19 79.95,96.32 79.95,96.65 79.82,96.78 76.45,96.78 75.68,96.01 75.18,96.01 73.96,97.23 73.96,97.82 74.16,98.03 74.16,99.23 73.63,99.77 73.63,101.82 73.52,101.93 73.38,101.93 73.27,101.81 73.13,101.81 73.03,101.91 73.03,102.05 73.14,102.16 73.14,102.3 73,102.45 71.62,102.45 71.29,102.11 71.29,101.04 71.39,100.94 71.5,100.94 71.6,100.84 71.6,100.7 71.5,100.61 71.39,100.61 71.29,100.51 71.29,100.3 71.85,99.74 71.85,99.35 v1(72.14,99.06)
DDR4_DIMM_CH1_TDQS_N10: length 40.5
  L03_SIG1 w0.079: v4(95,78.93) 95.29,79.37 95.5,79.58 95.59,79.81 95.59,80.07 95.49,80.33 95.49,80.5 95.62,80.81 95.62,81.01 95.51,81.26 95.33,81.45 95.08,81.55 94.93,81.55 94.79,81.61 94.68,81.72 94.62,81.86 94.62,82.02 94.74,82.3 94.74,82.67 91.62,85.78 91.62,87.97 91.07,88.53 90.59,88.53 89.96,87.9 89.82,87.9 89.47,88.24 89.47,88.39 90.11,89.02 90.11,89.49 88.58,91.02 87.9,91.02 87.77,91.15 87.77,91.46 88.74,92.43 88.74,92.98 88.42,93.3 87.35,93.3 86.71,92.66 85.9,92.66 ; 85.26,94.55 86.8,94.55 87.13,94.89 87.13,95.42 86.8,95.75 84.17,95.75 83.75,95.33 83.75,94.46 83.59,94.3 83.26,94.3 83.11,94.46 83.11,96.2 82.3,97.02 81.31,97.02
  L03_SIG1 w0.081: 85.26,94.55 85.07,94.37 85.07,93.49 85.9,92.66 ; v4(81.49,99.06) 81.13,98.71 81.13,98.16 80.93,97.95 80.93,97.4 81.31,97.02
DDR4_DIMM_CH1_TDQS_N11: length 41.8
  L05_SIG2 w0.079: v1(90.84,99.06) 90.53,98.75 90.53,98.53 90.72,98.34 91.91,98.34 93.89,96.37 94.59,96.37 95.25,97.02 98.25,97.02 98.54,96.73 98.54,96.28 98.25,95.98 96.74,95.98 96.62,95.85 96.62,95.52 96.74,95.39 98.61,95.39 100.32,93.67 100.5,93.67 100.74,93.91 100.74,94.09 99.44,95.38 99.44,95.75 99.81,96.12 100.18,96.12 101.8,94.51 101.8,93.03 101.3,92.54 100.83,92.54 100.61,92.32 100.61,92 102.38,90.23 102.38,86.58 101.66,85.86 101.66,83.26 101.43,82.7 101.43,80.96 101.66,80.73 101.66,80.29 101.54,79.99 101.54,79.87 101.67,79.54 101.67,79.32 101.54,79 101.36,78.81 101.16,78.81 101.06,78.71 v1(101.06,78.43)
DDR4_DIMM_CH1_TDQS_N12: length 30.7
  L03_SIG1 w0.079: v4(101.06,81.43) 101.06,81.71 101.16,81.81 101.35,81.81 101.53,82 101.66,82.3 101.66,84.91 100.66,85.91 100.66,87.18 100.44,87.4 100.16,87.4 100,87.57 100,87.82 100.16,87.99 101.22,87.99 101.51,88.28 101.51,88.74 101.22,89.03 99.13,89.03 98.96,89.21 98.96,89.79 99.09,89.92 99.69,89.92 99.96,90.19 99.96,90.69 99.69,90.96 99.13,90.96 98.96,91.14 98.96,91.75 99.83,92.63 99.83,93.55 99.49,93.89 98.59,93.89 98.42,94.06 98.42,94.31 98.59,94.48 99.56,94.48 99.83,94.75 99.83,95.25 99.56,95.52 98.32,95.52 98.17,95.68 98.17,95.95 98.32,96.11 99.57,96.11 99.96,96.49 99.96,97.13 99.62,97.47 99.32,97.47 99.04,97.75 99.04,98.08 99.14,98.18 99.64,98.18 99.88,98.43 99.88,98.75 v4(100.19,99.06)
DDR4_DIMM_CH1_TDQS_N13: length 75.3
  L07_SIG3 w0.085: v1(155.44,99.06) 155.2,98.82 155.2,98.08 154.54,97.42 153.69,97.42 153.29,97.82 151.67,97.82 150.6,96.75 149.89,96.75 148.89,95.75 148.46,95.75 147.58,94.87 145.98,94.87 145.23,94.12 140.45,94.12 140.24,93.92 140.24,93.07 139.94,92.76 139.29,92.76 138.99,93.07 138.99,93.96 138.82,94.12 136.74,94.12 136.53,93.91 136.53,93.23 135.48,92.18 131.43,92.18 131.17,92.44 131.17,93.14 131.43,93.41 133.5,93.41 133.66,93.57 133.66,93.87 133.46,94.07 130.91,94.07 129.39,92.56 128.24,92.56 128.06,92.38 128.06,91.92 127.42,91.28 126.79,91.28 126.5,91.58 126.5,92.35 126.29,92.56 125.8,92.56 125.08,91.84 123.84,91.84 122.8,90.79 120.49,90.79 118.64,88.94 117.88,88.63 116.06,86.81 114.84,86.81 114.57,86.7 114.32,86.53 113.6,85.81 113.03,85.81 112.78,85.56 112.78,84.68 110.35,82.25 110.21,82.07 arc(109.96,81.87) 109.66,81.8 arc(109.54,81.77) 109.45,81.7 109.33,81.54 arc(109.12,81.37) 108.86,81.31 108.81,81.31 arc(108.69,81.29) 108.59,81.2 108.49,81.09 arc(108.23,80.88) 107.91,80.8 arc(107.83,80.78) 107.76,80.74 107.68,80.66 arc(107.62,80.58) 107.61,80.49 107.61,80.33 107.74,80.02 107.74,79.81 107.61,79.51 107.61,79.34 107.73,79.07 107.73,78.79 107.61,78.51 107.61,78.35 107.73,78.07 107.73,77.78 107.61,77.49 107.61,77.36 107.73,77.06 107.73,76.79 107.61,76.5 107.61,76.36 107.73,76.08 107.73,75.82 107.59,75.5 107.59,75.36 107.73,75.04 107.73,74.81 107.6,74.5 107.41,74.31 107.22,74.31 107.12,74.21 v1(107.12,73.93)
DDR4_DIMM_CH1_TDQS_N14: length 83.7
  L05_SIG2 w0.079: v1(107.12,75.93) 107.12,76.21 107.22,76.31 107.41,76.31 107.61,76.51 107.72,76.78 107.72,77.07 107.61,77.33 107.61,77.51 107.75,77.83 107.75,78.03 107.61,78.36 107.61,78.54 107.73,78.83 107.73,79.06 107.61,79.36 107.61,79.52 107.73,79.81 107.73,80.05 107.61,80.33 107.61,80.53 107.73,80.81 107.73,81.06 107.61,81.34 107.61,81.52 107.67,81.66 107.77,81.75 107.9,81.81 108.08,81.81 108.3,81.9 108.5,82.1 108.6,82.33 108.6,82.74 108.88,83.41 109.34,83.88 109.34,86.59 111.58,88.83 113.39,88.83 115.51,90.95 115.51,91.49 116.94,92.92 117.44,92.92 118.56,94.04 131.84,94.04 134.57,96.77 140.78,96.77 141.21,97.2 141.21,97.99 140.53,98.66 140.53,99.01 141.01,99.48 147.24,99.48 147.63,99.09 150.52,99.09 152.18,100.75 153.65,100.75 153.82,100.58 153.82,99.78 154.12,99.48 154.8,99.48 155.1,99.78 155.1,100.52 155.31,100.73 155.54,100.73 155.75,100.52 155.75,99.86 156.04,99.57 156.67,99.57 156.96,99.86 156.96,100.49 157.22,100.75 158.5,100.75 158.7,100.55 158.7,99.83 158.2,99.32 158.2,98.49 158.83,97.85 164.22,97.85 164.53,98.15 164.53,98.8 v1(164.79,99.06)
DDR4_DIMM_CH1_TDQS_N15: length 81.6
  L07_SIG3 w0.085: v1(174.14,99.06) 173.85,98.77 173.85,98.54 174.01,98.38 175.27,98.38 175.68,97.97 175.68,97.32 171.85,93.49 ; 161.5,93.8 158.51,90.81 154.64,90.81 153.25,89.42 149.57,89.42 147.88,88.72 143.97,84.81 142.21,84.81 141.22,83.83 123.11,83.83 122.09,82.81 121.66,82.81 121.23,82.37 120.89,82.37 120.67,82.16 120.56,82.01 arc(120.38,81.86) 120.15,81.81 120.07,81.81 arc(119.94,81.78) 119.84,81.7 119.69,81.51 arc(119.51,81.36) 119.28,81.31 119.21,81.31 arc(119.08,81.28) 118.98,81.2 118.83,81.01 arc(118.65,80.87) 118.42,80.81 118.33,80.81 arc(118.2,80.78) 118.1,80.7 117.95,80.51 arc(117.77,80.37) 117.55,80.31 117.47,80.31 arc(117.34,80.28) 117.24,80.2 117.09,80.01 arc(116.91,79.87) 116.68,79.81 116.6,79.81 arc(116.48,79.78) 116.38,79.7 116.23,79.51 arc(116.05,79.37) 115.82,79.31 115.73,79.31 arc(115.61,79.28) 115.51,79.2 115.36,79.01 arc(115.18,78.87) 114.95,78.81 114.87,78.81 arc(114.74,78.78) 114.64,78.7 114.49,78.51 arc(114.31,78.37) 114.09,78.31 114.03,78.31 arc(113.9,78.29) 113.79,78.21 113.73,78.16 arc(113.69,78.09) 113.67,78.01 113.67,77.88 arc(113.68,77.83) 113.69,77.79 113.75,77.64 arc(113.78,77.56) 113.78,77.47 113.78,77.31 113.67,77.02 113.47,76.83 113.28,76.83 113.18,76.73 v1(113.18,76.43)
  L07_SIG3 w0.089: 161.5,93.8 169.16,93.8 171.86,96.5 172.09,96.5 172.33,96.26 172.33,96.11 170.48,94.26 170.48,93.86 170.85,93.49 171.85,93.49
DDR4_DIMM_CH1_TDQS_N16: length 91.1
  L05_SIG2 w0.079: v1(183.49,99.06) 183.16,98.73 183.16,98.41 183.16,97.94 182.16,96.95 182.16,96.47 181.76,96.07 180.37,96.07 178.69,94.38 172.83,94.38 172.71,94.26 172.71,93.9 172.82,93.79 175.72,93.79 176.04,93.47 176.04,93.07 175.72,92.75 171.31,92.75 169.56,91 169.18,90.84 151.59,90.84 150.81,90.76 149.8,90.56 148.26,89.92 146.71,89.28 144.58,87.86 143.11,87.86 142.01,87.41 140.54,85.93 138.22,84.97 137.38,84.8 123.15,84.8 122.17,83.82 121.25,83.82 120.64,83.21 119.94,83.21 119.17,82.44 118.87,82.05 arc(118.64,81.87) 118.35,81.81 118.32,81.81 arc(118.2,81.78) 118.11,81.7 117.98,81.53 arc(117.77,81.36) 117.51,81.31 117.45,81.31 arc(117.33,81.28) 117.24,81.21 117.08,81 arc(116.9,80.86) 116.68,80.81 116.64,80.81 arc(116.51,80.78) 116.39,80.7 116.35,80.66 arc(116.29,80.56) 116.27,80.45 116.27,80.43 arc(116.27,80.34) 116.3,80.25 116.32,80.2 arc(116.37,80.06) 116.38,79.91 116.38,79.9 arc(116.34,79.7) 116.23,79.53 116.17,79.47 arc(115.99,79.35) 115.77,79.31 115.74,79.31 arc(115.63,79.29) 115.54,79.23 115.5,79.18 arc(115.43,79.08) 115.4,78.96 arc(115.42,78.84) 115.45,78.72 115.47,78.68 arc(115.51,78.55) 115.52,78.41 115.52,78.41 arc(115.48,78.2) 115.36,78.02 115.33,77.98 arc(115.14,77.86) 114.91,77.81 114.86,77.81 arc(114.74,77.78) 114.64,77.7 114.48,77.51 arc(114.3,77.36) 114.08,77.31 114.04,77.31 arc(113.9,77.29) 113.78,77.21 113.78,77.2 arc(113.7,77.09) 113.67,76.95 113.67,76.84 113.79,76.54 113.79,76.31 113.67,76.01 113.67,75.85 113.78,75.57 113.78,75.27 113.67,74.99 113.67,74.84 113.8,74.53 113.8,74.31 113.67,74 113.49,73.82 113.29,73.82 113.18,73.71 v1(113.18,73.43)
