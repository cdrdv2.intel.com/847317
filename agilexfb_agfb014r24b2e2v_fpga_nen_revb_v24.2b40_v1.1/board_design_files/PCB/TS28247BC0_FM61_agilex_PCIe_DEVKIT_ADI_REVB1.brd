# Allegro board TS28247BC0_FM61_agilex_PCIe_DEVKIT_ADI_REVB1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
IO_1P8V_PG: length 457.1
  TOP w0.127: v1(47.38,32.21) 48.7,32.21 49.46,32.97 71.58,32.97 75.04,36.43 75.04,37.67 75.52,38.15 75.52,39.53 75.07,39.98 v1(74.68,39.98)
  L03_SIG1 w0.127: v1(74.68,39.98) 74.3,39.6 74.3,38.69 74.68,38.31 74.68,37.54 74.43,37.29 73.07,37.29 72.52,37.29 72.37,37.14 67.29,37.14 67.06,37.37 67.06,38.73 v1(67.47,39.14)
  L07_SIG3 w0.127: v1(34.42,64.85) 34.93,64.34 34.93,63.75 36.11,62.56 38.05,62.56 40.28,60.34 40.28,60.33 40.3,60.31 40.3,56.15 41.48,54.97 42.83,54.97 47.25,50.55 47.25,43 48.01,42.24 48.01,32.84 v1(47.38,32.21)
  L12_SIG4 w0.127: v1(255.75,26.66) 256.33,26.66 256.95,27.28 256.95,33.76 257.23,34.04 257.23,35.19 256.28,36.15 256.28,36.63 258.17,38.52 258.17,44.1 256.28,45.99 256.28,46.72 258.07,48.51 258.07,55.88 259.09,56.9 259.09,66.88 258.4,67.57 258.4,77.99 262.67,82.26 262.67,99.36 258.75,103.28 246.91,103.28 244.05,106.14 220.64,106.14 219.65,107.13 216.84,107.13 213.4,103.69 212.78,103.69 211.51,104.96 209.99,104.96 208.29,106.66 206.1,106.66 204.71,108.05 198.32,108.05 195.74,105.48 191.35,105.48 189.67,107.17 152.41,107.17 151.21,108.36 133.92,108.36 132.07,106.51 131.01,106.51 129.49,104.98 129.49,104.9 129.26,104.67 128.01,104.67 127.21,105.46 126.37,105.46 125.07,106.76 124.01,106.76 123.27,107.5 103.26,107.5 101.56,105.79 97.87,105.79 95.99,107.67 90.88,107.67 89.94,108.61 76.46,108.61 75.41,107.56 73.53,107.56 72.14,106.17 71.29,105.82 68.38,105.82 67.7,106.5 58.68,106.5 56.65,104.47 56.29,104.47 55.63,103.81 55.63,103.2 55.25,102.82 54.92,102.82 53.35,101.25 53.35,100.97 52.33,99.95 49.16,99.95 34.5,85.3 34.5,83.34 32.39,81.23 31.63,81.23 31.28,80.88 31.28,76.82 30.11,75.64 30.11,73.48 27.82,71.2 27.82,66.12 28.58,65.36 33.92,65.36 v1(34.42,64.85)
  BOTTOM w0.127: R6071.1 71.7,38.95 71.7,38.66 72.02,38.34 72.02,36.65 72.78,35.89 74.18,35.89 74.81,36.53 74.81,38.5 75.13,38.81 75.13,39.53 v1(74.68,39.98)
IO_3P3V: length 52.6
  TOP w0.254: R99.2 v1(50.43,11.45) R98.2
  TOP w0.305: v1(205.37,104.85) 205.87,104.35 R809.2
  TOP w0.381: FB40.1 v1(206.64,100.6) v1(206.64,99.9) ; R244.2 v1(41.09,30.05)
  BOTTOM w0.203: 43.95,106.76 43.77,106.94 U15.A2 44.26,107.32 ; U21.8 16.39,49.3 ; 17.36,49.48 17.15,49.28 U21.1
  BOTTOM w0.229: U16.F5 v1(28.72,100.91) U16.E6 ; U16.J10 v1(30.22,99.4) U16.K9
  BOTTOM w0.254: R716.1 v1(71.95,103.08) ; 29.34,49.48 29.09,49.23 U20.1 ; U22.1 23.12,49.23 23.38,49.48 23.63,49.48 ; R243.2 v1(54.24,23.57) ; R103.2 v1(52.2,11.45) R102.2
  BOTTOM w0.305: R801.2 200.67,97.61 v1(200.29,97.23) ; v1(82.56,107.01) 82.18,106.63 R721.1 R719.1 79.57,104.03 79.19,103.65 v1(79.19,103.08) ; v1(74.68,106.38) 75.19,105.87 75.19,104.73 74.56,104.09 R717.1
  BOTTOM w0.381: 17.36,49.48 v1(18.74,49.48) ; v1(76.02,103.08) 75.62,102.68 U67.14 ; v1(83.64,103.08) 83.24,102.68 U68.14 ; v1(15.56,49.48) 16.21,49.48 16.39,49.3 ; v1(100.08,102.57) R20.1 100.72,103.46 v1(101.1,103.08) ; R832.1 C174.1 ; C174.1 81.03,21.67 80.99,21.71 U5.14 ; C174.1 v1(80.14,21.1) ; R705.2 v1(6.97,51.32) ; v1(30.68,49.48) 30.6,49.56 29.42,49.56 29.34,49.48 ; R707.2 v1(10.58,60.91) ; FB41.1 v1(205.24,106.7) ; R706.2 v1(6.08,51.32) ; R314.2 v1(268.23,42.62) ; R311.2 v1(268.23,39.96) ; R709.2 v1(15.07,51.32) ; 23.63,49.48 v1(24.71,49.48) ; C269.1 v1(27.76,92.98) ; R316.2 v1(268.23,44.15) ; U23.14 90.1,102.68 v1(90.49,103.08) ; R708.2 v1(15.96,51.32) ; R247.2 v1(42.36,28.53) ; U24.4 268.07,64.91 v1(269.5,64.91) ; R309.2 v1(268.23,38.31)
  BOTTOM w0.457: v1(42.62,22.75) FB21.1
  vias: v1(2.45,58.82) v1(2.67,68.09) v1(2.67,66.18) v1(2.67,63.39) v1(3.37,90.25) v1(3.37,89.36) v1(14.68,48.59) v1(14.68,46.81) v1(31.57,48.59) v1(31.57,47.7) v1(34.04,92.47) v1(36.27,82.16) v1(36.91,81.52) v1(36.96,93.55) v1(36.96,92.47) v1(40.52,98.88) v1(43.44,64.85) v1(43.5,63.71) v1(43.5,62.69) v1(43.92,69.67) v1(44.08,65.86) v1(44.08,41.16) v1(44.33,44.91) v1(45.02,74.12) v1(45.02,72.85) v1(45.02,71.07) v1(45.09,75.9) v1(45.22,66.75) v1(45.22,64.98) v1(45.22,51.13) v1(45.22,49.35) v1(45.22,48.08) v1(45.22,46.31) v1(45.22,41.99) v1(45.22,40.21) v1(45.41,63.71) v1(45.41,62.69) v1(45.49,39.17) v1(45.49,38.15) v1(45.6,106.89) v1(45.66,65.86) v1(45.66,50.24) v1(45.66,47.2) v1(45.66,41.1) v1(45.85,75.9) v1(46.11,74.12) v1(46.11,72.85) v1(46.11,71.07) v1(46.11,66.75) v1(46.11,64.98) v1(46.11,51.13) v1(46.11,49.35) v1(46.11,48.08) v1(46.11,46.31) v1(46.11,41.99) v1(46.11,40.21) v1(46.74,106.89) v1(53.73,11.45) v1(55.63,11.45) v1(160.92,16.33) v1(160.92,15.45) v1(161.81,16.33) v1(161.81,15.45) v1(162.69,16.33) v1(162.69,15.45) v1(177.05,16.59) v1(177.05,15.7) v1(177.93,16.59) v1(177.93,15.7) v1(178.82,16.59) v1(178.82,15.7) v1(203.72,97.63) v1(264.42,64.02) v1(267.85,45.23) v1(267.85,35.7) v2(36.2,67.26) v2(36.2,66.5) v2(37.22,67.26) v2(37.22,66.5) v2(38.23,67.26) v2(38.23,66.5) v2(39.76,67.26) v2(39.76,66.5) v2(40.52,67.26) v2(40.52,66.5) v2(41.79,67.26) v2(41.79,66.5) v2(56.14,92.92) v2(56.14,91.77) v2(57.28,91.77)
IO_3P3V_EN: length 317.3
  L12_SIG4 w0.127: v1(31.06,68.02) 33.18,70.15 33.18,71.42 33.92,72.15 33.92,77.22 36.52,79.82 37.52,79.82 40.9,83.2 40.9,84.09 43.51,86.69 45.52,86.69 47.76,88.93 47.76,91.06 53.68,96.98 60.97,96.98 66.17,102.19 71.62,102.19 72.4,102.96 72.4,103 72.87,103.47 83.81,103.47 85.07,102.21 94.27,102.21 95.07,101.41 95.47,101.41 95.65,101.59 96.49,101.59 97.27,100.81 102.81,100.81 104.2,102.2 105.08,102.2 105.8,101.47 116.01,101.47 116.84,100.65 127.84,100.65 128.12,100.93 129.26,100.93 129.85,101.52 131.95,101.52 133.31,102.87 133.31,103.44 134.43,104.56 146.5,104.56 149.51,101.55 193.79,101.55 196.36,98.99 199.17,98.99 200.9,97.26 200.9,95.33 202.34,93.88 211.67,93.88 213.76,91.79 227.5,91.79 229.8,89.49 229.8,82.1 227.89,80.19 225.85,80.19 225.33,79.67 225.33,68.65 229.55,64.43 229.55,61.8 233.04,58.31 233.04,52.06 231.3,50.32 231.3,46.81 233.69,44.43 234.68,44.43 235.52,43.59 235.52,42.6 240.02,38.1 240.02,30.6 246.08,24.54 246.08,20.22 246.64,19.66 248.38,19.66 v1(249.18,20.46)
IREF: length 11.9
  TOP w0.149: U47.48 U47.47 199.54,65.64 200.05,66.14 v1(200.73,66.14) 200.74,66.13 U47.44 201.34,64.96 201.56,64.75 201.56,64.25 U47.43 202.37,64.24 202.93,63.68 202.93,62.99 202.57,62.64 202.57,60.76 202.05,60.24 U47.33
  BOTTOM w0.149: v1(200.73,66.14) 200.27,66.14 R6105.1
ISENSE0: length 47.7
  TOP w0.149: U76.33 189.02,85.39 189.28,85.13 189.28,84.87 189.47,84.68 190.08,84.68 v1(190.46,84.31) ; v1(194.99,63.8) 195.39,63.8 195.41,63.78 195.53,63.78 196.28,63.04 U47.4
  L16_SIG6 w0.081: v1(194.99,63.8) 196.17,63.8 197.57,65.2 197.57,69.95 196.37,71.15 193.73,71.15 191.5,73.38 191.5,75.11 190.27,76.33 184.81,76.33 183.78,77.37 183.78,86.18 184.87,87.28 187.23,87.28 188.98,85.53 189.02,85.53 189.28,85.27 189.28,84.96 189.5,84.74 190.02,84.74 v1(190.46,84.31)
ISENSE2: length 15.3
  TOP w0.149: v1(195,64.69) 195.06,64.69 196.32,63.44 U47.3 ; U78.33 189.37,57.2 v1(189.54,57.03)
  L07_SIG3 w0.089: v1(189.54,57.03) 191.32,57.03 196.2,61.9 196.2,63.5 v1(195,64.69)
ISENSE3: length 33.8
  TOP w0.149: U47.52 197.54,65.41 197.29,65.66 196.77,65.66 R5934.2 196.36,66.69 v1(196.12,66.93) ; v1(189.16,41) 189.14,41.02 U79.33
  L07_SIG3 w0.089: v1(189.16,41) 189.16,43.5 191.09,45.43 191.09,55.81 195.18,59.9 196.12,59.9 197.19,60.96 197.19,65.46 196.12,66.53 v1(196.12,66.93)
ISENSE4: length 25.7
  TOP w0.149: U77.33 189.04,72.74 v1(189.62,72.16) ; U47.51 197.94,65.55 198.06,65.67 v1(198.06,66.14)
  L16_SIG6 w0.081: v1(198.06,66.14) 198.33,66.41 198.83,66.41 199.17,66.07 199.17,64.72 197.9,63.45 197.39,63.45 197.13,63.19 194.47,63.19 194.31,63.35 194.31,64.56 194.9,65.15 195.49,65.15 195.76,64.87 196.07,64.87 196.3,65.1 196.3,65.81 196.53,66.04 196.53,67.19 191.85,71.86 189.92,71.86 v1(189.62,72.16)
ITH0: length 3.3
  TOP w0.149: C1822.2 194.36,62.05 194.52,62.05 195.46,61.12 196.07,61.12 196.15,61.04 U47.9
ITHR0: length 2.4
  TOP w0.149: U47.10 196.11,60.64 195.96,60.8 195.12,60.8 194.62,61.29 v1(194.62,61.34)
JTAG_INPUT_SOURCE: length 35.6
  L03_SIG1 w0.081: v1(2.8,43.2) 13.07,32.93 13.07,31.62 14.83,29.86 18.51,29.86 18.75,30.1 19.98,30.1 20.43,29.65 22.18,29.65 23.25,28.58 25.07,28.58 25.63,28.02 26.99,28.02 27.23,27.78 27.23,27.22 v4(27.63,26.82)
  BOTTOM w0.149: v1(2.8,43.2) 4.69,45.09 SW4.1
LINK_LED: length 16
  L16_SIG6 w0.508: J8.17 5.94,100.54 12.6,100.54 15.13,98.01 v1(16.26,98.01)
LOGIC0A: length 0.2
  BOTTOM w0.305: R208.2 v1(44.84,81.61)
LOGIC0B: length 0.3
  BOTTOM w0.305: R209.2 v1(44.2,80.72)
LOGIC1:
  vias: v1(43.57,81.61)
LT4625_INTVCC: length 12.4
  L07_SIG3 w0.381: v1(242.65,51.37) 242.65,51.89 242.7,51.95 242.7,55.12 v1(242.78,55.2) 246.51,55.2 v1(247.15,54.56)
  BOTTOM w0.254: R434.2 243.32,50.13 243.65,49.8 R431.2 ; R436.2 v1(242.78,55.2)
  BOTTOM w0.381: R434.2 242.65,50.61 v1(242.65,51.37) ; C443.2 247.47,54.88 v1(247.15,54.56)
LTM3888_ALERTN: length 65.3
  TOP w0.149: TP17.1 212.33,24.72 211.74,24.13 v1(211.74,22.46) ; U47.17 196.73,57.83 v1(196.73,56.92)
  L07_SIG3 w0.089: v1(196.73,56.92) 196.73,57 196.41,57.32 194.89,57.32 194.62,57.05 194.62,56.14 192.79,54.31 192.79,48.47 193.99,47.27 193.99,37.42 194.77,36.63 198.66,36.63 199.3,35.99 210.65,35.99 215.07,31.57 215.07,28.07 214.66,27.66 214.66,25.53 214.03,24.89 214.03,23.42 213.06,22.46 v1(211.74,22.46)
  BOTTOM w0.149: R516.2 R876.2 212.24,22.62 212.07,22.46 v1(211.74,22.46)
LTM3888_SCL: length 60.4
  TOP w0.149: U47.15 196.31,58.64 195.84,58.17 195.84,57.54 v1(195.26,56.95)
  L07_SIG3 w0.089: v1(195.26,56.95) 194.99,56.68 194.99,56.15 193.03,54.19 193.03,48.58 194.24,47.37 194.24,37.5 194.87,36.87 198.76,36.87 199.36,36.27 210.73,36.27 215.36,31.64 215.36,28.01 214.97,27.61 214.97,25.48 214.33,24.84 214.33,20.51 v1(214.89,19.95)
  BOTTOM w0.149: R515.2 v1(214.89,19.95)
LTM3888_SDA: length 57.7
  TOP w0.149: U47.16 196.34,58.24 196.15,58.04 v1(196.15,56.52)
  L07_SIG3 w0.089: v1(196.15,56.52) 195.84,56.21 195.4,56.21 193.31,54.12 193.31,48.66 194.49,47.48 194.49,37.59 194.98,37.11 198.86,37.11 199.46,36.52 210.83,36.52 215.6,31.74 215.6,27.87 215.32,27.58 215.32,26.78 215.77,26.32 215.77,24 215.4,23.62 215.4,23.13 v1(214.83,22.56)
  BOTTOM w0.149: R875.2 R514.2 v1(214.83,22.56)
LTM4623_INTVCC0: length 1.5
  BOTTOM w0.149: v1(211.82,59.49) 211.75,59.55 R6096.1 C1900.2
LTM4623_INTVCC1: length 1.6
  TOP w0.149: R6093.1 210.67,70.91 C1975.2 210.33,70.88 v1(210.04,70.59)
LTM4668_INTVCC0: length 12.5
  L03_SIG1 w0.081: v1(71.47,39.94) 71.84,39.56 71.84,38.71 v1(71.47,38.34)
  L16_SIG6 w0.081: v1(71.47,39.94) 71.09,40.31 69.44,40.31 v1(69.07,39.94) ; v1(71.47,38.34) 71.09,38.71 67.04,38.71 v1(66.67,38.34)
  BOTTOM w0.149: v1(71.47,39.94) 71.75,40.22 73.36,40.22 R6072.2
LTM4668_INTVCC1: length 8.1
  TOP w0.102: 52.76,55.48 52.76,55.48 53.11,55.48
  TOP w0.149: v1(52.13,55.1) 52.51,55.48 52.76,55.48 ; v1(54.53,56.67) 54.37,56.67 53.66,55.96 R6065.2 53.64,55.86 53.27,55.48 53.11,55.48
  L05_SIG2 w0.081: v1(54.53,56.67) 56.13,55.07 v1(56.93,55.07) ; v1(52.13,55.1) 51.75,55.48 51.75,56.28 v1(52.13,56.67)
LTM4686_3P3V_PG: length 43.8
  TOP w0.149: D25.1 228.76,45.27 v1(228.86,45.16)
  L16_SIG6 w0.081: v1(228.86,45.16) 229.23,45.16 230.01,44.39 235.13,44.39 235.53,44.79 244.67,44.79 245.63,43.84 245.63,42.65 247.39,40.88 247.39,37.94 248.17,37.16 248.17,35.43 248.39,35.2 248.43,35.2 248.98,34.65 248.98,33.71 249.89,32.79 250.15,32.79 252.13,30.81 252.13,28.91 252.41,28.63 252.71,28.63 252.97,28.37 252.97,28.1 253.19,27.87 254.28,27.87 254.54,28.12 254.54,28.37 254.85,28.68 257.72,28.68 v1(258.15,28.26)
LTM_PMBUS_ALERTN: length 359.9
  L12_SIG4 w0.089: v1(220.28,75.53) 220.28,74.96 221.57,73.66 221.57,73.46 221.81,73.22 221.81,65.98 222.28,65.51 224.67,65.51 226.65,63.53 226.83,63.53 227.16,63.19 227.16,58.98 226.27,58.09 226.27,52.76 v1(226.6,52.43) 226.6,47.73 227.59,46.74 230.92,46.74 233.51,44.15 234.55,44.15 235.24,43.46 235.24,42.47 239.35,38.36 v1(239.35,37.42)
  L14_SIG5 w0.081: v1(50.17,13.19) 58.5,13.19 61.22,10.47 61.22,10.39 61.73,9.88 62.54,9.88 65.06,7.37 127.08,7.37 129.72,10.01 133.79,10.01 138.61,14.84 157.46,14.84 157.79,14.51 167.19,14.51 167.9,13.79 170.24,13.79 171.33,14.89 190.13,14.89 191.19,13.82 193.35,13.82 194.04,14.51 196.48,14.51 196.6,14.38 211.03,14.38 211.92,13.49 215.07,13.49 216.08,14.51 244.18,14.51 245.73,16.06 245.73,30.88 244.56,32.06 v1(244.18,32.06)
  L16_SIG6 w0.081: v1(244.18,32.06) 243.11,32.06 239.35,35.82 v1(239.35,37.42)
  BOTTOM w0.149: R5974.2 227.63,52.87 227.18,52.43 v1(226.6,52.43) ; v1(244.18,32.06) 244.58,32.06 245.02,31.62 245.02,25.81 246.26,24.56 246.26,20.42 247.5,19.18 251.67,19.18 252.74,18.11 257.54,18.11 261.35,21.92 261.35,23.37 261.02,23.7 259.11,23.7 258.56,24.26 v1(258.15,24.26) ; v1(50.17,13.19) 47.71,13.19 44.23,16.67 44.2,16.67 42.98,17.89 40.24,17.89 38.62,16.26 36.18,16.26 35.47,15.55 25.15,15.55 23.91,16.79 23.91,21.49 25.38,22.96 25.38,25.48 25.97,26.06 26.14,26.06 27.57,27.49 27.57,27.56 28.43,28.42 v1(28.43,28.42)
LTM_SCL: length 137.7
  TOP w0.149: J17.1 236.48,88.27 236.94,87.81 R6274.2
  L07_SIG3 w0.089: v1(241.41,31.83) 236.53,36.71 227.55,36.71 v1(222.47,41.79) 221.41,42.85 219.92,42.85 218.73,44.05 218.73,45.16 219.26,45.7 224.75,45.7 226.52,47.48 226.52,50.6 227.18,51.26 227.87,51.26 228.35,51.74 v1(228.35,51.77) 228.35,51.84 227.9,52.3 227.9,53.16 229.42,54.69 232.93,54.69 233.84,55.6 233.84,57.18 232.22,58.8 221.3,58.8 220.23,59.86 220.23,64.12 220.43,64.31 220.43,66.47 219.85,67.05 218.04,67.05 217.63,67.46 217.63,71.66 217.79,71.81 217.79,72.65 217.51,72.93 217.51,74.17 v1(218.38,75.04) 218.95,75.62 219.62,75.62 220.2,75.03 220.2,73.92 220.78,73.33 221.16,73.33 221.81,73.98 221.81,79.13 222.17,79.48 224.85,79.48 226.04,80.67 226.04,82.8 226.43,83.18 229.16,83.18 229.58,83.6 229.58,84.66 233.11,88.19 235.31,88.19 J17.1
  BOTTOM w0.149: v1(241.41,31.83) 241.71,32.13 241.71,33.68 242.58,34.55 244.41,34.55 245.83,33.12 245.83,30.33 246.36,29.8 246.36,25.63 246.89,25.1 248.77,25.1 248.86,25.01 R470.2
LTM_SDA: length 135
  TOP w0.149: R6275.2 235.39,87.54 234.88,88.05 234.57,88.05 233.94,88.68 J17.2
  L07_SIG3 w0.089: v1(242.5,31.91) 242.05,31.45 241.25,31.45 240.75,31.96 240.75,32.15 236.43,36.46 227.45,36.46 223.27,40.64 v1(222.47,40.64) 222.03,41.09 222.03,41.89 221.3,42.61 219.82,42.61 218.49,43.95 218.49,45.26 219.16,45.94 224.65,45.94 226.28,47.58 226.28,50.97 v1(227.08,51.77) 227.64,52.33 227.64,54.28 228.43,55.07 232.57,55.07 232.77,55.27 232.77,56.9 231.12,58.55 221.19,58.55 219.99,59.75 219.99,64.22 220.17,64.4 220.17,66.39 219.75,66.81 217.88,66.81 217.35,67.34 217.35,71.43 217,71.78 217,72.65 217.23,72.88 217.23,74.5 218.65,75.92 220.56,75.92 220.76,75.72 220.76,75.47 220.5,75.21 220.5,74.19 v1(220.92,73.77) 221.52,74.38 221.52,79.17 222.08,79.73 224.75,79.73 225.79,80.78 225.79,82.89 226.33,83.42 229.06,83.42 229.34,83.7 229.34,84.76 J17.2
  BOTTOM w0.149: v1(242.5,31.91) 243.39,32.79 244.76,32.79 245.42,32.13 245.42,25.99 246.56,24.84 246.56,24.29 246.74,24.11 249.51,24.11 249.7,24.3 R471.2
MAIN_I2C_SCL: length 506.9
  TOP w0.149: v1(246.23,61.88) 245.83,62.28 245.83,63.22 246.49,63.89 U73.6 ; U32.20 v1(71.01,86.43)
  TOP w0.159: U17.16 43.82,22.24 v1(43.44,21.86)
  L03_SIG1 w0.081: v1(208.86,106.76) 206.42,109.2 197.72,109.2 194.06,105.54 147.4,105.54 143.97,108.97 130.91,108.97 129.8,110.07 127.25,110.07 125.86,108.69 101.88,108.69 100.5,110.07 97.94,110.07 96.55,108.69 91.47,108.69 v1(89.16,106.38)
  L05_SIG2 w0.081: v1(89.16,106.38) 88.6,106.94 84.26,106.94 83.93,106.61 75.83,106.61 75.24,107.19 72.69,107.19 71.92,106.42 71.26,106.14 69.92,106.14 69.48,106.57 67.03,106.57 63.48,103.03 63.48,93.09 66.38,90.2 67.24,90.2 v1(71.01,86.43) ; v1(239.47,87.84) 231.4,87.84 229.06,90.17 217.38,90.17 216.77,90.78 216.77,93.53 217.3,94.06 217.3,100.94 216.52,101.72 216.52,101.73 216.11,102.14 216.11,102.9 215.37,103.63 215.37,103.86 213.87,105.36 211.13,105.36 209.73,106.76 v1(208.86,106.76) ; v1(249.35,25.86) 249.77,26.27 249.77,30.03 253.35,33.61 257.21,33.61 258.02,34.42 258.02,34.42 259.57,35.97 261.17,35.97 261.47,35.66 263.61,35.66 264.47,36.53 264.47,37.65 263.3,38.81 247.96,38.81 246.03,40.74 246.03,50.22 247.71,51.89 247.71,58.09 246.23,59.57 v1(246.23,61.88)
  L12_SIG4 w0.089: v1(34.83,21.22) 34.83,20.96 35.23,20.56 35.23,20.27 34.99,20.02 34.68,20.02 34.43,19.77 34.43,18.25 32.26,16.08 24.52,16.08 22.74,17.86 20.96,17.86 19.69,19.13 19.69,36.53 18.55,37.67 18.55,42.12 15.12,45.54 15.12,47.26 v1(15.56,47.7) 16.2,47.07 21.6,47.07 22.74,48.21 25.22,48.21 v1(25.6,48.59) 26.04,49.04 27.88,49.04 29.34,50.5 31,50.5 32.65,52.15 32.65,54.82 33.03,55.2 37.09,55.2 43.14,61.24 45.55,61.24 47.89,63.58 47.89,65.74 49.79,67.64 49.79,68.4 50.81,69.42 50.81,72.72 58.3,80.22 62.33,80.22 68.54,86.43 v1(71.01,86.43) ; v1(249.35,25.86) 248.5,26.71 248.5,29.29 247.66,30.13 247.66,31.79 247.37,32.08 246.6,32.08 246.19,32.48 246.19,34.81 247.33,35.95 248.65,35.95 249.03,36.32 249.03,41.15 249.31,41.43 249.31,45.27 253.11,49.07 253.11,58.28 245.93,65.46 245.93,75.89 241.19,80.63 241.19,84.37 239.47,86.1 v1(239.47,87.84)
  L16_SIG6 w0.081: v1(43.44,21.86) 43.03,21.45 42.09,21.45 41.88,21.67 40.93,21.67 40.47,21.21 37.93,21.21 37.52,21.63 35.23,21.63 v1(34.83,21.22)
  BOTTOM w0.149: v1(15.56,47.7) R287.1 U21.7 ; v1(89.16,106.38) 88.72,105.93 88.72,104.79 89.03,104.47 R304.2
MAIN_I2C_SDA: length 453
  TOP w0.149: U73.5 247.87,63.24 248.8,62.31 v1(254.64,62.31) ; v1(71.01,87.32) 71.4,86.93 U32.19
  TOP w0.159: U17.18 45.53,21.09 45.09,20.65 v1(43.44,20.65)
  L03_SIG1 w0.081: v1(208.86,107.65) 206.98,109.53 197.57,109.53 194.14,106.1 147.99,106.1 144.61,109.48 130.97,109.48 130.03,110.42 126.99,110.42 125.89,109.32 102.34,109.32 101.22,110.45 97.5,110.45 96.37,109.32 91.22,109.32 v1(88.27,106.38)
  L05_SIG2 w0.081: v1(208.86,107.65) 211.08,107.65 213.13,105.6 213.97,105.6 215.61,103.96 215.61,103.73 216.11,103.23 216.11,103.23 216.34,103 216.34,102.24 216.83,101.75 216.83,101.74 217.54,101.03 217.54,91.19 218.27,90.45 238.12,90.45 v1(239.47,89.11) ; v1(88.27,106.38) 87.3,106.38 86.74,105.81 76.13,105.81 75.14,106.8 72.91,106.8 72.24,106.13 71.46,105.81 69.66,105.81 69.29,106.18 67.25,106.18 64.01,102.94 64.01,93.51 66.68,90.83 67.49,90.83 v1(71.01,87.32)
  L12_SIG4 w0.089: v1(250.15,23.46) 250.15,25.02 250.52,25.4 250.52,30.01 248.22,32.32 246.99,32.32 246.74,32.57 246.74,34.32 247.38,34.95 249.51,34.95 250.1,35.54 250.1,37.73 251.16,38.79 251.16,45.54 253.6,47.98 253.6,56.14 254.64,57.18 v1(254.64,62.31) 250.76,62.31 246.18,66.89 246.18,75.98 241.43,80.73 241.43,84.47 239.88,86.02 239.88,88.69 v1(239.47,89.11) ; v1(36.43,22.82) 36.04,22.43 35.49,22.43 35.23,22.17 35.23,21.84 35.01,21.62 34.68,21.62 34.43,21.37 34.43,20.28 34.18,20.02 33.9,20.02 33.63,19.76 33.63,18.59 32.14,17.1 24.63,17.1 23.49,18.24 21.22,18.24 20.45,19 20.45,24.21 20.84,24.59 20.84,28.4 20.33,28.91 20.33,36.65 19.57,37.42 19.57,41.93 v1(15.56,45.93) 16.33,46.69 24.58,46.69 v1(25.6,47.7) 26.04,48.15 27.63,48.15 29.6,50.12 31.38,50.12 35.57,54.31 38.07,54.31 40.98,57.21 40.98,58.32 43.52,60.86 45.68,60.86 48.39,63.58 48.39,65.48 50.3,67.39 50.3,68.28 51.31,69.29 51.31,72.6 58.55,79.83 62.59,79.83 68.75,85.99 71.29,85.99 71.51,86.21 71.51,86.82 v1(71.01,87.32)
  L16_SIG6 w0.081: v1(43.44,20.65) 43.87,21.08 43.87,22.13 43.7,22.3 36.96,22.3 36.44,22.82 v1(36.43,22.82)
  BOTTOM w0.149: U21.6 16.26,47.75 16.26,47.42 15.65,46.81 R286.1 v1(15.56,45.93) ; v1(88.27,106.38) 87.87,105.97 87.87,104.05 R305.2
MAIN_PMBUS_EN: length 60.7
  L03_SIG1 w0.127: v1(17.15,47.45) 18.93,45.67 25.92,45.67 27.95,43.64 27.95,33.23 30.59,30.58 30.59,29.94 30.83,29.7 31.15,29.7 31.39,29.46 31.39,29.06 31.23,28.9 31.23,28.02 v4(30.83,27.62)
  L05_SIG2 w0.127: v1(2.67,65.29) 8.6,65.29 14.08,59.82 14.08,58.76 17.63,55.21 17.63,47.93 v1(17.15,47.45)
  BOTTOM w0.149: U21.5 v1(17.15,47.45)
  BOTTOM w0.254: SW3.3 2.94,65.03 v1(2.67,65.29)
MAX10_AGND: length 0.7
  BOTTOM w0.381: v1(261.35,32.26) v1(260.67,32.26) R387.1
  vias: v1(251.59,36.46) v1(251.59,34.56) v1(253.63,34.56) v1(253.7,36.48) v1(255.66,36.46) v1(255.66,34.56) v1(255.75,31.46) v1(257.64,34.56) v1(257.69,36.46) v1(259.72,36.46) v1(259.72,34.56)
MAX_SDA: length 13.1
  L03_SIG1 w0.081: v1(19.18,19.51) 20.35,20.68 22.97,20.68 25.28,18.37 27.73,18.37 28.03,18.66 28.03,20.82 v4(28.43,21.22)
MDI_HPS_N0: length 9.8
  L16_SIG6 w0.079: v1(26.17,92.42) 25.9,92.15 25.9,91.91 25.67,91.68 24.01,91.68 23.74,91.95 22.77,91.95 22.07,92.65 20.78,92.65 20.67,92.55 J8.10
  BOTTOM w0.102: U7.3 26.42,90.49 26.28,90.62 26.28,91.02 25.9,91.4 25.9,92.15 v1(26.17,92.42)
MDI_HPS_N1: length 14.7
  L16_SIG6 w0.079: v1(28.05,91.78) 27.78,92.05 27.78,92.29 27.55,92.52 27.16,92.52 26.68,92.05 26.68,91.46 26.23,91.01 22.66,91.01 22.13,90.48 20.35,90.48 18.96,91.87 18.24,91.87 18.13,91.97 J8.5
  BOTTOM w0.102: v1(28.05,91.78) 27.78,91.52 27.78,90.62 27.92,90.49 U7.6
MDI_HPS_N2: length 14.3
  L16_SIG6 w0.079: v1(29.05,91.02) 28.78,90.75 28.78,90.52 28.02,89.75 26.41,89.75 26.27,89.61 23.47,89.61 23.12,89.26 20.62,89.26 18.94,87.57 18.24,87.57 18.13,87.47 J8.2
  BOTTOM w0.102: v1(29.05,91.02) 28.78,90.75 28.78,90.63 28.92,90.49 U7.8
MDI_HPS_N3: length 16.5
  L16_SIG6 w0.079: v1(30.87,91.65) 30.6,91.91 30.6,92.15 30.37,92.39 29.88,92.39 29.5,92 29.5,90.4 28.04,88.94 26.34,88.94 25.92,88.52 23.2,88.52 21.47,86.79 20.78,86.79 20.67,86.89 J8.9
  BOTTOM w0.102: U7.11 30.42,90.49 30.28,90.62 30.28,90.81 30.6,91.13 30.6,91.38 v1(30.87,91.65)
MDI_HPS_P0: length 9.7
  L16_SIG6 w0.079: J8.11 20.67,92.98 20.78,92.88 22.16,92.88 22.87,92.18 23.83,92.18 24.11,91.91 24.57,91.91 24.67,92 24.67,92.11 24.77,92.2 24.91,92.2 25,92.11 25,92 25.1,91.91 25.57,91.91 25.67,92.01 25.67,92.15 v1(25.41,92.42)
  BOTTOM w0.102: U7.2 25.92,90.49 26.05,90.62 26.05,90.93 25.67,91.31 25.67,92.15 v1(25.41,92.42)
MDI_HPS_P1: length 14.7
  L16_SIG6 w0.079: v1(27.29,91.78) 27.55,92.05 27.55,92.19 27.45,92.3 27.25,92.3 26.91,91.95 26.91,91.37 26.32,90.78 26.16,90.78 26.06,90.68 26.06,90.58 25.96,90.48 25.82,90.48 25.73,90.58 25.73,90.68 25.63,90.78 22.76,90.78 22.23,90.25 20.26,90.25 18.87,91.64 18.24,91.64 18.13,91.54 J8.4
  BOTTOM w0.102: v1(27.29,91.78) 27.55,91.52 27.55,90.62 27.42,90.49 U7.5
MDI_HPS_P2: length 14.4
  L16_SIG6 w0.079: J8.3 18.13,87.9 18.24,87.8 18.85,87.8 20.53,89.49 23.02,89.49 23.38,89.84 26.18,89.84 26.31,89.98 27.92,89.98 28.04,90.09 28.04,90.23 27.95,90.32 27.95,90.45 28.05,90.55 28.18,90.55 28.27,90.47 28.41,90.47 28.55,90.61 28.55,90.75 v1(28.29,91.02)
  BOTTOM w0.102: U7.7 28.42,90.49 28.55,90.62 28.55,90.76 v1(28.29,91.02)
MDI_HPS_P3: length 16.5
  L16_SIG6 w0.079: J8.8 20.67,86.46 20.78,86.56 21.56,86.56 23.3,88.29 26.02,88.29 26.44,88.71 28.13,88.71 29.73,90.3 29.73,90.73 29.82,90.82 29.93,90.82 30.03,90.92 30.03,91.06 29.93,91.16 29.82,91.16 29.73,91.25 29.73,91.9 29.98,92.16 30.27,92.16 30.37,92.06 30.37,91.91 v1(30.11,91.65)
  BOTTOM w0.102: v1(30.11,91.65) 30.37,91.38 30.37,91.22 30.05,90.9 30.05,90.62 29.92,90.49 U7.10
MICTOR_BYPASSN: length 39.3
  L03_SIG1 w0.081: v4(27.63,27.62) 27.63,27.86 27.23,28.26 27.23,28.66 25.07,30.82 21.71,30.82 21.31,30.42 20.59,30.42 20.19,30.82 14.91,30.82 14.59,31.14 14.59,31.38 14.06,31.91 14.06,33.02 3.37,43.7 2.61,43.7 1.91,44.4 1.91,46.12 v1(2.8,47.01)
  BOTTOM w0.149: v1(2.8,47.01) 3.42,47.63 SW4.3
MICTOR_JTAG_TCK: length 67.6
  TOP w0.149: J12.15 49.28,89.11 49.41,89.23 49.6,89.23 v1(50.05,89.68)
  L05_SIG2 w0.081: v1(95.86,71.43) 96.27,71.43 97.19,72.34 97.19,74.2 96.95,74.43 96.7,74.43 96.36,74.77 96.36,75.48 95.25,76.59 93.85,76.59 93.14,77.3 93.14,77.5 92.89,77.75 92.89,78.46 92.54,78.81 92.18,78.81 91.68,79.3 91.64,79.3 91.04,79.89 91.04,80.58 90.82,80.8 90.46,80.8 89.96,81.3 86.36,81.3 83.54,80.14 79.44,80.14 76.52,83.06 70.31,83.06 64.13,89.24 58.78,89.24 58.66,89.13 58.66,88.42 58.55,88.31 58.39,88.31 58.28,88.42 58.28,89.13 58.16,89.24 58,89.24 57.89,89.13 57.89,88.42 57.78,88.31 57.62,88.31 57.5,88.42 57.5,89.13 57.39,89.24 57.23,89.24 57.12,89.13 57.12,88.42 57,88.31 56.84,88.31 56.73,88.42 56.73,89.13 56.62,89.24 53.95,89.24 53.04,90.14 50.51,90.14 v1(50.05,89.68)
  BOTTOM w0.149: v1(50.05,89.68) 50.05,89.57 50.93,88.68 R217.2
MICTOR_JTAG_TDI: length 58.3
  TOP w0.149: J12.19 48.01,89.01 48.27,89.26 v1(48.27,89.68)
  L03_SIG1 w0.081: v1(48.27,89.68) 48.76,90.17 50.15,90.17 50.53,89.79 50.78,89.79 51.48,89.1 52.78,89.1 54.19,90.5 55.48,90.5 55.63,90.35 55.63,90.05 55.43,89.85 54.61,89.85 53.73,88.96 53.73,88.52 53.93,88.32 55.16,88.32 55.82,88.98 62.21,88.98 62.31,88.89 62.31,88.75 62.21,88.65 61.09,88.65 60.99,88.55 60.99,88.41 61.09,88.31 64.04,88.31 69.35,83.01 77.33,83.01 79.87,80.47 88.01,80.47 88.8,79.68 89.46,79.68 89.6,79.54 90.55,79.54 v4(90.67,79.43)
  BOTTOM w0.149: R214.2 v1(48.27,89.68)
MICTOR_JTAG_TDO: length 65.6
  TOP w0.149: v1(51.82,89.68) R197.2 50.55,89.3 J12.11
  L05_SIG2 w0.081: v1(95.86,72.43) 96.33,72.9 96.33,74.48 95.94,74.87 95.74,74.87 95.39,75.22 95.39,75.56 94.57,76.38 93.7,76.38 92.93,77.16 92.93,77.42 92.55,77.8 92.49,77.8 91.74,78.55 91.29,78.55 90.91,78.93 90.91,79.26 90.47,79.71 90.47,80.09 90.01,80.55 89.61,80.55 89.38,80.77 85.96,80.77 83.53,79.77 79.35,79.77 76.44,82.68 70.06,82.68 65.03,87.71 60.54,87.71 60.43,87.82 60.43,88.6 60.31,88.71 60.15,88.71 60.04,88.6 60.04,87.82 59.93,87.71 59.77,87.71 59.65,87.82 59.65,88.6 59.54,88.71 59.38,88.71 59.27,88.6 59.27,87.82 59.16,87.71 56.12,87.71 56.02,87.81 56.02,88.81 55.92,88.91 55.78,88.91 55.69,88.81 55.69,87.81 55.59,87.71 55.45,87.71 55.35,87.81 55.35,88.81 55.25,88.91 55.11,88.91 55.02,88.81 55.02,87.81 54.92,87.71 53.79,87.71 v1(51.82,89.68)
  BOTTOM w0.149: R197.2 v1(51.82,89.68)
MICTOR_JTAG_TMS: length 56.4
  TOP w0.149: J12.17 48.65,89.17 v1(49.16,89.68)
  L03_SIG1 w0.081: v4(90.67,78.43) 90.67,78.71 90.05,79.33 88.53,79.33 87.76,80.09 79.73,80.09 77.44,82.37 69.22,82.37 63.61,87.99 60.42,87.99 60.32,88.09 60.32,88.56 60.22,88.66 58.41,88.66 58.31,88.56 58.31,88.42 58.41,88.32 59.7,88.32 59.8,88.23 59.8,88.09 59.7,87.99 56.6,87.99 56.51,88.09 56.51,88.23 56.6,88.32 57.61,88.32 57.71,88.42 57.71,88.56 57.61,88.66 56.21,88.66 56.12,88.56 56.12,88.09 56.02,87.99 53.65,87.99 53.4,88.24 51.72,88.24 50.78,89.19 49.64,89.19 v1(49.16,89.68)
  BOTTOM w0.149: R216.2 v1(49.16,89.68)
MICTOR_JTAG_TRSTN: length 3.5
  TOP w0.149: v1(46.49,89.68) 46.81,89.36 47.12,89.36 47.38,89.11 J12.21
  BOTTOM w0.149: R213.1 47.38,89.11 47.12,89.36 46.81,89.36 v1(46.49,89.68)
MICTOR_PWR1: length 1.1
  TOP w0.149: J12.12 v1(50.55,80.14)
MICTOR_SRSTN: length 104.2
  TOP w0.149: v1(52.71,89.68) 52.27,89.23 51.57,89.23 51.19,88.85 J12.9
  L03_SIG1 w0.081: v1(40.9,37.92) 40.9,38.05 38.62,40.34 38.62,47.73 37.68,48.67 36.56,48.67 32.95,52.28 32.95,55.91 32.19,56.67 32.19,61.41 32.79,62 32.79,70.4 33.2,70.82 33.2,76.33 36.58,79.71 37.85,79.71 38.49,80.34 38.49,82.37 37.98,82.88 37.98,92.08 39.69,93.79 51.49,93.79 52.32,92.96 52.32,90.07 v1(52.71,89.68)
  L12_SIG4 w0.089: v1(40.9,37.92) 40.27,37.29 40.27,32.84 37.6,30.18 37.6,29.03 37.42,28.86 37.12,28.86 36.83,28.57 36.83,28.27 36.58,28.02 34.63,28.02 34.43,27.82 34.43,25.08 34.18,24.82 33.87,24.82 33.63,24.58 33.63,24.28 32.83,23.48 32.83,22.69 32.43,22.29 v1(32.43,22.02)
MODE/SYNC: length 7.4
  L16_SIG6 w0.081: v1(74.73,39.27) 73.24,39.27 71.91,37.95 69.45,37.95 v1(69.07,38.34)
  BOTTOM w0.149: R6072.1 74.01,38.8 74.25,39.04 74.51,39.04 v1(74.73,39.27)
MODE/SYNC1: length 1.7
  TOP w0.149: R6066.2 55.33,55.86 R6065.1 54.53,55.84 v1(54.53,55.07)
MSEL1: length 88.9
  L07_SIG3 w0.089: v1(214.13,26.05) 213.56,25.48 212.61,25.48 210.88,27.21 207.96,27.21 207.65,26.9 207.65,26.16 205.95,24.46 193.17,24.46 192.41,25.22 186.37,25.22 175.8,35.79 171.36,35.79 169.98,37.16 168.66,37.16 164.7,41.13 163.67,41.13 163.32,41.48 158.73,41.48 154.29,45.93 145.99,45.93 143.1,43.03 142.38,43.03 142.1,43.3 141.4,43.3 141.03,42.93 v1(140.03,42.93)
  BOTTOM w0.149: SW1.2 214.14,26.31 214.13,26.3 v1(214.13,26.05)
MSEL2: length 88.2
  L07_SIG3 w0.089: v1(212.86,26.05) 211.32,27.59 207.86,27.59 207.4,27.13 207.4,26.37 205.87,24.84 193.38,24.84 192.67,25.56 188.32,25.56 186.9,26.98 186.21,26.98 181.39,31.8 181.39,32.69 180.51,33.57 179.72,33.57 176.86,36.43 176.27,36.43 175.65,37.06 170.8,37.06 170.31,37.54 168.79,37.54 164.78,41.56 163.8,41.56 163.36,41.99 159.24,41.99 154.31,46.92 146.32,46.92 143.22,43.81 142.4,43.81 142.14,43.55 141.43,43.55 141.05,43.93 v1(140.03,43.93)
  BOTTOM w0.149: SW1.3 212.87,26.31 212.86,26.3 v1(212.86,26.05)
Net_307:
  vias: v1(129.64,47.93)
Net_308:
  vias: v1(132.23,47.43)
Net_331:
  vias: v1(103.66,44.93)
Net_1683:
  vias: v1(141.76,49.93)
Net_1684:
  vias: v1(141.76,48.93)
Net_1685:
  vias: v1(136.56,52.93)
Net_1686:
  vias: v1(134.83,51.93)
Net_1687:
  vias: v1(134.83,52.93)
Net_1688:
  vias: v1(137.43,51.43)
Net_1689:
  vias: v1(140.89,47.43)
Net_1690:
  vias: v1(92.4,45.43)
Net_1691:
  vias: v1(93.26,44.93)
Net_1692:
  vias: v1(93.26,43.93)
Net_1693:
  vias: v1(94.13,45.43)
Net_1694:
  vias: v1(94.13,44.43)
Net_1695:
  vias: v1(95,44.93)
Net_1696:
  vias: v1(107.99,42.43)
Net_1697:
  vias: v1(107.99,41.43)
Net_1698:
  vias: v1(107.12,42.93)
Net_1699:
  vias: v1(110.58,44.93)
Net_1700:
  vias: v1(110.58,43.93)
Net_1701:
  vias: v1(112.32,44.93)
Net_1702:
  vias: v1(112.32,43.93)
Net_1703:
  vias: v1(113.18,45.43)
Net_1704:
  vias: v1(113.18,44.43)
Net_1705:
  vias: v1(114.05,44.93)
Net_1706:
  vias: v1(114.05,43.93)
Net_1707:
  vias: v1(104.52,44.43)
Net_1708:
  vias: v1(105.39,43.93)
Net_1709:
  vias: v1(106.25,44.43)
Net_1710:
  vias: v1(107.12,44.93)
Net_1711:
  vias: v1(107.12,43.93)
Net_1712:
  vias: v1(107.99,45.43)
Net_1713:
  vias: v1(107.99,44.43)
Net_1714:
  vias: v1(103.66,42.93)
Net_1715:
  vias: v1(103.66,41.93)
Net_1716:
  vias: v1(104.52,42.43)
Net_1717:
  vias: v1(104.52,41.43)
Net_1718:
  vias: v1(105.39,42.93)
Net_1719:
  vias: v1(105.39,41.93)
Net_1720:
  vias: v1(111.45,45.43)
Net_1721:
  vias: v1(111.45,44.43)
Net_1722:
  vias: v1(106.25,42.43)
Net_1723:
  vias: v1(106.25,41.43)
Net_1724:
  vias: v1(107.12,41.93)
Net_1725:
  vias: v1(125.31,50.43)
Net_1726:
  vias: v1(124.44,49.93)
Net_1727:
  vias: v1(124.44,48.93)
Net_1728:
  vias: v1(123.57,50.43)
Net_1729:
  vias: v1(123.57,49.43)
Net_1730:
  vias: v1(122.71,49.93)
Net_1731:
  vias: v1(132.23,50.43)
Net_1732:
  vias: v1(132.23,49.43)
Net_1733:
  vias: v1(133.97,47.43)
Net_1734:
  vias: v1(133.97,46.43)
Net_1735:
  vias: v1(138.29,47.93)
Net_1736:
  vias: v1(138.29,46.93)
Net_1737:
  vias: v1(137.43,47.43)
Net_1738:
  vias: v1(137.43,46.43)
Net_1739:
  vias: v1(136.56,47.93)
Net_1740:
  vias: v1(136.56,46.93)
Net_1741:
  vias: v1(134.83,47.93)
Net_1742:
  vias: v1(131.37,49.93)
Net_1743:
  vias: v1(131.37,48.93)
Net_1745:
  vias: v1(129.64,48.93)
Net_1747:
  vias: v1(128.77,49.43)
Net_1749:
  vias: v1(127.9,48.93)
Net_1750:
  vias: v1(132.23,46.43)
Net_1751:
  vias: v1(131.37,47.93)
Net_1752:
  vias: v1(131.37,46.93)
Net_1753:
  vias: v1(130.5,47.43)
Net_1754:
  vias: v1(130.5,46.43)
Net_1755:
  vias: v1(129.64,46.93)
Net_1757:
  vias: v1(130.5,49.43)
Net_1758:
  vias: v1(135.7,47.43)
Net_1759:
  vias: v1(135.7,46.43)
Net_1760:
  vias: v1(134.83,46.93)
Net_1761:
  vias: v1(109.72,81.43)
Net_1762:
  vias: v1(108.85,80.93)
Net_1763:
  vias: v1(112.32,78.93)
Net_1764:
  vias: v1(112.32,79.93)
Net_1765:
  vias: v1(114.05,79.93)
Net_1766:
  vias: v1(114.05,81.93)
Net_1767:
  vias: v1(107.99,78.43)
Net_1768:
  vias: v1(107.99,79.43)
Net_1769:
  vias: v1(108.85,78.93)
Net_1770:
  vias: v1(109.72,79.43)
Net_1771:
  vias: v1(113.18,78.43)
Net_1772:
  vias: v1(107.99,82.43)
Net_1773:
  vias: v1(127.04,73.43)
Net_1774:
  vias: v1(126.17,73.93)
Net_1775:
  vias: v1(126.17,74.93)
Net_1776:
  vias: v1(125.31,73.43)
Net_1777:
  vias: v1(125.31,74.43)
Net_1779:
  vias: v1(133.97,73.43)
Net_1780:
  vias: v1(133.97,74.43)
Net_1781:
  vias: v1(135.7,76.43)
Net_1782:
  vias: v1(135.7,77.43)
Net_1783:
  vias: v1(140.03,75.93)
Net_1784:
  vias: v1(140.03,76.93)
Net_1785:
  vias: v1(139.16,76.43)
Net_1786:
  vias: v1(139.16,77.43)
Net_1787:
  vias: v1(138.29,75.93)
Net_1788:
  vias: v1(138.29,76.93)
Net_1789:
  vias: v1(136.56,75.93)
Net_1790:
  vias: v1(133.1,73.93)
Net_1791:
  vias: v1(133.1,74.93)
Net_1792:
  vias: v1(131.37,73.93)
Net_1793:
  vias: v1(131.37,74.93)
Net_1794:
  vias: v1(130.5,73.43)
Net_1795:
  vias: v1(130.5,74.43)
Net_1796:
  vias: v1(129.64,73.93)
Net_1797:
  vias: v1(129.64,74.93)
Net_1798:
  vias: v1(133.97,76.43)
Net_1799:
  vias: v1(133.97,77.43)
Net_1800:
  vias: v1(133.1,75.93)
Net_1801:
  vias: v1(133.1,76.93)
Net_1802:
  vias: v1(132.23,76.43)
Net_1803:
  vias: v1(132.23,77.43)
Net_1804:
  vias: v1(131.37,75.93)
Net_1805:
  vias: v1(131.37,76.93)
Net_1806:
  vias: v1(130.5,76.43)
Net_1807:
  vias: v1(130.5,77.43)
Net_1808:
  vias: v1(129.64,75.93)
Net_1809:
  vias: v1(129.64,76.93)
Net_1810:
  vias: v1(132.23,73.43)
Net_1811:
  vias: v1(132.23,74.43)
Net_1812:
  vias: v1(137.43,76.43)
Net_1813:
  vias: v1(137.43,77.43)
Net_1814:
  vias: v1(136.56,76.93)
Net_1815:
  vias: v1(105.39,68.93)
Net_1817:
  vias: v1(91.53,69.93)
Net_1818:
  vias: v1(89.8,78.93)
Net_1819:
  vias: v1(91.53,76.93)
Net_1820:
  vias: v1(99.32,71.43)
Net_1821:
  vias: v1(91.53,78.93)
Net_1822:
  vias: v1(95,70.93)
Net_1826:
  vias: v1(104.52,53.43)
Net_1828:
  vias: v1(141.76,52.93)
Net_1829:
  vias: v1(127.04,70.43)
Net_1830:
  vias: v1(105.39,52.93)
Net_1831:
  vias: v1(105.39,69.93)
Net_1832:
  vias: v1(128.77,68.43)
Net_1833:
  vias: v1(132.23,56.43)
Net_1834:
  vias: v1(131.37,57.93)
Net_1835:
  vias: v1(131.37,56.93)
Net_1836:
  vias: v1(130.5,57.43)
Net_1837:
  vias: v1(127.04,57.43)
Net_1841:
  vias: v1(133.1,53.93)
Net_1842:
  vias: v1(132.23,54.43)
Net_1843:
  vias: v1(133.1,54.93)
Net_1844:
  vias: v1(128.77,57.43)
Net_1845:
  vias: v1(132.23,55.43)
Net_1847:
  vias: v1(134.83,53.93)
Net_1849:
  vias: v1(127.04,56.43)
Net_1850:
  vias: v1(133.97,54.43)
Net_1851:
  vias: v1(136.56,53.93)
Net_1852:
  vias: v1(134.83,54.93)
Net_1854:
  vias: v1(127.9,53.93)
Net_1855:
  vias: v1(127.9,56.93)
Net_1858:
  vias: v1(130.5,54.43)
Net_1860:
  vias: v1(129.64,54.93)
Net_1861:
  vias: v1(132.23,57.43)
Net_1862:
  vias: v1(141.76,51.93)
Net_1863:
  vias: v1(127.9,70.93)
Net_1864:
  vias: v1(142.63,73.43)
Net_1865:
  vias: v1(142.63,79.43)
Net_1866:
  vias: v1(141.76,46.93)
Net_1867:
  vias: v1(89.8,46.93)
Net_1868:
  vias: v1(141.76,47.93)
Net_1869:
  vias: v1(89.8,47.93)
Net_1870:
  vias: v1(89.8,48.93)
Net_1871:
  vias: v1(89.8,49.93)
Net_1872:
  vias: v1(95.86,51.43)
Net_1873:
  vias: v1(132.23,51.43)
Net_1874:
  vias: v1(107.99,51.43)
Net_1875:
  vias: v1(141.76,73.93)
Net_1876:
  vias: v1(106.25,51.43)
Net_1877:
  vias: v1(90.67,51.43)
Net_1878:
  vias: v1(104.52,51.43)
Net_1879:
  vias: v1(102.79,51.43)
Net_1880:
  vias: v1(101.06,51.43)
Net_1881:
  vias: v1(95,51.93)
Net_1883:
  vias: v1(107.12,51.93)
Net_1884:
  vias: v1(105.39,51.93)
Net_1885:
  vias: v1(103.66,51.93)
Net_1887:
  vias: v1(101.92,51.93)
Net_1888:
  vias: v1(100.19,51.93)
Net_1889:
  vias: v1(89.8,51.93)
Net_1890:
  vias: v1(137.43,52.43)
Net_1891:
  vias: v1(132.23,52.43)
Net_1892:
  vias: v1(104.52,52.43)
Net_1893:
  vias: v1(102.79,52.43)
Net_1894:
  vias: v1(101.06,52.43)
Net_1895:
  vias: v1(138.29,52.93)
Net_1896:
  vias: v1(107.12,52.93)
Net_1897:
  vias: v1(141.76,74.93)
Net_1898:
  vias: v1(103.66,52.93)
Net_1899:
  vias: v1(101.92,52.93)
Net_1900:
  vias: v1(105.39,53.93)
Net_1901:
  vias: v1(103.66,53.93)
Net_1902:
  vias: v1(101.92,53.93)
Net_1903:
  vias: v1(100.19,53.93)
Net_1904:
  vias: v1(140.89,54.43)
Net_1905:
  vias: v1(102.79,54.43)
Net_1906:
  vias: v1(101.06,54.43)
Net_1907:
  vias: v1(140.03,54.93)
Net_1908:
  vias: v1(141.76,75.93)
Net_1909:
  vias: v1(126.17,70.93)
Net_1910:
  vias: v1(103.66,70.93)
Net_1911:
  vias: v1(101.92,70.93)
Net_1912:
  vias: v1(142.63,71.43)
Net_1913:
  vias: v1(137.43,71.43)
Net_1914:
  vias: v1(128.77,71.43)
Net_1915:
  vias: v1(127.04,71.43)
Net_1916:
  vias: v1(125.31,71.43)
Net_1918:
  vias: v1(102.79,71.43)
Net_1919:
  vias: v1(142.63,76.43)
Net_1920:
  vias: v1(101.06,71.43)
Net_1921:
  vias: v1(141.76,71.93)
Net_1922:
  vias: v1(136.56,71.93)
Net_1923:
  vias: v1(129.64,71.93)
Net_1924:
  vias: v1(127.9,71.93)
Net_1925:
  vias: v1(126.17,71.93)
Net_1928:
  vias: v1(101.92,71.93)
Net_1929:
  vias: v1(100.19,71.93)
Net_1930:
  vias: v1(141.76,76.93)
Net_1931:
  vias: v1(98.46,71.93)
Net_1932:
  vias: v1(142.63,72.43)
Net_1934:
  vias: v1(133.97,72.43)
Net_1935:
  vias: v1(130.5,72.43)
Net_1936:
  vias: v1(128.77,72.43)
Net_1937:
  vias: v1(127.04,72.43)
Net_1938:
  vias: v1(125.31,72.43)
Net_1941:
  vias: v1(142.63,77.43)
Net_1942:
  vias: v1(102.79,72.43)
Net_1944:
  vias: v1(99.32,72.43)
Net_1945:
  vias: v1(97.59,72.43)
Net_1950:
  vias: v1(32.43,21.22)
Net_1999:
  vias: v1(256.55,22.66)
OVERTEMPN: length 320.3
  TOP w0.149: v1(74.05,89.36) 73.54,88.86 U32.16
  L03_SIG1 w0.081: v1(74.05,89.36) 73.29,90.12 73.29,91.65 73.54,91.9 73.54,92.79 73.03,93.3 73.03,96.6 72.52,97.11 72.52,101.93 75.32,104.73 75.32,106 v1(76.97,107.65)
  L07_SIG3 w0.089: v1(251.75,24.26) 255.1,20.91 255.66,20.91 256.27,20.3 261.12,20.3 263.91,23.09 263.91,29.92 270.52,36.53 270.52,40.5 v1(271.24,41.23)
  L12_SIG4 w0.089: v1(251.75,24.26) 252.94,25.45 252.94,33.7 252.24,34.4 252.24,37 251.47,37.77 251.47,44.58 253.85,46.97 253.85,47.53 255.27,48.95 255.27,63.67 246.42,72.53 246.42,76.08 243.62,78.88 243.1,79.39 243.1,80.27 241.69,81.69 241.69,84.56 240.29,85.95 240.29,88.95 239.17,90.07 238.18,90.07 236.61,91.65 236.61,103.51 234.6,105.51 220.15,105.51 216.57,101.93 214.28,101.93 213.9,101.55 212.3,101.55 210.4,103.46 207.78,103.46 207.32,103.91 206.28,103.91 205.85,104.35 203.23,104.35 201.99,105.59 196.62,105.59 195.2,104.17 191.9,104.17 189.47,106.61 150.98,106.61 149.89,107.7 134.27,107.7 132.34,105.78 131.05,105.78 130.36,105.09 130.36,104.25 130.07,103.96 126.67,103.96 125.18,105.44 123.86,105.44 123.04,106.26 111.39,106.26 110.73,105.59 103.46,105.59 102.5,104.63 97.34,104.63 94.96,107.01 90.33,107.01 90.27,107.06 89.94,107.06 89,108 77.32,108 v1(76.97,107.65)
PCIE_1V2_CLKREQN: length 34.9
  BOTTOM w0.149: U5.5 83.57,28.57 R833.2 91.26,30.11 94.77,33.63 94.77,36.63 98.18,40.03 98.18,40.97 98.89,41.68 98.89,43.64 99.14,43.89 99.5,43.89 100.03,44.43 100.31,44.43 100.77,44.88 101.2,44.88 101.73,45.42 102.06,45.42 102.57,45.93 102.9,45.93 103.41,46.43 103.87,46.43 104.38,45.93 104.78,45.93 105.28,45.43 v1(106.25,45.43)
PCIE_CLKREQN: length 37.5
  TOP w0.149: J7.B12 58.83,3.73 58.83,10.2 v1(59.19,10.56)
  L03_SIG1 w0.081: v1(83.59,21.1) 82.74,20.25 73.58,20.25 72.77,19.44 71.19,19.44 70.11,18.37 67,18.37 v1(59.19,10.56)
  BOTTOM w0.149: v1(83.59,21.1) U5.10
PCIE_EP_3P3V:
  vias: v1(52.33,8.33) v1(52.33,7.44) v1(53.09,8.33) v1(53.09,7.44) v2(52.97,6.43)
PCIE_EP_3V3_I2C_SCL: length 80.7
  TOP w0.149: J7.B5 49.66,9.85 49.92,10.11 v1(49.92,10.56)
  L07_SIG3 w0.089: v1(29.23,28.42) 29.23,28.16 28.83,27.76 28.83,27.44 29.05,27.22 29.45,27.22 29.63,27.05 29.63,23.44 29.84,23.22 31.82,23.22 32.01,23.04 32.01,22.66 32.25,22.42 32.58,22.42 32.83,22.17 32.83,17.86 33.87,16.82 36.17,16.82 37.26,17.91 37.88,17.91 38.56,18.6 42.32,18.6 49.92,11 v1(49.92,10.56)
  L16_SIG6 w0.081: v1(81.64,22.15) 79.26,22.15 78.44,21.33 74.3,21.33 73.63,20.65 71.04,20.65 69.85,19.47 69.85,19.23 69.38,18.76 67.92,18.76 67.48,19.2 65.99,19.2 59.57,12.78 54.13,12.78 52.18,10.83 52.18,10.49 51.52,9.84 50.64,9.84 v1(49.92,10.56)
PCIE_EP_3V3_I2C_SDA: length 81.8
  TOP w0.149: v1(50.93,10.56) 50.93,8.97 50.66,8.7 J7.B6
  L07_SIG3 w0.089: v1(50.93,10.56) 50.49,10.11 49.67,10.11 49.26,10.53 49.26,11.03 42.05,18.23 38.67,18.23 38.02,17.58 37.49,17.58 36.34,16.42 33.79,16.42 32.03,18.18 32.03,22.16 31.76,22.42 29.05,22.42 28.83,22.64 28.83,26.96 28.43,27.36 v1(28.43,27.62)
  L16_SIG6 w0.081: v1(50.93,10.56) 50.93,11 54.33,14.39 60.61,14.39 65.75,19.53 67.72,19.53 68.16,19.09 69.09,19.09 69.34,19.35 69.34,19.62 69.07,19.89 69.07,20.32 69.42,20.67 70.22,20.67 71.88,22.32 78.07,22.32 78.53,22.78 v1(82.29,22.78)
PCIE_EP_3V3_WAKEN: length 33.1
  L16_SIG6 w0.081: v1(54.74,11.45) 54.74,11.94 55.21,12.4 60.47,12.4 66.73,18.66 67.55,18.66 67.82,18.39 69.75,18.39 70.38,19.02 70.6,19.02 71.09,19.51 77.61,19.51 79.77,21.67 82.46,21.67 v1(82.94,22.15)
PCIE_EP_12V: length 27.9
  L12_SIG4 w0.508: v1(243.12,84.22) 243.52,84.61 244.61,84.61 245.14,84.08 245.14,82.04 243.96,80.86 243.96,79.75 246.77,76.94 254.39,76.94 255,76.33 255,75.03 v2(255.79,74.25)
  BOTTOM w0.203: U40.2 263.76,79.81 264.17,79.4 264.17,78.26 263.2,77.29 v2(261.75,77.29)
  BOTTOM w0.381: R412.1 v1(243.12,84.22)
  vias: v1(262.77,72.41) v2(46.49,8.08) v2(46.49,7.44) v2(46.49,6.81) v2(46.49,6.17) v2(47.12,8.08) v2(47.12,7.44) v2(47.12,6.81) v2(47.12,6.17) v2(47.76,8.08) v2(47.76,7.44) v2(47.76,6.81) v2(47.76,6.17) v2(255.79,75.77) v2(255.79,72.72) v2(257.69,76.53) v2(257.69,75.01) v2(259.21,76.53) v2(259.21,75.01) v2(260.36,77.29) v2(260.36,75.77) v2(260.36,74.25) v2(260.36,72.72) v2(261.75,75.77) v2(261.75,74.25) v2(261.75,72.72) v3(262.52,73.36)
PCIE_EP_I2C_SCL: length 51.4
  L12_SIG4 w0.089: v1(105.39,44.93) 104.26,44.93 103.77,45.42 103.51,45.42 103,45.93 102.58,45.93 102.2,46.3 101.68,46.3 101.43,46.05 100.64,46.05 100.39,46.3 99.9,46.3 99.65,46.05 99.02,46.05 98.77,46.3 98.19,46.3 97.94,46.05 97.26,46.05 97.01,46.3 96.39,46.3 96.14,46.05 95.51,46.05 95.26,46.3 94.71,46.3 94.43,46.02 94.15,46.02 93.55,45.43 93.13,45.43 92.66,44.95 92.31,44.95 91.93,45.33 91.33,45.33 90.84,44.84 90.45,44.84 89.97,44.36 89.6,44.36 88.65,43.41 79.55,43.41 77.4,41.26 77.4,36.56 78.51,35.45 78.51,32.21 79.75,30.98 79.75,30.16 81.35,28.56 v1(81.64,28.56)
  BOTTOM w0.149: v1(105.39,44.93) 104.94,44.49 104.94,40.74 R81.1
PCIE_EP_I2C_SDA: length 49.2
  L12_SIG4 w0.089: v1(103.66,43.93) 103.66,44.21 102.88,44.98 102.52,44.98 102.01,45.49 101.63,45.49 101.32,45.8 100.69,45.8 100.34,45.46 99.91,45.46 99.56,45.8 99.07,45.8 98.72,45.46 98.2,45.46 97.85,45.8 97.37,45.8 96.89,45.33 96.5,45.33 96.02,45.8 95.6,45.8 95.12,45.33 94.74,45.33 94.23,44.82 93.95,44.82 93.52,44.4 93.06,44.4 92.68,44.02 92.23,44.02 91.93,44.32 91.35,44.32 90.85,43.83 90.42,43.83 89.98,43.39 89.61,43.39 89.16,42.94 79.83,42.94 77.89,41 77.89,36.98 79.37,35.49 79.37,32.22 80.14,31.45 80.14,30.47 81.05,29.56 82.06,29.56 v1(82.29,29.79)
  BOTTOM w0.149: v1(103.66,43.93) 104.1,43.49 104.1,41.65 103.66,41.21 R82.1 ; U5.3 v1(82.29,29.79)
PCIE_EP_JTAG_TCK: length 62.5
  L03_SIG1 w0.081: v1(49.16,8.05) 49.16,9.6 48.01,10.75 48.01,11.7 44.53,15.19 43.86,15.19 43.23,15.82 43.23,16.68 41.92,17.99 39.5,17.99 39.12,17.6 39.12,16.31 39.02,16.21 38.59,16.21 38.49,16.31 38.49,18.35 38.6,18.46 41.5,18.46 41.61,18.58 41.61,18.74 41.5,18.85 40.19,18.85 40.03,19 40.03,19.98 40.15,20.1 41.42,20.1 41.54,20.21 41.54,20.37 41.42,20.48 40.15,20.48 40.03,20.6 40.03,20.76 40.15,20.87 40.83,20.87 40.95,20.98 40.95,21.14 40.83,21.25 40.15,21.25 40.03,21.37 40.03,21.53 40.15,21.64 40.83,21.64 40.95,21.75 40.95,21.91 40.83,22.03 40.15,22.03 40.03,22.14 40.03,22.3 40.15,22.41 40.83,22.41 40.95,22.53 40.95,22.69 40.83,22.8 40.07,22.8 39.96,22.91 39.96,23.07 40.07,23.18 40.83,23.18 40.95,23.3 40.95,23.46 40.83,23.57 39.74,23.57 39.63,23.67 39.63,23.85 39.74,23.95 41.05,23.95 41.16,24.06 41.16,24.36 41.05,24.46 39.74,24.46 39.63,24.58 39.63,24.74 39.74,24.85 40.91,24.85 41.03,24.96 41.03,25.12 40.91,25.24 38.66,25.24 37.47,26.42 33.63,26.42 v1(33.23,26.82)
  L12_SIG4 w0.089: v1(33.23,26.82) 32.83,27.22 32.83,28.91 33.23,29.31 v1(33.61,29.31)
  BOTTOM w0.149: v1(33.61,29.31) 34.51,29.31 R358.1 ; v1(49.16,8.05) 49.66,7.55 J7.A5
PCIE_EP_JTAG_TDI: length 55.2
  L16_SIG6 w0.081: v1(32.43,28.42) 32.02,28.02 26.6,28.02 26.43,27.85 26.43,18.69 26.78,18.34 37.45,18.34 37.83,18.72 37.83,19.58 38.26,20.02 38.88,20.02 39.25,20.38 42.25,20.38 44.19,18.45 44.19,17.5 50,11.69 50,11.26 50.41,10.84 50.41,10.53 50.77,10.17 51.31,10.17 v1(51.7,10.56)
  BOTTOM w0.149: v1(51.7,10.56) 50.43,9.29 50.43,3.79 J7.A6
PCIE_EP_JTAG_TDO: length 54.7
  L03_SIG1 w0.081: v1(51.19,8.33) 48.65,10.87 48.65,11.99 45.05,15.58 44.43,15.58 43.7,16.31 43.7,16.95 42.04,18.61 42.04,21.09 41.66,21.46 41.66,26.31 41.55,26.42 41.39,26.42 41.28,26.31 41.28,25.85 41.16,25.73 41,25.73 40.89,25.85 40.89,27.6 40.78,27.71 40.62,27.71 40.5,27.6 40.5,25.77 40.39,25.66 40.23,25.66 40.12,25.77 40.12,27.52 40,27.64 39.84,27.64 39.73,27.52 39.73,25.82 39.62,25.71 39.46,25.71 39.35,25.82 39.35,27.21 38.92,27.64 38.92,28.37 38.82,28.48 38.62,28.48 38.51,28.37 38.51,27.31 38.41,27.21 38.13,27.21 38.03,27.31 38.03,30.08 37.93,30.18 37.73,30.18 37.62,30.08 37.62,27.38 37.47,27.22 33.09,27.22 32.83,26.96 32.83,26.42 v4(32.43,26.02)
  BOTTOM w0.149: J7.A7 51.66,5.7 50.93,6.43 50.93,8.08 v1(51.19,8.33)
PCIE_EP_JTAG_TMS: length 63.2
  L16_SIG6 w0.081: v1(34.83,28.42) 34.42,28.83 29.5,28.83 29.22,29.11 26.02,29.11 25.43,28.53 25.43,19 26.63,17.81 26.63,17.48 27.06,17.05 33.23,17.05 34.17,17.99 37.8,17.99 39.07,19.26 39.07,19.69 39.44,20.06 42.03,20.06 43.79,18.3 43.79,17.43 44.28,16.94 44.28,16.74 49.43,11.59 49.43,10.5 50.47,9.46 51.61,9.46 v1(52.71,10.56)
  BOTTOM w0.149: J7.A8 52.66,5.35 52.12,5.89 52.12,6.51 51.7,6.94 51.7,9.54 v1(52.71,10.56)
PCIE_EP_PERSTN: length 409.9
  TOP w0.149: v1(253.35,29.85) U30.H4
  L03_SIG1 w0.081: v1(35.63,23.62) 36.03,23.22 37.47,23.22 38.83,21.86 38.83,19.34 37.98,18.49 37.98,15.58 40.01,13.55 42,13.55 43.17,14.72 44.33,14.72 47.25,11.79 47.25,10.65 48.62,9.28 48.62,8.05 49.11,7.57 51.19,7.57 51.82,8.21 51.82,8.46 53.92,10.56 v1(55.63,10.56)
  L07_SIG3 w0.089: v1(36.84,54.69) 38.97,52.56 38.97,50.09 39.58,49.48 39.58,45.39 40.39,44.59 40.39,39.86 40.88,39.37 40.88,39.02 41.31,38.59 41.31,37.76 41.88,37.19 41.88,36.6 41.29,36.01 41.29,32.27 41.55,32.01 41.55,30.88 41.15,30.48 40.7,30.48 40.22,29.99 40.22,29.39 38.93,28.11 38.93,27.84 39.31,27.46 39.31,26.26 38.67,25.62 38.19,25.62 37.39,24.82 36.27,24.82 36.03,24.58 36.03,24.02 v1(35.63,23.62)
  L16_SIG6 w0.081: v1(253.35,29.85) 253.12,30.08 253.12,36.98 253.56,37.42 257.06,37.42 258.33,38.69 258.33,45.98 260.64,48.29 260.64,55.73 259.32,57.05 259.32,61.19 252.15,68.35 252.15,76.55 240.44,88.27 233.28,88.27 232.62,88.93 232.62,89.87 231.75,90.73 216.35,90.73 215.46,89.85 199.76,89.85 198.03,88.13 195.98,88.13 193.2,90.91 182.47,90.91 174.55,98.84 174.55,99.23 172.91,100.87 158.55,100.87 157.51,99.83 157.51,98.78 157.41,98.68 150.63,98.68 150.32,98.99 149.09,98.99 148.73,99.34 144.97,99.34 144.49,99.82 143.75,99.82 143.03,100.54 140.19,100.54 138.97,99.32 138.41,99.32 137.78,98.68 137.39,98.68 137.32,98.75 137.01,98.75 136.69,98.42 130.38,98.42 129.52,97.56 125.53,97.56 124.84,98.26 124.84,98.4 124.62,98.62 123.53,98.62 123.03,99.12 118.42,99.12 117.84,99.69 115.3,99.69 114.71,100.28 112.66,100.28 112.5,100.43 109.15,100.43 108.77,100.05 106.43,100.05 105.6,99.71 104.38,99.71 103.58,98.91 101.89,98.91 101.33,99.47 93.99,99.47 93.77,99.25 93.19,99.25 92.9,99.54 85.44,99.54 85.11,99.2 83.58,99.2 83.31,99.47 75.38,99.47 74.98,99.07 74.42,99.07 73.72,99.77 70.6,99.77 70.02,99.19 70.02,98.85 69.69,98.53 65.03,98.53 63.82,97.32 59.44,97.32 56.06,93.94 54.99,93.94 53.42,92.37 49.43,92.37 47.69,90.63 47.17,90.63 46.69,90.15 46.39,90.15 45.56,89.32 45.37,89.32 44.29,88.24 44.29,87.85 43.02,86.59 41.45,86.59 41.1,86.24 40.84,86.24 40.65,86.04 40.65,81.39 39.98,80.72 39.3,80.72 37.76,79.18 35.8,79.18 34.07,77.45 34.07,73.3 34.36,73 34.36,70.66 34.73,70.29 34.73,67.09 34.36,66.72 34.36,65.49 35.02,64.84 35.02,58.64 35.57,58.09 35.57,55.58 35.95,55.2 36.33,55.2 v1(36.84,54.69)
  BOTTOM w0.149: J7.A11 55.38,3.84 55.38,9.35 55.63,9.6 v1(55.63,10.56)
PCIE_EP_PRSNT_N: length 79.9
  L07_SIG3 w0.089: v1(46.24,9.35) 46.24,13.41 41.75,17.9 38.81,17.9 38.15,17.24 37.65,17.24 36.03,15.62 23.73,15.62 20.99,18.37 13.22,18.37 9.15,22.43 9.15,33.53 v1(4.71,37.98)
  BOTTOM w0.149: SW6.4 3.79,41.79 3.56,41.56 3.56,40.74 3.79,40.52 SW6.3 5.75,40.52 5.98,40.29 5.98,39.47 5.75,39.25 SW6.2 3.79,39.25 3.56,39.02 3.56,38.2 3.79,37.98 v1(4.71,37.98)
  BOTTOM w0.152: v1(46.24,9.35) 45.78,8.9 45.78,4.11 J7.A1
PCIE_EP_PRSNT_NX1: length 83.2
  TOP w0.149: J7.B17 63.66,8.5 v1(61.6,10.56)
  L16_SIG6 w0.081: v1(61.6,10.56) 61.19,10.96 55.49,10.96 55.09,10.57 54.08,10.57 53.25,9.73 52.81,9.73 51.82,8.74 50.23,8.74 48.4,10.57 48.4,11.59 43.64,16.35 43.64,16.75 42.89,17.51 42.89,18 42.16,18.73 39.28,18.73 37.73,17.17 36.08,17.17 35.52,16.61 25.92,16.61 24.44,18.1 24.44,24.51 24.8,24.87 24.8,25.35 24.44,25.71 24.44,26.44 24.75,26.75 24.75,27.43 24.44,27.74 24.44,28.35 25.2,29.11 25.2,30.51 17.41,38.31 16.52,38.31 13.04,41.79 v1(12.33,41.79)
PCIE_EP_PRSNT_NX4: length 100.3
  TOP w0.149: C1480.1 v1(79.76,9.86) 77.66,7.76 J7.B31
  L16_SIG6 w0.081: v1(12.33,40.52) 13.55,40.52 16.26,37.8 17.03,37.8 24.26,30.56 24.26,28.78 23.88,28.4 23.88,24.59 24.01,24.46 24.01,17.99 25.71,16.28 36,16.28 36.61,16.89 38.36,16.89 39.81,18.34 41.72,18.34 43.36,16.69 43.36,16.08 48,11.45 48,10.38 50.43,7.95 51.39,7.95 52.15,8.71 52.64,8.71 54.04,10.12 61.48,10.12 62.28,9.32 79.22,9.32 v1(79.76,9.86)
PCIE_EP_PRSNT_NX8: length 116.2
  TOP w0.149: v1(95.64,10.56) 94.66,9.58 J7.B48
  L16_SIG6 w0.081: v1(95.64,10.56) 95.64,9.99 94.49,8.84 60.13,8.84 59.2,9.77 54.51,9.77 53.5,8.77 53.5,8.18 53.14,7.83 52.15,7.83 51.87,7.55 50.35,7.55 47.29,10.6 47.29,11.69 43.06,15.92 43.06,16.63 41.86,17.83 39.94,17.83 38.66,16.55 36.83,16.55 36.18,15.9 24.87,15.9 23.57,17.2 23.57,24.01 23.32,24.26 23.32,30.23 17.03,36.53 15.04,36.53 v1(12.33,39.25)
PCIE_EP_PRSNT_NX16: length 145.5
  TOP w0.152: v1(121.67,10.56) 123.01,9.22 125.86,9.22 127.66,7.43 J7.B81
  L16_SIG6 w0.081: v1(12.33,37.98) 12.4,37.98 14.49,35.89 16.77,35.89 22.36,30.31 22.36,24.34 23.16,23.53 23.16,17.06 24.7,15.52 36.41,15.52 37.06,16.18 37.55,16.18 39.94,13.79 44.63,13.79 46.68,11.75 46.68,10.58 48.56,8.7 48.56,7.79 49.33,7.01 50.07,7.01 50.07,7.01 53.45,7.01 53.8,7.37 53.8,8.47 54.82,9.49 58.29,9.49 59.81,7.97 94.61,7.97 96.04,9.4 120.82,9.4 121.67,10.25 v1(121.67,10.56)
PCIE_EP_RX_CN0: length 7.3
  BOTTOM w0.116: C175.1 63.28,10.16 63.28,5.61 63.66,5.23 J7.A17
