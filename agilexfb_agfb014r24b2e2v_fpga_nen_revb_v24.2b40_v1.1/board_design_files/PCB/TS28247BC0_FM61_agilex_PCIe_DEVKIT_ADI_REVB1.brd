# Allegro board TS28247BC0_FM61_agilex_PCIe_DEVKIT_ADI_REVB1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_DIMM_CH1_A6: length 87.5
  L03_SIG1 w0.081: v4(123.99,99.06) 124.17,99.24 124.59,99.24 125.46,100.11 125.46,100.35 125.18,100.62 124.66,100.62 124.44,100.85 124.44,101.58 124.09,101.93 122.68,101.93 122.49,102.11 121.88,102.11 121.78,102.01 121.78,99.37 121.86,99.29 121.86,98.87 121.86,98.86 121.64,98.64 121.29,98.64 120.94,98.29 120.94,97.99 120,97.05 119.59,97.05 119.4,97.24 119.24,97.24 119.06,97.05 118.73,97.05 118.46,97.32 118.27,97.32 117.89,96.94 117.17,96.94 117.07,96.83 117.07,96.63 117.17,96.53 117.54,96.53 117.64,96.44 117.64,96.3 117.54,96.2 117.17,96.2 117.07,96.1 117.07,95.96 117.17,95.86 117.66,95.86 117.75,95.77 117.75,95.63 117.66,95.53 117.17,95.53 117.07,95.43 117.07,95.29 117.17,95.19 117.67,95.19 117.77,95.09 117.77,93.89 117.68,93.8 117.5,93.8 117.41,93.89 117.41,94.76 117.31,94.86 117.17,94.86 117.07,94.76 117.07,94.41 116.97,94.31 115.12,94.31 115.02,94.21 115.02,94.08 115.12,93.98 116.76,93.98 116.86,93.88 116.86,93.74 116.76,93.64 115.11,93.64 115.02,93.54 115.02,93.41 115.11,93.31 116.52,93.31 116.62,93.21 116.62,93.07 116.52,92.97 115.17,92.97 115,92.8 115,92.14 115.36,91.77 115.36,91.1 115.14,90.88 115.14,88.75 115.49,88.4 115.63,88.06 115.63,85.87 115.53,85.77 115.4,85.77 115.3,85.87 115.3,87.98 115.2,88.07 115.06,88.07 114.96,87.98 114.96,86.91 114.86,86.81 114.73,86.81 114.63,86.91 114.63,88.19 114.53,88.29 114.39,88.29 114.29,88.19 114.29,82.72 114.39,82.63 114.53,82.63 114.63,82.72 114.63,83.95 114.73,84.05 114.86,84.05 114.96,83.95 114.96,82.89 115.06,82.8 115.2,82.8 115.3,82.89 115.3,85.17 115.4,85.27 115.53,85.27 115.63,85.17 115.63,82.59 115.16,82.11 115.16,81.95 115.57,81.53 115.57,81.27 115.36,81.06 115.36,80.8 115.6,80.56 115.6,80.31 115.2,79.9 115.2,79.72 115.54,79.37 115.54,79.23 115.2,78.89 115.2,78.71 115.46,78.46 115.46,78.22 115.14,77.91 115.14,77.77 115.51,77.4 115.51,77.24 115.19,76.91 114.62,76.91 114.43,76.73 114.43,75.78 114.11,75.45 113.84,75.45 113.32,74.93 113.06,74.93 112.71,74.58 112.71,73.74 112.35,73.38 112.05,73.38 111.72,73.05 111.16,73.05 110.91,73.3 110.19,73.3 109.94,73.05 109.43,73.05 109.18,73.3 108.54,73.3 108.29,73.05 107.57,73.05 107.33,73.3 106.76,73.3 106.43,72.98 106.05,72.98 105.73,73.3 105.23,73.3 104.99,73.05 104.17,73.05 103.92,73.3 103.28,73.3 103.03,73.05 102.57,73.05 102.09,73.54 101.78,73.54 101.52,73.8 101.52,73.97 v4(101.06,74.43)
DDR4_DIMM_CH1_A7: length 87.4
  L07_SIG3 w0.089: v1(122.29,105.06) 122.29,104.69 121.13,103.52 121.01,103.52 120.91,103.63 120.91,103.77 121.11,103.97 121.11,104.27 120.74,104.65 120.41,104.65 120.19,104.43 120.19,103.1 120.09,103 118.55,103 118.45,103.1 118.45,103.24 118.55,103.34 119.7,103.34 119.8,103.44 119.8,103.58 119.7,103.68 118.55,103.68 118.45,103.78 118.45,103.93 118.55,104.03 119.72,104.03 119.82,104.13 119.82,104.27 119.72,104.37 117.83,104.37 117.64,104.18 117.64,102.53 117.54,102.43 117.3,102.43 117.2,102.53 117.2,104.61 117.33,104.74 119.24,104.74 119.34,104.84 119.34,105 119.23,105.11 116.47,105.11 116.32,104.96 116.32,104.57 116.73,104.16 116.73,102.39 116.58,102.25 116.34,102.25 116.19,102.39 116.19,103.57 116.09,103.67 115.81,103.67 115.71,103.57 115.71,102.5 115.34,102.13 115.34,100.64 115.44,100.54 115.59,100.54 115.69,100.64 115.69,101.92 115.79,102.02 115.93,102.02 116.03,101.92 116.03,100.03 115.87,99.86 115.87,98.31 115.76,98.2 115.54,98.2 115.44,98.1 115.44,97.96 115.54,97.86 115.81,97.86 115.96,97.71 115.96,97.37 114.91,96.32 113.92,96.32 113.35,95.75 113.35,95.3 113.11,95.07 112.74,95.07 112.45,95.37 111.53,95.37 110.9,94.74 110.9,94.09 110.49,93.69 110.04,93.69 109.22,94.03 107.24,94.03 107.14,93.93 107.14,93.78 107.24,93.68 109.06,93.68 109.16,93.58 109.16,93.39 109.06,93.29 105.45,93.29 105.24,93.5 102.2,93.5 101.57,92.87 101.57,92.09 100.96,91.48 100.96,91.14 100.47,90.64 100.15,90.64 99.59,90.08 99.59,89.91 99.97,89.53 99.97,88.31 99.87,88.21 99.73,88.21 99.63,88.31 99.63,88.92 99.53,89.02 99.38,89.02 99.28,88.92 99.28,88.13 99.76,87.65 99.76,87.3 99.48,87.02 99.48,86.82 99.76,86.54 99.76,86.14 99.66,86.04 99.41,86.04 99.31,85.94 99.31,85.72 99.41,85.62 99.74,85.62 99.84,85.52 99.84,85.32 99.74,85.22 99.41,85.22 99.31,85.12 99.31,84.92 99.41,84.82 99.66,84.82 99.76,84.72 99.76,84.26 99.48,83.98 99.48,83.83 99.76,83.55 99.76,81.01 100.03,80.74 100.03,80.55 99.81,80.01 99.81,79.85 99.93,79.55 99.93,79.28 99.81,78.99 99.81,78.86 99.94,78.55 99.94,78.34 99.71,77.79 99.71,75.22 100.08,74.85 100.08,74.4 v1(101.06,73.43)
DDR4_DIMM_CH1_A8: length 86.5
  L03_SIG1 w0.081: v4(123.15,99.06) 123.46,99.06 123.99,99.59 124.36,99.59 124.46,99.69 124.46,100.35 124.1,100.71 124.1,101.42 123.96,101.56 122.74,101.56 122.64,101.46 122.64,101.32 122.74,101.22 123.67,101.22 123.77,101.13 123.77,100.99 123.67,100.89 122.57,100.89 122.47,100.79 122.47,100.65 122.57,100.55 123.71,100.55 123.81,100.46 123.81,100.32 123.71,100.22 122.77,100.22 122.67,100.12 122.67,99.98 122.77,99.88 123.44,99.88 123.54,99.79 123.54,99.65 123.44,99.55 122.32,99.55 122.22,99.45 122.22,98.99 122.32,98.89 122.79,98.89 122.89,98.79 122.89,97.75 122.79,97.66 122.65,97.66 122.55,97.75 122.55,98.41 122.46,98.5 122.32,98.5 122.22,98.41 122.22,97.92 121.94,97.65 121.8,97.65 121.53,97.92 121.39,97.92 120.94,97.47 120.94,97.28 121.41,96.82 121.41,96.68 121.28,96.54 121.13,96.54 120.63,97.05 120.48,97.05 120.15,96.72 118.53,96.72 118.43,96.62 118.43,96.48 118.53,96.38 120.11,96.38 120.21,96.28 120.21,96.15 120.11,96.05 118.19,96.05 118.09,95.95 118.09,95.81 118.19,95.71 120.13,95.71 120.23,95.61 120.23,95.48 120.13,95.38 118.64,95.38 118.1,94.84 118.1,93.74 117.46,93.09 117.14,93.09 116.77,92.72 116.77,91.89 116.66,91.78 116.52,91.78 116.41,91.89 116.41,92.51 116.31,92.61 116.15,92.61 115.7,92.16 115.7,91.49 116.15,91.04 116.15,89.04 116.05,88.94 115.91,88.94 115.81,89.04 115.81,90.74 115.72,90.84 115.58,90.84 115.48,90.74 115.48,88.89 115.78,88.58 115.97,88.14 115.97,86.18 116.07,86.08 116.46,86.08 116.55,85.99 116.55,85.85 116.46,85.75 116.07,85.75 115.97,85.65 115.97,85.2 116.07,85.09 116.46,85.09 116.56,85 116.56,84.86 116.46,84.76 116.08,84.76 115.97,84.65 115.97,84.13 116.07,84.03 116.63,84.03 116.73,83.93 116.73,83.79 116.63,83.7 116.07,83.7 115.97,83.6 115.97,83.46 116.07,83.36 116.63,83.36 116.73,83.26 116.73,83.12 116.63,83.02 116.07,83.02 115.97,82.93 115.97,82.3 116.18,82.08 116.45,82.08 116.54,81.99 116.54,81.84 116.45,81.75 116.15,81.75 115.97,81.56 115.97,81.29 116.21,81.05 116.21,80.79 115.97,80.54 115.97,80.32 116.21,80.07 116.21,79.82 115.94,79.55 115.94,79.33 116.21,79.06 116.21,78.8 115.92,78.51 115.92,78.33 116.21,78.05 116.21,77.82 115.91,77.52 115.91,77.35 116.21,77.05 116.21,76.83 115.84,76.46 115.68,76.46 115.09,75.87 114.82,75.87 114.46,75.51 114.46,74.81 114.08,74.42 113.88,74.42 113.62,74.17 113.62,73.23 113.32,72.93 112.96,72.93 112.59,72.55 111.91,72.55 111.66,72.8 111.18,72.8 110.94,72.55 110.16,72.55 109.91,72.8 109.38,72.8 109.14,72.55 108.56,72.55 108.31,72.8 107.63,72.8 107.38,72.55 106.83,72.55 106.71,72.67 105.85,72.67 105.73,72.55 105.08,72.55 104.83,72.8 104.23,72.8 103.98,72.55 103.27,72.55 103.03,72.8 102.6,72.8 102.35,72.55 101.66,72.55 101.29,72.92 100.88,72.92 100.64,73.17 100.64,74.2 100.19,74.65 v4(100.19,74.93)
DDR4_DIMM_CH1_A9: length 86.6
  L03_SIG1 w0.081: v4(100.19,73.93) 100.19,73.6 99.8,73.21 99.8,72.79 100.15,72.44 100.39,72.44 100.77,72.05 101.45,72.05 101.69,72.3 102.16,72.3 102.4,72.05 103.23,72.05 103.47,72.3 103.81,72.3 104.05,72.05 104.85,72.05 105.1,72.3 107.36,72.3 107.61,72.05 108.43,72.05 108.68,72.3 109.14,72.3 109.39,72.05 110.03,72.05 110.28,72.3 110.79,72.3 111.04,72.05 111.73,72.05 111.98,72.3 112.67,72.3 112.92,72.05 113.46,72.05 113.82,72.42 114.15,72.42 114.51,72.77 114.51,74.55 114.89,74.93 115.26,74.93 115.39,75.06 115.39,75.41 115.5,75.53 116.15,75.53 116.46,75.84 116.46,76.01 116.2,76.28 116.2,76.52 116.62,76.94 116.85,76.94 117.15,77.25 117.15,77.48 116.78,77.86 116.78,78.01 117.08,78.31 117.08,78.57 116.83,78.82 116.83,79.06 117.08,79.3 117.08,79.55 116.8,79.82 116.8,80.04 117.08,80.31 117.08,80.55 116.77,80.86 116.77,81 116.88,81.12 117.13,81.12 117.36,81.34 117.36,81.52 117.23,81.65 117.07,81.65 116.89,81.84 116.89,81.98 117.08,82.17 117.08,86.64 116.97,86.74 116.97,87.96 116.88,88.05 116.74,88.05 116.64,87.96 116.64,86.9 116.54,86.8 116.4,86.8 116.3,86.9 116.3,88.22 116.22,88.43 116.22,88.62 116.49,88.9 116.49,90.07 116.59,90.17 116.73,90.17 116.82,90.07 116.82,88.79 116.92,88.69 117.06,88.69 117.16,88.79 117.16,90.41 117.06,90.51 116.59,90.51 116.49,90.61 116.49,90.99 117.1,91.61 117.1,91.83 117.62,92.34 117.62,92.78 118.44,93.6 118.44,94.21 118.54,94.31 120.52,94.31 120.62,94.41 120.62,94.55 120.52,94.64 118.79,94.64 118.69,94.74 118.69,94.88 118.79,94.98 121.16,94.98 122.64,96.45 122.64,96.59 122.54,96.69 122.4,96.69 121.17,95.46 121.03,95.46 120.71,95.77 120.71,95.92 120.98,96.18 121.42,96.18 121.91,96.67 121.91,96.79 121.71,97 121.71,97.14 121.81,97.24 121.95,97.24 122.15,97.04 122.43,97.04 122.7,97.32 122.92,97.32 123.01,97.22 123.01,97.05 123.35,96.72 124.54,96.72 124.63,96.8 124.63,96.97 124.54,97.06 123.79,97.06 123.22,97.63 123.22,98.61 123.32,98.71 123.46,98.71 123.56,98.61 123.56,97.88 123.66,97.78 123.8,97.78 123.9,97.88 123.9,98.43 124.37,98.9 124.73,98.9 125.8,99.97 125.8,100.7 125.18,101.32 125.18,102.35 125.08,102.45 124.94,102.45 124.84,102.35 124.84,102.01 124.75,101.92 124.59,101.92 124.5,102.01 124.5,102.34 124.39,102.45 123.62,102.45 123.43,102.26 122.81,102.26 122.63,102.45 121.57,102.45 121.44,102.33 v4(121.44,99.06)
DDR4_DIMM_CH1_A10: length 87
  L07_SIG3 w0.089: v1(139.29,105.06) 139.29,108.43 138.76,108.96 131.33,108.96 129.87,110.42 126.47,110.42 125.53,109.48 111.58,109.48 111.48,109.38 111.48,108.1 111.71,107.87 113.91,107.87 114.07,107.71 114.07,105.92 114.21,105.78 114.21,98.45 113.38,97.63 113.38,97.33 112.67,96.61 112.18,96.41 111.07,96.41 109.77,95.11 109.64,95.06 105.38,95.06 104.85,94.53 101.76,94.53 98.85,91.62 98.85,90.81 98.09,90.05 98.09,88.08 97.99,87.98 97.84,87.98 97.74,88.08 97.74,89.62 97.64,89.72 97.5,89.72 97.4,89.62 97.4,87.27 97.58,87.09 97.58,86.84 97.4,86.66 97.4,86.23 98.04,85.59 98.04,74.77 98.39,74.43 v1(99.32,74.43)
DDR4_DIMM_CH1_A11: length 86.1
  L07_SIG3 w0.089: v1(99.32,73.43) 98.95,73.43 98.85,73.53 98.85,73.81 98.95,73.91 99.62,73.91 100.2,73.32 100.35,73.32 100.45,73.42 100.45,73.57 99.76,74.26 99.76,74.69 99.53,74.91 99.19,74.91 98.86,75.23 98.86,82.27 98.44,82.69 98.44,86.72 98.34,86.82 98.05,86.82 97.95,86.92 97.95,87.06 98.05,87.16 98.34,87.16 98.44,87.26 98.44,89.92 99.74,91.21 99.74,92.01 101.91,94.18 104.99,94.18 105.52,94.71 109.79,94.71 109.98,94.79 111.24,96.05 112.22,96.05 112.86,96.32 113.58,97.04 113.99,97.04 114.23,97.28 114.23,97.9 115.1,98.78 115.1,99.22 114.66,99.66 114.66,102.42 115.03,102.79 115.03,104.26 114.93,104.36 114.76,104.36 114.66,104.46 114.66,104.6 114.76,104.7 114.93,104.7 115.03,104.8 115.03,105.42 115.16,105.56 115.7,105.56 115.8,105.66 115.8,105.82 115.7,105.92 114.57,105.92 114.47,106.02 114.47,106.16 114.57,106.26 115.97,106.26 116.07,106.36 116.07,106.5 115.97,106.6 114.51,106.6 114.41,106.7 114.41,106.85 114.51,106.95 115.97,106.95 116.07,107.05 116.07,107.19 115.97,107.29 114.52,107.29 114.42,107.39 114.42,107.53 114.52,107.63 115.97,107.63 116.07,107.73 116.07,107.87 115.97,107.97 114.53,107.97 114.43,108.08 114.43,108.22 114.53,108.32 115.97,108.32 116.07,108.42 116.07,108.56 115.97,108.66 114.1,108.66 114,108.56 114,108.32 113.9,108.22 113.76,108.22 113.66,108.32 113.66,108.56 113.56,108.66 113.41,108.66 113.31,108.56 113.31,108.32 113.21,108.22 113.07,108.22 112.97,108.32 112.97,108.56 112.87,108.66 112.73,108.66 112.63,108.56 112.63,108.32 112.53,108.22 112.39,108.22 112.28,108.32 112.28,108.56 112.18,108.66 111.95,108.66 111.84,108.77 111.84,108.9 111.94,109 116.32,109 116.42,108.9 116.42,106.36 116.52,106.26 116.94,106.26 117.04,106.16 117.04,105.96 117.14,105.86 117.28,105.86 117.38,105.96 117.38,106.16 117.48,106.26 117.62,106.26 117.72,106.16 117.72,105.96 117.82,105.86 117.97,105.86 118.07,105.96 118.07,106.16 118.17,106.26 118.31,106.26 118.41,106.16 118.41,105.96 118.51,105.86 118.65,105.86 118.75,105.96 118.75,106.16 118.85,106.26 119.4,106.26 119.84,105.82 120.68,105.82 v1(121.44,105.06)
DDR4_DIMM_CH1_A12: length 81.1
  L03_SIG1 w0.081: v4(120.59,99.06) 120.73,99.2 120.73,99.69 120.64,99.79 120.23,99.79 120.13,99.89 120.13,100.03 120.23,100.13 120.64,100.13 120.73,100.22 120.73,100.36 120.64,100.46 119.97,100.46 119.87,100.56 119.87,100.7 119.97,100.8 120.64,100.8 120.73,100.9 120.73,101.03 120.64,101.13 120.23,101.13 120.13,101.23 120.13,101.37 120.23,101.47 120.64,101.47 120.73,101.57 120.73,101.79 120.61,101.91 119.96,101.91 119.76,102.11 119.26,102.11 119.16,102.01 119.16,101.87 119.26,101.77 119.51,101.77 119.6,101.68 119.6,101.52 119.51,101.43 119.25,101.43 119.12,101.3 119.12,101.14 119.35,100.91 119.35,100.77 119.13,100.55 119.13,100.4 119.36,100.17 119.36,99.96 119.12,99.72 119.12,99.54 119.24,99.42 119.39,99.42 119.62,99.64 119.77,99.64 119.98,99.44 120.11,99.44 120.2,99.35 120.2,99.18 120.11,99.09 119.5,99.09 119.08,98.67 118.65,98.67 117.59,97.61 116.67,97.61 115.67,96.6 115.67,95.08 115.57,94.98 115.43,94.98 115.33,95.08 115.33,96.63 115.23,96.73 115.1,96.73 115,96.63 115,95.83 114.9,95.74 114.76,95.74 114.66,95.83 114.66,96.63 114.56,96.73 114.43,96.73 114.33,96.63 114.33,95.58 114.23,95.48 114.09,95.48 113.99,95.58 113.99,96.63 113.89,96.72 113.75,96.72 113.66,96.63 113.66,94.24 113.75,94.14 113.89,94.14 113.99,94.24 113.99,95.04 114.09,95.14 114.23,95.14 114.33,95.04 114.33,91.8 114.23,91.7 114.09,91.7 113.99,91.8 113.99,93.71 113.89,93.8 113.75,93.8 113.66,93.71 113.66,92.71 113.53,92.57 113.53,92.43 113.65,92.31 113.65,92.16 113.54,92.06 113.42,92.06 113.29,92.19 113.14,92.19 113.04,92.08 113.04,91.94 113.38,91.59 113.38,91.29 113.13,91.03 113.13,89.02 113.62,88.53 113.62,88 113.52,87.9 113.23,87.9 113.13,87.8 113.13,87.66 113.23,87.57 113.52,87.57 113.62,87.47 113.62,87.33 113.52,87.23 113.23,87.23 113.13,87.13 113.13,86.99 113.23,86.9 113.52,86.9 113.62,86.8 113.62,86.2 113.52,86.1 113.37,86.1 113.27,86 113.27,85.86 113.37,85.76 113.52,85.76 113.62,85.67 113.62,85.19 113.52,85.09 113.37,85.09 113.27,84.99 113.27,84.85 113.37,84.76 113.52,84.76 113.62,84.66 113.62,84.1 113.52,84.01 113.24,84.01 113.15,83.91 113.15,83.77 113.24,83.67 113.52,83.67 113.62,83.57 113.62,83.43 113.52,83.34 113.24,83.34 113.15,83.24 113.15,83.1 113.24,83 113.52,83 113.62,82.9 113.62,82.32 113.37,82.07 113.37,81.81 113.62,81.56 113.62,81.3 113.36,81.04 113.36,80.87 113.62,80.61 113.62,80.3 113.4,80.08 113.4,79.79 113.62,79.57 113.62,79.32 113.37,79.08 113.37,78.81 113.62,78.56 113.62,78.3 113.38,78.05 113.38,77.83 113.62,77.59 113.62,77.34 113.24,76.96 113.08,76.96 112.58,76.46 112.31,76.46 111.84,75.98 111.84,75.28 111.49,74.93 111.21,74.93 110.7,74.42 110.34,74.42 109.98,74.06 109.37,74.06 109.1,74.32 108.67,74.32 108.4,74.05 107.74,74.05 107.47,74.32 106.86,74.32 106.6,74.05 106.04,74.05 105.77,74.32 105.04,74.32 104.77,74.05 104.16,74.05 103.79,74.42 103.33,74.42 102.83,74.93 102.57,74.93 102.11,75.39 101.66,75.39 101.3,75.03 100.92,75.03 100.41,75.54 99.87,75.54 99.59,75.82 99.08,75.82 98.71,75.45 98.18,75.45 97.83,75.8 96.85,75.8 v4(96.73,75.93)
DDR4_DIMM_CH1_A13: length 81
  L03_SIG1 w0.081: v4(145.24,105.06) 144.09,106.21 143.95,106.21 143.85,106.11 143.85,105.97 144.73,105.1 144.73,104.96 144.63,104.86 144.49,104.86 142.04,107.32 130.69,107.32 129.85,106.48 128.98,106.12 128.25,106.12 127.44,106.46 126.58,107.32 113.19,107.32 110.51,104.64 108.29,104.64 105.8,102.14 105.8,100.2 104.86,99.26 104.86,98.74 104.01,97.89 104.01,97.24 103.78,97.01 103.78,96.5 102.81,95.54 102.81,94.73 103.17,94.37 103.17,91.22 104.13,90.26 104.13,85.62 105.04,84.71 105.04,83.6 104.05,82.61 104.05,80.79 103.8,80.55 103.44,80.55 102.91,80.02 102.54,80.02 102.06,79.53 101.58,79.53 101.3,79.81 100.9,79.81 100.62,79.53 99.98,79.53 99.6,79.91 99.22,79.91 98.71,79.4 98.2,79.4 98,79.2 98,78.31 97.75,78.05 97.39,78.05 96.88,77.55 96.32,77.55 96.2,77.43 v4(95.86,77.43)
DDR4_DIMM_CH1_A14: length 81.7
  L03_SIG1 w0.081: v4(141.87,105.03) 142.31,104.59 142.31,104.15 142.07,103.9 141.55,103.9 141.46,103.99 141.46,104.74 141.37,104.83 141.18,104.83 141.07,104.73 141.07,103.99 140.98,103.9 140.77,103.9 140.68,103.99 140.68,104.54 140.55,104.67 140.27,104.67 139.91,104.31 138.07,104.31 137.68,104.7 137.68,105.47 136.84,106.31 131.94,106.31 131.19,105.56 130.6,105.56 129.39,104.34 127.87,104.34 126.77,105.44 125.96,105.44 125.09,106.31 114.11,106.31 113.36,105.56 113.36,104.88 113.16,104.68 112.94,104.68 111.69,103.43 108.55,103.43 106.9,101.78 106.9,99.74 107.4,99.24 107.4,98.94 106.56,98.1 106.56,97.29 106.29,97.02 105.92,97.02 104.8,95.9 104.8,95.25 104.94,95.11 104.94,94.77 104.49,94.32 104.49,92.44 105.09,91.83 105.46,91.83 105.7,91.59 105.7,89.91 105.96,89.65 105.96,85.97 106.59,85.33 106.59,85.11 106.94,84.76 106.94,84.18 106.64,83.44 106.64,82.27 106.5,82.13 106.5,81.73 106.63,81.6 106.63,81.26 106.45,81.08 106.45,80.95 106.35,80.84 106.13,80.84 105.62,80.33 105.26,80.33 104.76,79.83 104.39,79.83 103.86,79.3 103.49,79.3 103,78.82 102.65,78.82 102.14,78.31 101.66,78.31 101.4,78.06 100.85,78.06 100.59,78.31 100.04,78.31 99.53,77.8 99.17,77.8 98.88,77.52 98.88,76.74 98.59,76.44 98.22,76.44 97.8,76.02 97.25,76.02 96.97,76.3 95.98,76.3 v4(95.86,76.43)
DDR4_DIMM_CH1_A15: length 82.9
  L03_SIG1 w0.081: v4(143.54,99.06) 143.82,99.74 143.82,102.87 143.7,103.17 142.28,105.3 141.79,105.5 141.69,105.5 141.62,105.57 141.52,105.57 139.32,104.66 138.27,104.66 138.06,104.86 138.06,105.58 137,106.64 131.79,106.64 130.8,106.23 129.25,104.68 128.04,104.68 127.09,105.63 126.93,106.01 126.7,106.24 125.73,106.64 113.97,106.64 112.48,105.16 112.48,104.7 111.55,103.77 108.4,103.77 106.56,101.93 106.56,98.99 105.66,97.65 105.66,97.24 104.49,96.07 104.31,95.64 104.31,95.28 104.15,95.12 104.15,92.3 104.87,91.58 104.87,91.14 105.19,90.38 105.19,88.17 105.6,87.16 105.6,85.97 105.78,85.08 105.78,80.79 105.53,80.54 105.17,80.54 104.67,80.04 104.3,80.04 103.79,79.53 103.42,79.53 102.94,79.05 102.58,79.05 102.06,78.54 101.84,78.54 101.17,78.82 100.92,78.82 100.28,78.55 99.99,78.55 99.47,78.03 99.09,78.03 98.36,77.3 97.15,76.8 96.88,76.53 96.58,76.53 96.3,76.81 95.56,76.81 95.45,76.93 v4(95,76.93)
DDR4_DIMM_CH1_A16: length 80.5
  L03_SIG1 w0.081: v4(95,75.93) 95,75.46 95.42,75.03 95.42,74.34 95.71,74.04 96.08,74.04 96.67,73.46 96.81,73.46 97.29,72.98 97.7,72.98 98.22,72.45 98.6,72.45 98.89,72.16 98.89,71.28 99.14,71.02 99.7,71.02 99.98,71.3 100.57,71.3 100.87,71 101.33,71 101.63,71.3 102.24,71.3 102.55,71 103.11,71 103.41,71.3 103.97,71.3 104.3,70.97 104.81,70.97 105.14,71.3 105.59,71.3 105.95,70.94 106.56,70.94 106.92,71.3 107.35,71.3 107.66,70.98 108.22,70.98 108.54,71.3 109.15,71.3 109.44,71.02 110.06,71.02 110.35,71.3 110.78,71.3 111.13,70.94 111.69,70.94 112.05,71.3 112.68,71.3 112.99,71 113.47,71 113.77,71.3 114.33,71.3 114.61,71.02 115.22,71.02 115.67,71.47 115.92,71.47 116.21,71.76 116.21,73.63 116.49,73.92 116.71,73.92 117.23,74.44 117.58,74.44 117.94,74.8 117.94,76.53 118.18,76.76 118.18,77.09 118,77.26 118,77.58 118.17,77.75 118.17,78.11 118,78.28 118,78.58 118.14,78.73 118.14,79.13 118,79.27 118,79.58 118.16,79.74 118.16,80.11 117.98,80.28 117.98,80.57 118.18,80.77 118.18,81.09 117.99,81.28 117.99,81.58 118.16,81.74 118.16,82.12 117.87,82.4 117.87,82.58 117.75,82.71 117.75,88.39 117.86,88.5 117.86,90.36 117.98,90.49 117.98,90.8 118.47,91.29 118.47,92.62 118.99,93.14 119.91,93.14 120.34,93.58 120.74,93.58 122.15,94.98 123.35,94.98 123.54,95.17 123.54,95.57 123.98,96.01 124.79,96.01 125.58,96.8 125.58,97.31 126.17,97.9 126.61,97.9 126.73,97.85 126.82,97.79 126.9,97.71 126.99,97.58 127.18,97.13 127.64,96.66 127.77,96.48 127.86,96.25 128.4,95.71 129.56,95.71 129.69,95.59 130.88,95.59 131.24,95.96 131.24,96.21 132.21,97.17 132.21,97.97 132.54,98.3 132.54,99.37 132.82,99.65 133.79,99.65 133.97,99.83 135.66,99.83 136.48,100.66 137.68,100.66 138.05,100.29 138.05,99.69 139.13,98.61 139.38,98.61 139.83,99.06 v4(140.14,99.06)
DDR4_DIMM_CH1_ACT_N: length 87
  L03_SIG1 w0.081: v4(102.79,76.43) 103.05,76.16 103.05,76 103.5,75.55 103.87,75.55 104.39,75.03 104.91,75.03 105.19,75.31 105.67,75.31 105.95,75.03 106.48,75.03 106.76,75.31 107.4,75.31 107.66,75.05 108.2,75.05 108.54,75.39 108.97,75.39 109.48,75.9 109.81,75.9 110.37,76.46 110.78,76.46 111.23,76.91 111.47,76.91 111.84,77.29 111.84,82.26 111.94,82.35 112.36,82.35 112.46,82.45 112.46,82.59 112.36,82.69 111.82,82.69 111.73,82.79 111.73,82.93 111.82,83.02 112.36,83.02 112.46,83.12 112.46,83.26 112.36,83.36 111.89,83.36 111.79,83.46 111.79,83.6 111.89,83.69 112.36,83.69 112.46,83.79 112.46,83.93 112.36,84.03 111.89,84.03 111.79,84.13 111.79,84.27 111.89,84.37 112.36,84.37 112.46,84.46 112.46,84.6 112.36,84.7 111.81,84.7 111.71,84.8 111.71,84.94 111.81,85.04 112.36,85.04 112.46,85.13 112.46,85.27 112.36,85.37 111.94,85.37 111.84,85.47 111.84,85.61 111.94,85.71 112.36,85.71 112.46,85.8 112.46,85.94 112.36,86.04 111.94,86.04 111.84,86.14 111.84,86.28 111.94,86.38 112.36,86.38 112.46,86.48 112.46,86.61 112.36,86.71 111.94,86.71 111.84,86.81 111.84,86.95 111.94,87.05 112.36,87.05 112.46,87.15 112.46,87.28 112.36,87.38 111.92,87.38 111.82,87.48 111.82,87.62 111.92,87.72 112.35,87.72 112.45,87.82 112.45,87.96 112.35,88.05 111.26,88.05 111.15,88.16 111.15,88.46 111.28,88.58 111.78,88.58 111.88,88.68 111.88,88.82 111.78,88.92 111.27,88.92 111.17,89.02 111.17,89.16 111.27,89.25 112.36,89.25 112.46,89.35 112.46,89.49 112.36,89.59 111.27,89.59 111.17,89.69 111.17,89.83 111.27,89.92 112.36,89.92 112.46,90.02 112.46,90.16 112.36,90.26 111.27,90.26 111.17,90.36 111.17,90.5 111.27,90.59 112.36,90.59 112.46,90.69 112.46,90.83 112.36,90.93 111.56,90.93 111.46,91.03 111.46,91.17 111.56,91.26 112.08,91.26 112.19,91.38 112.19,91.56 112.08,91.67 111.51,91.67 111.15,92.03 111.15,94.32 111.25,94.42 111.39,94.42 111.49,94.32 111.49,92.41 111.58,92.32 111.72,92.32 111.82,92.41 111.82,93.97 111.92,94.07 112.06,94.07 112.16,93.97 112.16,92.58 112.25,92.48 112.44,92.48 112.54,92.58 112.54,94.61 112.28,94.87 112.28,96.73 112.37,96.83 112.51,96.83 112.61,96.73 112.61,95.94 112.71,95.84 112.85,95.84 112.95,95.94 112.95,96.89 112.47,97.36 112.47,97.71 112.68,97.92 112.68,98.31 112.77,98.41 112.91,98.41 113.01,98.31 113.01,97.88 113.11,97.78 113.25,97.78 113.35,97.88 113.35,98.64 113.45,98.74 113.58,98.74 113.68,98.64 113.68,97.93 113.78,97.84 113.92,97.84 114.02,97.93 114.02,98.64 114.12,98.74 114.25,98.74 114.35,98.64 114.35,97.92 114.45,97.82 114.59,97.82 114.69,97.92 114.69,98.59 114.79,98.69 114.93,98.69 115.02,98.59 115.02,97.85 115.12,97.75 115.26,97.75 115.36,97.85 115.36,98.6 115.46,98.7 115.6,98.7 115.69,98.6 115.69,97.96 115.79,97.86 115.94,97.86 116.04,97.96 116.04,98.18 116.14,98.29 116.7,98.29 116.78,98.37 116.78,98.55 116.68,98.66 116.19,98.66 116.03,98.82 116.03,99.34 116.14,99.45 116.14,99.64 115.89,99.89 115.89,100.09 116.14,100.34 116.14,100.67 116.23,100.77 116.37,100.77 116.47,100.67 116.47,99.52 116.57,99.42 116.71,99.42 116.81,99.52 116.81,100.65 116.91,100.75 117.56,100.75 117.66,100.86 117.66,101.33 117.76,101.43 117.95,101.43 118.04,101.34 118.04,100.46 117.94,100.36 117.67,100.36 117.58,100.27 117.58,100.06 117.67,99.97 117.94,99.97 118.04,99.87 118.04,99.65 117.95,99.56 117.3,99.56 117.15,99.41 117.15,99.18 117.27,99.06 v4(118.04,99.06)
DDR4_DIMM_CH1_ALERT_N: length 78.8
  L05_SIG2 w0.081: v1(119.74,105.06) 120.19,104.61 120.19,101.79 120.1,101.69 119.96,101.69 119.86,101.79 119.86,104.31 119.76,104.41 119.62,104.41 119.52,104.31 119.52,101.76 119.43,101.66 119.29,101.66 119.19,101.76 119.19,104.31 119.09,104.41 118.95,104.41 118.85,104.31 118.85,101.39 118.75,101.29 118.62,101.29 118.52,101.39 118.52,102.58 118.42,102.68 118.28,102.68 118.18,102.58 118.18,100.93 118.08,100.83 117.95,100.83 117.85,100.93 117.85,102.58 117.75,102.68 117.61,102.68 117.51,102.58 117.51,101.7 117.41,101.61 117.27,101.61 117.18,101.7 117.18,102.45 117.08,102.55 116.83,102.55 116.73,102.45 116.73,100.43 115.78,99.48 114.48,99.48 114.2,99.2 114.2,98.55 113.35,97.7 113.35,97.16 112.93,96.74 112.49,96.74 110.56,94.81 110.42,94.81 110.32,94.91 110.32,95.05 111.41,96.13 111.41,96.27 111.31,96.37 111.17,96.37 109.83,95.03 109.83,94.84 108.58,93.59 108.44,93.59 108.34,93.68 108.34,93.82 109.38,94.86 109.38,95 109.28,95.1 109.14,95.1 106.6,92.56 106.6,92.42 106.7,92.32 106.84,92.32 107.81,93.29 107.94,93.29 108.04,93.19 108.04,93.05 106.57,91.57 106.57,91.11 105.14,89.68 105.14,88.3 105.52,87.92 105.52,85.16 104.94,84.58 104.94,84.21 104.37,83.63 104.37,82.93 104.11,82.68 104.11,81.85 103.92,81.66 103.92,81.19 104.05,81.07 104.05,80.79 103.9,80.64 103.9,80.22 104.05,80.07 104.05,79.79 103.91,79.66 103.91,79.21 104.05,79.07 104.05,78.79 103.92,78.66 103.92,78.19 104.04,78.08 104.04,77.78 103.68,77.42 103.46,77.42 102.96,76.92 102.54,76.92 102.16,76.53 101.68,76.53 101.38,76.84 100.98,76.84 100.37,77.45 98.25,77.45 97.8,77.9 97.34,77.9 96.86,77.43 v1(94.13,77.43)
DDR4_DIMM_CH1_BA0: length 79.1
  L03_SIG1 w0.081: v4(139.29,99.06) 138.84,99.51 138.84,100.29 138.44,100.69 138.14,100.69 137.76,101.06 136.4,101.06 135.51,100.18 133.83,100.18 133.69,100.03 132.5,100.03 132.21,99.73 132.21,98.54 131.22,97.55 131.22,97.09 131,96.86 130.61,96.86 130.37,96.63 130.37,96.24 130.1,95.96 129.8,95.96 129.71,96.06 128.58,96.06 128.2,96.43 127.78,97.06 127.44,97.44 127.35,97.65 127.19,97.89 127.1,97.99 126.86,98.23 126.03,98.23 125.23,97.43 125.23,96.93 124.67,96.37 123.72,96.37 123.3,95.96 122.65,95.96 120.66,93.97 118.9,93.97 118.77,93.84 118.77,93.46 117.98,92.67 117.98,92.12 117.63,91.77 117.63,90.72 117.52,90.61 117.52,88.64 117.41,88.53 117.41,82.56 117.9,82.07 117.9,81.79 117.69,81.57 117.69,81.28 117.89,81.08 117.89,80.77 117.69,80.57 117.69,80.28 117.89,80.08 117.89,79.77 117.72,79.61 117.72,79.24 117.91,79.06 117.91,78.79 117.73,78.61 117.73,78.24 117.91,78.06 117.91,77.8 117.72,77.61 117.72,77.24 117.91,77.05 117.91,76.79 117.6,76.48 117.3,76.48 117.02,76.2 117.02,75.27 116.71,74.96 116.47,74.96 115.91,74.4 115.63,74.4 115.35,74.12 115.35,72.24 114.99,71.88 114.66,71.88 114.33,71.55 113.75,71.55 113.5,71.8 112.88,71.8 112.63,71.55 112,71.55 111.75,71.8 111.06,71.8 110.81,71.55 110.27,71.55 110.02,71.8 109.45,71.8 109.2,71.55 108.59,71.55 108.35,71.8 107.67,71.8 107.42,71.55 106.84,71.55 106.56,71.83 105.95,71.83 105.67,71.55 105.11,71.55 104.87,71.8 104.37,71.8 104.12,71.55 103.31,71.55 103.06,71.8 102.49,71.8 102.22,71.53 101.61,71.53 101.34,71.8 100.81,71.8 100.57,71.55 99.9,71.55 99.73,71.73 99.73,72.56 99.46,72.82 99.25,72.82 98.66,73.41 98.18,73.41 97.67,73.92 97.37,73.92 96.86,74.42 96.48,74.42 95.87,75.03 95.71,75.03 95.49,75.26 95.49,75.97 95.16,76.3 94.25,76.3 v4(94.13,76.43)
DDR4_DIMM_CH1_BA1: length 79.4
  L03_SIG1 w0.081: v4(138.44,105.06) 138.89,105.5 140.33,105.5 141.14,106.31 141.14,106.72 140.87,106.98 131.07,106.98 129.55,105.46 127.73,105.46 127.47,105.72 127.47,105.94 126.44,106.98 113.45,106.98 111.68,105.21 111.68,104.37 111.41,104.1 108.24,104.1 106.21,102.07 106.21,99.87 105.7,99.35 105.7,98.93 104.84,98.08 104.84,97.29 104.29,96.74 104.29,96.47 103.5,95.68 103.5,95.22 103.68,95.04 103.68,91.93 104.01,91.6 104.01,91.03 104.84,90.2 104.84,87.8 105.27,86.76 105.27,85.02 105.44,84.86 105.44,83.3 104.93,82.79 104.93,81.2 104.6,80.87 104.43,80.87 103.86,80.31 103.5,80.31 103,79.81 102.63,79.81 102.13,79.3 101.48,79.3 101.23,79.05 100.74,79.05 100.49,79.3 99.96,79.3 99.55,78.9 99.02,78.9 98.43,78.31 98.31,78.31 97.8,77.8 97.44,77.8 96.96,77.32 96.43,77.32 96.15,77.04 95.67,77.04 95.39,77.32 94.74,77.32 94.44,77.03 93.36,77.03 v4(93.26,76.93)
DDR4_DIMM_CH1_BG0: length 78.6
  L03_SIG1 w0.081: v4(118.89,99.06) 118.79,99.17 118.79,102.35 118.88,102.45 120.07,102.45 120.27,102.25 120.95,102.25 121.07,102.13 121.07,98.89 120.87,98.69 119.69,98.69 119.59,98.59 119.59,98.45 119.69,98.35 120.48,98.35 120.58,98.26 120.58,98.12 120.48,98.02 119.6,98.02 119.36,97.79 119.17,97.79 118.84,98.12 118.57,98.12 117.73,97.27 116.98,97.27 116.73,97.02 116.73,94.77 116.62,94.66 116.46,94.66 116.36,94.76 116.36,96.26 116.26,96.36 116.1,96.36 116,96.26 116,94.8 115.86,94.65 115.1,94.65 115,94.75 115,94.89 114.91,94.98 114.75,94.98 114.66,94.89 114.66,92 115.03,91.64 115.03,91.24 114.81,91.02 114.81,88.84 114.71,88.74 114.57,88.74 114.47,88.84 114.47,91.05 114.37,91.15 114.24,91.15 114.14,91.05 114.14,89.31 114.04,89.22 113.9,89.22 113.8,89.31 113.8,90.88 113.7,90.98 113.56,90.98 113.47,90.88 113.47,89.16 113.96,88.67 113.96,82.58 114.46,82.08 114.46,77.75 114.13,77.42 114.01,77.42 113.62,77.04 113.62,76.18 113.37,75.93 113.11,75.93 112.54,75.36 112.22,75.36 111.92,75.06 111.92,74.32 111.54,73.94 111.18,73.94 110.8,73.55 110.3,73.55 110.05,73.81 109.5,73.81 109.25,73.55 108.55,73.55 108.3,73.8 107.64,73.8 107.39,73.55 106.74,73.55 106.5,73.8 105.96,73.8 105.72,73.55 105.07,73.55 104.82,73.8 104.34,73.8 104.09,73.55 103.29,73.55 102.9,73.94 102.52,73.94 102.07,74.39 101.76,74.39 101.35,74.81 100.85,74.81 100.34,75.31 99.8,75.31 99.4,74.91 99.15,74.91 98.73,74.5 98.21,74.5 97.8,74.91 97.43,74.91 96.92,75.41 96.61,75.41 96.13,75.89 95.86,75.89 95.24,76.52 94.72,76.52 94.42,76.81 93.86,76.81 93.26,76.22 v4(93.26,75.93)
DDR4_DIMM_CH1_BG1: length 87.5
  L03_SIG1 w0.081: v4(118.89,105.06) 119.19,105.06 119.56,104.69 119.96,104.69 120.13,104.86 120.13,105.52 120.22,105.61 121.01,105.61 121.1,105.52 121.1,105.37 121.01,105.28 120.56,105.28 120.47,105.19 120.47,105.03 120.56,104.94 121.01,104.94 121.26,104.69 122.47,104.69 122.66,104.88 122.66,105.48 122.79,105.6 123.66,105.6 123.75,105.51 123.75,105.36 123.63,105.24 123.17,105.24 123.07,105.14 123.07,104.97 123.17,104.86 123.62,104.86 123.8,104.69 125.03,104.69 125.29,104.94 125.43,104.94 125.61,104.77 125.61,104.62 125.2,104.22 123.5,104.22 123.26,104.46 122.86,104.46 122.65,104.25 120.89,104.25 120.69,104.45 120.35,104.45 120.12,104.22 119.37,104.22 119.19,104.4 115.98,104.4 115.82,104.57 115.34,104.57 115.05,104.28 115.05,103.74 114.75,103.44 114.58,103.44 114.08,103.94 113.88,103.94 113.79,103.85 113.79,103.7 114.05,103.44 114.05,103.3 113.95,103.2 113.82,103.2 113.55,103.47 113.41,103.47 113.33,103.39 113.33,102.91 113.1,102.68 112.74,102.68 112.48,102.42 112.12,102.42 111.92,102.22 111.92,102.08 111.82,101.97 111.7,101.97 111.6,102.08 111.6,102.24 111.5,102.34 111.36,102.34 111.26,102.24 111.26,101.45 111.16,101.35 111.02,101.35 110.93,101.45 110.93,102.3 110.83,102.4 110.69,102.4 110.59,102.3 110.59,99.56 110.49,99.47 110.35,99.47 110.26,99.56 110.26,101.57 110.15,101.67 109.35,101.67 109.25,101.57 109.25,99.75 109.35,99.65 109.49,99.65 109.59,99.75 109.59,101.13 109.68,101.23 109.82,101.23 109.92,101.13 109.92,99.02 110.1,98.84 110.1,98.61 109.92,98.43 109.92,98.22 110.18,97.96 110.18,97.79 110.06,97.66 109.92,97.66 109.46,98.13 109.32,98.13 108.82,97.63 108.82,97.4 109.13,97.08 109.13,96.78 108.85,96.49 108.55,96.49 107.31,95.26 107.31,93.65 107.7,93.26 107.7,92.61 107.43,92.34 107.43,92.02 107.76,91.69 107.76,89.22 107.09,88.54 107.09,87.86 107.18,87.76 107.45,87.76 107.6,87.61 107.6,86.72 107.5,86.62 107.13,86.62 107.03,86.52 107.03,86.38 107.13,86.28 107.47,86.28 107.56,86.19 107.56,85.95 107.77,85.74 107.77,85.39 108.24,84.91 108.44,84.91 108.62,85.09 109.38,85.09 109.48,84.99 109.48,84.82 109.38,84.71 108.87,84.71 108.06,83.91 108.06,83.43 107.79,83.16 107.79,82.97 107.92,82.84 108.19,82.84 108.39,82.64 108.39,82.29 108.16,82.05 108.16,81.02 108.26,80.92 108.38,80.92 108.49,81.02 108.49,81.35 108.59,81.45 109.02,81.45 109.33,81.14 109.33,80.89 109.22,80.79 109.22,80.61 109.34,80.5 109.34,80.36 109.23,80.25 109.08,80.25 108.85,80.48 108.57,80.48 108.36,80.26 108.36,79.57 108.52,79.4 109.16,79.4 109.4,79.17 109.4,78.64 109.1,78.35 108.78,78.35 108.1,79.03 107.78,79.03 107.38,78.63 107.38,78.38 107.76,78.01 107.76,77.78 107.33,77.36 106.95,77.36 106.68,77.62 106.68,77.89 106.53,78.04 105.99,78.04 105.86,77.91 105.86,77.64 105.76,77.54 105.01,77.54 104.74,77.81 104.1,77.81 103.66,77.36 v4(103.66,76.93)
DDR4_DIMM_CH1_CK_N0: length 87.8
  L03_SIG1 w0.079: v1(129.09,99.27) 128.9,99.08 128.9,98.9 128.55,98.55 128.13,98.55 127.9,98.65 127.31,99.24 127.16,99.24 126.76,99.64 126.76,100.15 127.26,100.65 128.07,100.65 128.61,100.11 129.33,100.11 129.5,100.29 129.5,100.62 129.34,100.77 128.82,100.77 128.55,101.05 128.55,101.58 128.27,101.86 128.27,102.31 128.5,102.54 129.1,102.54 129.28,102.37 129.42,102.37 129.52,102.47 129.52,103.05 129.42,103.15 127.44,103.15 127.34,103.05 127.34,102.77 127.68,102.44 127.68,101.86 127.17,101.35 126.51,101.35 126.1,101.77 126.1,103.23 125.95,103.37 115.89,103.37 114.9,102.38 113.99,102.38 113.46,101.85 113.11,101.85 112.49,101.23 112.24,101.23 111.41,100.4 111.41,99.78 111.84,99.35 111.84,98.81 111,97.97 111,97.16 110.65,96.81 110.33,96.81 109.19,95.68 108.89,95.68 108.15,94.93 108.15,93.97 108.52,93.6 108.52,92.27 108.74,92.04 109.91,92.04 110.22,91.74 110.22,87.05 109.97,86.8 109.46,86.8 109.18,87.09 109.18,90.69 109.05,90.81 108.74,90.81 108.59,90.66 108.59,86.29 108.84,86.04 110.07,86.04 110.33,85.78 110.33,84.02 110.07,83.76 109.11,83.76 108.98,83.63 108.98,83.23 109.11,83.1 110.07,83.1 110.33,82.84 110.33,82.33 110.2,82.02 110.2,81.83 110.33,81.52 110.33,81.34 110.21,81.04 110.21,80.86 110.33,80.56 110.33,80.3 110.21,80 110.21,79.82 110.33,79.53 110.33,79.34 110.21,79.04 110.21,78.82 110.33,78.52 110.33,78.32 110.25,78.11 109.95,77.82 109.66,77.82 arc(109.55,77.79) 109.46,77.72 109.31,77.53 arc(109.12,77.37) 108.88,77.32 108.85,77.32 arc(108.69,77.28) 108.56,77.18 108.45,77.04 arc(108.25,76.88) 108,76.82 arc(107.82,76.78) 107.68,76.66 107.59,76.54 arc(107.38,76.38) 107.12,76.32 107.1,76.32 arc(106.85,76.38) 106.65,76.54 106.54,76.68 arc(106.41,76.78) 106.25,76.82 106.23,76.82 arc(106.09,76.79) 105.98,76.7 105.83,76.5 arc(105.66,76.37) 105.45,76.32 105.35,76.32 arc(105.12,76.37) 104.94,76.52 104.79,76.71 arc(104.69,76.79) 104.56,76.82 104.47,76.82 arc(104.35,76.79) 104.24,76.71 104.09,76.52 arc(103.91,76.37) 103.69,76.32 103.61,76.32 arc(103.39,76.37) 103.21,76.52 103.05,76.71 arc(102.96,76.79) 102.83,76.82 102.76,76.82 arc(102.63,76.79) 102.53,76.71 102.38,76.52 arc(102.2,76.37) 101.97,76.32 101.89,76.32 arc(101.77,76.29) 101.66,76.21 101.51,76.02 arc(101.33,75.87) 101.11,75.82 101.04,75.82 arc(100.83,75.86) 100.65,75.98 100.55,76.08 100.52,76.16 100.39,76.29 100.26,76.29 100.19,76.21 v4(100.19,75.93)
  BOTTOM w0.102: v1(129.09,99.27) 128.77,99.58 128.77,100.08 R679.2
DDR4_DIMM_CH1_CK_N1: length 4.1
  L05_SIG2 w0.079: v1(129.17,101.41) 128.87,101.41 128.77,101.51 128.77,104.74 v1(129.09,105.06)
DDR4_DIMM_CH1_CK_P0: length 87.8
  L03_SIG1 w0.079: v4(100.19,76.93) 100.19,76.6 100.27,76.51 100.48,76.51 100.71,76.28 100.74,76.21 100.81,76.14 arc(100.92,76.07) 101.04,76.05 101.11,76.05 arc(101.23,76.08) 101.33,76.16 101.48,76.35 arc(101.67,76.5) 101.89,76.55 101.97,76.55 arc(102.1,76.58) 102.2,76.66 102.35,76.85 arc(102.53,77) 102.76,77.05 102.83,77.05 arc(103.06,77) 103.23,76.85 103.39,76.66 arc(103.49,76.58) 103.61,76.55 103.69,76.55 arc(103.81,76.58) 103.91,76.66 104.06,76.85 arc(104.25,77) 104.47,77.05 104.56,77.05 arc(104.79,77) 104.97,76.85 105.12,76.66 arc(105.22,76.58) 105.35,76.55 105.45,76.55 arc(105.56,76.57) 105.65,76.64 105.8,76.84 arc(105.99,76.99) 106.23,77.05 106.25,77.05 arc(106.51,76.99) 106.72,76.82 106.83,76.68 arc(106.95,76.58) 107.1,76.55 107.12,76.55 arc(107.28,76.58) 107.41,76.69 107.5,76.8 arc(107.72,76.98) 108,77.05 arc(108.15,77.08) 108.27,77.18 108.38,77.32 arc(108.59,77.49) 108.85,77.55 108.88,77.55 arc(109.02,77.58) 109.13,77.67 109.28,77.86 arc(109.45,78) 109.66,78.05 109.86,78.05 110.05,78.24 110.1,78.36 110.1,78.47 109.98,78.77 109.98,79.08 110.1,79.38 110.1,79.48 109.98,79.78 109.98,80.05 110.1,80.34 110.1,80.51 109.98,80.81 109.98,81.08 110.1,81.38 110.1,81.47 109.98,81.78 109.98,82.07 110.1,82.37 110.1,82.75 109.98,82.87 109.01,82.87 108.75,83.13 108.75,83.72 109.01,83.98 109.98,83.98 110.1,84.11 110.1,85.68 109.98,85.81 108.74,85.81 108.36,86.19 108.36,90.76 108.65,91.04 109.14,91.04 109.4,90.78 109.4,87.18 109.56,87.03 109.87,87.03 109.99,87.14 109.99,91.64 109.82,91.82 108.65,91.82 108.29,92.17 108.29,93.5 107.92,93.88 107.92,95.03 108.8,95.91 109.1,95.91 110.23,97.04 110.55,97.04 110.77,97.26 110.77,98.06 111.61,98.91 111.61,99.26 111.19,99.68 111.19,100.5 112.15,101.46 112.4,101.46 113.02,102.08 113.36,102.08 113.9,102.61 114.8,102.61 115.8,103.6 126.05,103.6 126.33,103.32 126.33,101.86 126.61,101.58 127.07,101.58 127.45,101.96 127.45,102.34 127.11,102.67 127.11,103.15 127.35,103.38 129.52,103.38 129.75,103.15 129.75,102.37 129.52,102.14 129.18,102.14 129.01,102.32 128.6,102.32 128.5,102.21 128.5,101.95 128.77,101.67 128.77,101.15 128.92,101 129.44,101 129.73,100.71 129.73,100.19 129.42,99.88 128.51,99.88 127.97,100.42 127.35,100.42 126.99,100.05 126.99,99.73 127.25,99.47 127.4,99.47 128.02,98.85 128.18,98.78 128.46,98.78 128.67,99 128.67,99.16 128.57,99.27 v1(128.24,99.27)
  BOTTOM w0.102: v1(128.24,99.27) 128.54,99.57 128.54,100.08 R678.2
DDR4_DIMM_CH1_CK_P1: length 4.1
  L05_SIG2 w0.079: v1(128.15,101.41) 128.44,101.41 128.54,101.51 128.54,104.76 v1(128.24,105.06)
DDR4_DIMM_CH1_CKE0: length 83.9
  L07_SIG3 w0.089: v1(101.06,77.43) 100.87,77.24 100.87,76.26 101.48,75.65 101.48,74.76 101.8,74.44 102.04,74.44 102.34,74.14 102.34,73.7 102.13,73.49 101.68,73.49 101.11,74.05 101.11,74.27 100.21,75.17 100.21,76.97 100.57,77.85 100.57,78.01 100.45,78.3 100.45,78.57 100.57,78.86 100.57,79 100.44,79.31 100.44,79.55 100.57,79.85 100.57,79.99 100.44,80.3 100.44,80.94 100.23,81.16 100.23,81.42 100.36,81.56 100.62,81.56 100.72,81.66 100.72,81.8 100.62,81.9 100.3,81.9 100.2,82 100.2,82.14 100.3,82.24 100.62,82.24 100.72,82.34 100.72,82.48 100.62,82.58 100.3,82.58 100.2,82.68 100.2,87.1 100.44,87.33 100.44,87.51 100.2,87.74 100.2,87.92 100.31,88.03 100.31,89.73 100.12,89.92 100.12,90.12 100.28,90.28 100.55,90.28 100.65,90.18 100.65,87.97 100.75,87.87 100.9,87.87 101,87.97 101,88.89 101.1,88.99 101.24,88.99 101.34,88.89 101.34,87.82 101.44,87.72 101.58,87.72 101.68,87.82 101.68,89.63 101.52,89.8 101.21,89.8 101.1,89.9 101.1,90.04 101.21,90.14 101.56,90.14 101.66,90.24 101.66,90.38 101.56,90.48 101.18,90.48 101.08,90.58 101.08,90.72 101.18,90.83 101.58,90.83 101.78,91.03 101.93,91.03 102.03,90.93 102.03,87.64 102.13,87.54 102.27,87.54 102.51,87.78 102.51,88.14 102.37,88.29 102.37,88.56 102.62,88.81 102.62,89.01 102.37,89.26 102.37,91.13 102.47,91.23 102.61,91.23 102.71,91.13 102.71,89.92 102.81,89.82 102.95,89.82 103.05,89.92 103.05,91 103.19,91.14 103.19,91.48 102.98,91.69 102.24,91.69 101.92,92.01 101.92,92.33 102.06,92.47 103.16,92.47 103.29,92.34 103.29,91.93 103.39,91.83 103.53,91.83 103.63,91.93 103.63,92.37 103.74,92.47 104.32,92.47 104.51,92.28 104.86,92.28 104.97,92.39 104.97,92.66 104.81,92.81 102.34,92.81 102.24,92.91 102.24,93.05 102.34,93.15 105.06,93.15 105.27,92.94 106.95,92.94 107.06,92.84 107.06,92.7 106.95,92.6 105.44,92.6 105.34,92.5 105.34,92.35 105.44,92.25 107.41,92.25 107.51,92.35 107.51,92.84 107.61,92.94 108.09,92.94 108.19,92.84 108.19,92.35 108.29,92.25 109.33,92.25 109.43,92.35 109.43,92.5 109.33,92.6 108.78,92.6 108.68,92.7 108.68,92.84 108.78,92.94 109.61,92.94 110.01,93.35 110.63,93.35 111.44,94.15 111.44,94.3 111.3,94.45 111.3,94.65 111.67,95.02 112.3,95.02 112.6,94.73 113.26,94.73 113.69,95.16 113.69,95.61 114.01,95.93 114.19,95.93 114.32,95.8 114.51,95.8 114.64,95.93 114.95,95.93 115.21,95.68 115.35,95.68 115.45,95.78 115.45,95.92 115.29,96.08 115.29,96.22 115.39,96.32 115.53,96.32 115.69,96.16 115.83,96.16 115.93,96.26 115.93,96.41 115.78,96.56 115.78,96.7 116.34,97.27 116.34,98.98 v1(116.42,99.06)
DDR4_DIMM_CH1_CKE1: length 84.8
  L03_SIG1 w0.081: v1(115.49,105.06) 115.85,105.06 116.17,104.73 118.34,104.73 118.49,104.88 118.49,105.5 118.35,105.64 118.08,105.64 117.98,105.54 117.98,105.18 117.88,105.08 117.75,105.08 117.65,105.18 117.65,105.54 117.55,105.64 117.41,105.64 117.31,105.54 117.31,105.18 117.21,105.08 117.07,105.08 116.98,105.18 116.98,105.54 116.88,105.64 116.74,105.64 116.64,105.54 116.64,105.18 116.54,105.08 116.4,105.08 116.31,105.18 116.31,105.54 116.21,105.64 114.98,105.64 114.88,105.53 114.88,105.39 115.02,105.25 115.02,104.88 114.8,104.66 114.44,104.66 114.11,104.32 113.77,104.32 113.46,104.01 113.21,104.01 112.5,103.3 112.5,102.94 112.32,102.76 109.15,102.76 108.91,102.52 108.91,99.91 108.82,99.81 108.68,99.81 108.58,99.91 108.58,102.08 108.48,102.17 108.34,102.17 108.24,102.08 108.24,100.26 108.15,100.16 108.01,100.16 107.91,100.26 107.91,101.43 107.81,101.52 107.67,101.52 107.57,101.43 107.57,100.01 107.78,99.8 108.14,99.8 108.48,99.47 109.02,99.47 109.15,99.34 109.15,98.94 109.31,98.77 109.31,98.6 108.58,97.86 108.44,97.86 108.35,97.96 108.35,98.1 108.72,98.48 108.72,98.62 108.62,98.72 108.49,98.72 107.93,98.16 107.93,97.89 108.3,97.52 108.3,96.72 107.19,95.61 107.05,95.61 106.95,95.71 106.95,95.84 107.93,96.82 107.93,96.96 107.83,97.06 107.69,97.06 106.97,96.33 106.2,96.33 106.1,96.23 106.1,96.1 106.2,96 106.53,96 106.63,95.9 106.63,95.76 106.53,95.66 106.03,95.66 105.94,95.56 105.94,95.42 106.03,95.33 106.87,95.33 106.97,95.23 106.97,95.09 106.87,94.99 105.82,94.99 105.72,94.89 105.72,94.75 105.82,94.66 106.87,94.66 106.97,94.56 106.97,94.42 106.87,94.32 106.59,94.32 106.49,94.22 106.49,93.97 106.37,93.85 106.22,93.85 106.11,93.97 106.11,94.21 106,94.32 105.44,94.32 105.16,94.04 105.16,93.28 105.27,93.17 105.97,93.17 106.19,93.39 106.47,93.39 106.7,93.17 107.26,93.17 107.36,93.07 107.36,92.93 107.07,92.65 107.07,92.4 106.96,92.28 106.81,92.28 106.7,92.4 106.7,92.68 106.55,92.83 105.38,92.83 105.28,92.74 105.28,92.6 105.38,92.5 106.11,92.5 106.78,91.83 107.13,91.83 107.42,91.54 107.42,91.11 107.2,90.9 106.75,90.9 106.65,90.8 106.65,90.6 106.75,90.5 107.31,90.5 107.41,90.4 107.41,90.24 107.31,90.14 106.75,90.14 106.63,90.02 106.63,89.85 106.72,89.75 106.92,89.75 107.02,89.65 107.02,89.51 106.92,89.42 106.72,89.42 106.63,89.32 106.63,89.18 106.72,89.08 106.81,89.08 106.9,88.98 106.9,88.84 106.81,88.74 106.72,88.74 106.63,88.65 106.63,87.51 106.77,87.37 107.12,87.37 107.22,87.26 107.22,87.07 107.12,86.96 106.78,86.96 106.63,86.81 106.63,86.24 107.26,85.61 107.26,85.41 107.61,85.06 107.61,83.52 107.31,83.21 107.31,82.47 107.57,82.21 107.57,81.94 107.66,81.85 107.75,81.85 107.85,81.75 107.85,81.61 107.75,81.51 107.66,81.51 107.57,81.41 107.57,81.27 107.66,81.18 107.75,81.18 107.85,81.08 107.85,80.94 107.75,80.84 107.66,80.84 107.57,80.74 107.57,79.77 107.2,79.41 107.02,79.41 106.51,78.9 106.02,78.9 105.61,78.49 105.29,78.49 104.85,78.05 104.18,78.05 103.9,78.33 103.53,78.33 103,77.8 102.62,77.8 102.13,77.31 101.77,77.31 101.06,76.59 v4(101.06,76.43)
DDR4_DIMM_CH1_CS_N0: length 86.2
  L07_SIG3 w0.089: v1(102.79,77.43) 102.58,77.64 102.58,77.95 102.4,78.37 102.4,78.5 102.56,78.87 102.56,79 102.4,79.37 102.4,79.52 102.52,79.8 102.52,80.05 102.4,80.33 102.4,80.58 102.72,80.89 102.72,82.74 103.77,83.79 103.77,84.83 104.23,85.28 104.23,85.59 104.91,86.27 104.91,86.75 105.95,87.78 105.95,89.77 106.15,89.97 110.45,89.97 113.21,91.12 113.41,91.31 113.41,91.64 114.11,92.34 114.34,92.9 115.04,93.59 115.7,93.59 117.84,95.74 118.46,95.74 118.93,96.21 118.93,96.88 119.32,97.27 119.32,97.57 118.72,98.17 118.72,98.97 118.87,99.12 120.22,99.12 121.78,100.68 122.57,100.68 122.86,100.97 122.86,101.55 123.21,101.91 123.61,101.91 124.25,102.55 124.79,102.55 124.89,102.65 124.89,102.8 124.79,102.9 124.59,102.9 124.49,103 124.49,103.14 124.59,103.24 125.21,103.24 125.31,103.14 125.31,102.65 125.41,102.55 125.91,102.55 126.17,102.81 126.17,103.14 126.64,103.61 127.67,103.61 127.99,103.94 130.13,103.94 130.72,104.53 131.01,104.53 131.23,104.75 131.23,105.15 131.55,105.47 135.74,105.47 135.85,105.37 135.85,105.22 135.74,105.12 134.27,105.12 134.16,105.02 134.16,104.88 134.27,104.78 135.73,104.78 136.99,103.53 137.77,103.53 138.56,104.32 139.74,104.32 140.3,104.87 140.3,108.42 140.69,108.81 145.65,108.81 145.8,108.66 145.8,105.19 144.87,104.26 144.87,102.29 144.05,101.47 144.05,99.59 143.95,99.49 142.24,99.49 v1(141.84,99.09)
DDR4_DIMM_CH1_CS_N1: length 85.3
  L03_SIG1 w0.081: v4(99.32,77.43) 100.47,77.43 100.85,77.8 101.38,77.8 101.63,77.55 102.07,77.55 102.58,78.06 102.95,78.06 103.45,78.55 103.88,78.55 104.33,79 104.69,79 105.17,79.47 105.62,79.47 106.07,79.93 106.34,79.93 106.72,80.31 106.72,81.05 106.84,81.17 106.84,81.69 106.74,81.79 106.74,82.08 106.97,82.31 106.97,83.3 107.28,84.04 107.28,84.91 106.92,85.27 106.92,85.47 106.29,86.11 106.29,90.99 106.52,91.22 106.52,91.62 105.97,92.16 105.23,92.16 104.82,92.57 104.82,94.18 105.36,94.71 105.36,95.03 105.6,95.28 105.6,96.23 106.04,96.67 106.42,96.67 106.8,97.05 107.14,97.05 107.45,97.36 107.45,98.15 108.22,98.92 108.22,99.25 108,99.47 107.64,99.47 107.24,99.87 107.24,101.6 108.73,103.09 111.82,103.09 113.07,104.34 113.32,104.34 113.65,104.68 113.97,104.68 114.18,104.89 114.18,105.21 113.95,105.44 113.95,105.65 114.27,105.97 118.59,105.97 119.08,105.49 119.44,105.49 119.93,105.97 121.26,105.97 121.42,105.82 121.42,105.66 121.59,105.49 122.01,105.49 122.46,105.94 123.86,105.94 124.31,105.49 125.37,105.49 126.88,103.98 130.3,103.98 130.81,104.49 131.04,104.49 131.36,104.81 131.36,105.21 132.1,105.95 135.98,105.95 136.44,105.49 136.97,105.49 137.18,105.28 137.18,103.99 137.29,103.73 137.51,103.51 142.72,103.51 143.49,102.75 143.49,99.82 143.17,99.51 143.17,98.91 143.39,98.69 145.72,98.69 v4(146.09,99.06)
DDR4_DIMM_CH1_DBI_N0: length 51.2
  L05_SIG2 w0.079: v1(95,81.93) 95,81.64 94.89,81.54 94.8,81.54 94.71,81.63 94.6,81.88 94.6,82 94.75,82.34 94.75,83.31 94.49,83.57 94.49,84.84 94.08,85.25 93.53,85.25 93.33,85.05 93,85.05 92.65,85.4 92.65,85.71 93.16,86.22 93.16,86.61 92.72,87.05 91.99,87.05 91.68,87.36 91.68,88.06 90.78,88.96 90.19,88.96 88.02,91.14 87.78,91.14 86.78,92.14 86.04,92.14 84.84,93.33 83.75,93.33 83.45,93.63 83.45,94.4 83.08,94.77 82.33,94.77 81.72,95.38 77.11,95.38 76.93,95.56 76.93,95.78 77.11,95.97 79.91,95.97 80.17,96.23 80.17,96.75 79.91,97.01 76.36,97.01 75.59,96.24 75.27,96.24 74.18,97.33 74.18,97.73 74.39,97.93 74.39,99.33 73.86,99.86 73.86,101.91 73.09,102.68 71.53,102.68 71.06,102.21 71.06,100.2 71.62,99.64 71.62,99.39 v1(71.29,99.06)
DDR4_DIMM_CH1_DBI_N1: length 40.4
  L03_SIG1 w0.079: v4(95,79.93) 94.85,79.79 94.85,79.64 94.97,79.52 95.12,79.52 95.31,79.71 95.37,79.86 95.37,80.02 95.26,80.28 95.26,80.55 95.39,80.86 95.39,80.96 95.32,81.13 95.2,81.26 95.03,81.32 94.88,81.32 94.66,81.41 94.49,81.59 94.39,81.82 94.39,82.07 94.51,82.35 94.51,82.57 91.39,85.69 91.39,87.88 90.97,88.3 90.69,88.3 90.06,87.67 89.72,87.67 89.24,88.15 89.24,88.48 89.88,89.12 89.88,89.39 88.48,90.79 87.81,90.79 87.54,91.05 87.54,91.55 88.51,92.52 88.51,92.89 88.33,93.07 87.44,93.07 86.81,92.43 85.81,92.43 84.81,93.43 84.81,94.43 85.16,94.78 86.7,94.78 86.9,94.98 86.9,95.32 86.7,95.52 84.26,95.52 83.97,95.23 83.97,94.36 83.69,94.07 83.17,94.07 82.88,94.36 82.88,96.11 82.2,96.79 81.22,96.79
  L03_SIG1 w0.081: 81.22,96.79 80.7,97.3 80.7,98.05 80.91,98.25 80.91,98.8 v4(80.64,99.06)
DDR4_DIMM_CH1_DBI_N2: length 41.6
  L05_SIG2 w0.079: v1(101.06,79.43) 101.06,79.14 101.16,79.04 101.26,79.04 101.35,79.13 101.44,79.36 101.44,79.49 101.31,79.82 101.31,80.04 101.43,80.33 101.43,80.64 101.2,80.87 101.2,82.74 101.43,83.3 101.43,83.59 101.28,83.74 101.28,83.97 101.43,84.12 101.43,85.96 102.15,86.68 102.15,90.13 100.38,91.9 100.38,92.41 100.74,92.77 101.21,92.77 101.57,93.13 101.57,94.41 100.09,95.89 99.91,95.89 99.67,95.66 99.67,95.48 100.97,94.18 100.97,93.81 100.6,93.45 100.23,93.45 98.51,95.16 96.65,95.16 96.39,95.42 96.39,95.95 96.65,96.21 98.15,96.21 98.31,96.37 98.31,96.63 98.15,96.79 95.34,96.79 94.69,96.14 93.79,96.14 91.82,98.11 90.62,98.11 90.3,98.43 90.3,98.75 v1(89.99,99.06)
DDR4_DIMM_CH1_DBI_N3: length 30.5
  L03_SIG1 w0.079: v4(101.06,82.43) 101.06,82.14 101.16,82.04 101.25,82.04 101.34,82.13 101.43,82.35 101.43,82.63 101.22,82.84 101.22,83.02 101.43,83.23 101.43,84.82 100.43,85.81 100.43,87.09 100.34,87.18 100.07,87.18 99.77,87.48 99.77,87.92 100.07,88.22 101.12,88.22 101.28,88.38 101.28,88.65 101.12,88.81 99.03,88.81 98.73,89.11 98.73,89.88 98.99,90.15 99.6,90.15 99.73,90.28 99.73,90.6 99.6,90.73 99.03,90.73 98.73,91.04 98.73,91.84 99.61,92.72 99.61,93.45 99.39,93.66 98.49,93.66 98.19,93.96 98.19,94.41 98.49,94.71 99.47,94.71 99.61,94.84 99.61,95.16 99.47,95.29 98.23,95.29 97.94,95.58 97.94,96.05 98.23,96.34 99.48,96.34 99.73,96.59 99.73,97.04 99.52,97.24 99.22,97.24 98.81,97.65 98.81,98.18 99.04,98.41 99.54,98.41 99.65,98.52 99.65,98.75 v4(99.34,99.06)
DDR4_DIMM_CH1_DBI_N4: length 75
  L07_SIG3 w0.085: v1(107.12,74.93) 107.12,74.63 107.21,74.54 107.31,74.54 107.41,74.63 107.5,74.85 107.5,74.99 107.37,75.31 107.37,75.54 107.5,75.86 107.5,76.03 107.38,76.31 107.38,76.55 107.5,76.83 107.5,77.02 107.38,77.31 107.38,77.54 107.5,77.83 107.5,78.02 107.38,78.3 107.38,78.56 107.5,78.84 107.5,79.02 107.38,79.3 107.38,79.56 107.51,79.86 107.51,79.97 107.38,80.28 107.38,80.49 arc(107.41,80.67) 107.51,80.82 107.6,80.9 arc(107.74,81) 107.91,81.03 arc(108.13,81.08) 108.31,81.23 108.41,81.35 arc(108.59,81.49) 108.81,81.54 108.86,81.54 arc(109.02,81.58) 109.15,81.68 109.27,81.84 arc(109.44,81.98) 109.66,82.03 arc(109.86,82.08) 110.03,82.21 110.18,82.4 112.55,84.78 112.55,85.66 112.93,86.04 113.5,86.04 114.18,86.71 114.46,86.9 114.8,87.04 115.97,87.04 117.75,88.82 118.51,89.14 120.4,91.02 122.7,91.02 123.75,92.07 124.98,92.07 125.7,92.79 126.38,92.79 126.73,92.44 126.73,91.68 126.89,91.51 127.33,91.51 127.83,92.02 127.83,92.47 128.15,92.79 129.3,92.79 130.81,94.3 133.55,94.3 133.89,93.97 133.89,93.47 133.59,93.18 131.53,93.18 131.4,93.05 131.4,92.54 131.53,92.41 135.39,92.41 136.3,93.32 136.3,94.01 136.64,94.35 138.92,94.35 139.22,94.05 139.22,93.16 139.39,92.99 139.85,92.99 140.02,93.16 140.02,94.01 140.35,94.35 145.14,94.35 145.88,95.1 147.48,95.1 148.36,95.98 148.79,95.98 149.79,96.98 150.51,96.98 151.58,98.05 153.38,98.05 153.78,97.65 154.45,97.65 154.97,98.18 154.97,98.68 v1(154.59,99.06)
