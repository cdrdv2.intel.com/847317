# Allegro board TS28247BC0_FM61_agilex_PCIe_DEVKIT_ADI_REVB1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_DIMM_CH1_TDQS_N17: length 55.9
  L07_SIG3 w0.085: v1(95,73.93) 95.29,74.3 95.48,74.49 95.6,74.79 95.6,75.04 95.32,75.74 95.32,75.98 94.74,76.56 94.74,77.53 94.6,77.85 94.6,79.71 94.73,79.84 94.73,80.56 94.62,80.84 94.62,81 94.73,81.28 94.73,81.56 94.62,81.83 94.62,82.01 94.74,82.3 94.74,82.89 93.48,84.15 93.48,84.67 93.73,84.92 93.73,90.75 93.42,91.06 92.98,91.06 92.67,90.75 92.67,88.16 92.55,88.03 92.21,88.03 92.08,88.16 92.08,91.51 92.34,91.77 92.34,92.31 94.35,94.31 94.64,94.31 94.75,94.2 94.75,93.87 93.4,92.52 93.4,92.05 93.64,91.81 94.18,91.81 96.86,94.49 96.86,94.98 95.84,96 95.84,96.28 96.04,96.49 96.32,96.49 97.33,95.48 98.04,95.48 98.61,96.06 98.61,96.68 99.77,97.83 107.96,97.83 108.9,98.78 109.09,98.9 v1(109.54,99.09)
DDR4_DIMM_CH2_A0: length 95.5
  L03_SIG1 w0.081: v4(121.44,32.42) 121.44,31.17 121.34,31.07 121.12,31.07 121.02,31.17 121.02,31.63 120.85,31.8 120.43,31.8 120.21,31.58 120.21,31.09 119.88,30.76 119.88,30.12 119.6,29.84 119.6,28.31 119.71,28.2 119.85,28.2 119.95,28.3 119.95,29.55 120.05,29.65 120.18,29.65 120.28,29.55 120.28,28.29 120.38,28.19 120.52,28.19 120.62,28.29 120.62,29.86 120.22,30.26 120.22,30.6 120.46,30.85 120.72,30.85 120.97,30.6 120.97,28.81 121.07,28.71 121.2,28.71 121.3,28.81 121.3,30.61 121.41,30.71 121.54,30.71 121.64,30.61 121.64,28.83 121.74,28.72 121.87,28.72 121.97,28.83 121.97,30.4 122.08,30.5 122.21,30.5 122.31,30.4 122.31,27.27 122.99,26.58 123.47,26.58 123.57,26.69 123.57,26.82 123.47,26.92 123.19,26.92 123.08,27.02 123.08,27.15 123.19,27.25 124.19,27.25 124.29,27.36 124.29,27.49 124.19,27.59 122.86,27.59 122.66,27.78 122.66,30.71 122.51,30.87 121.99,30.87 121.84,31.02 121.84,32.63 121.48,32.98 120.68,32.98 120.58,33.08 120.58,33.29 120.68,33.39 121.43,33.39 121.53,33.49 121.53,33.63 121.43,33.73 120.65,33.73 120.54,33.83 120.54,33.96 120.65,34.06 121.45,34.06 121.55,34.17 121.55,34.3 121.45,34.4 120.63,34.4 120.53,34.5 120.53,34.63 120.63,34.73 121.49,34.73 121.59,34.84 121.59,34.97 121.49,35.07 120.58,35.07 120.47,35.17 120.47,35.32 120.58,35.42 121.38,35.42 121.48,35.52 121.48,35.65 121.38,35.75 120.34,35.75 120.24,35.85 120.24,35.99 120.34,36.09 121.38,36.09 121.48,36.19 121.48,36.32 121.38,36.42 120.59,36.42 120.49,36.52 120.49,36.66 120.59,36.76 121.67,36.76 121.77,36.86 121.77,36.99 121.67,37.09 120.69,37.09 120.59,37.2 120.59,37.33 120.69,37.43 123.09,37.43 123.19,37.53 123.19,37.67 123.09,37.76 122.08,37.76 121.98,37.86 121.98,38 122.08,38.1 123.11,38.1 123.21,38.2 123.21,38.34 123.11,38.44 122.31,38.44 122.21,38.53 122.21,38.67 122.31,38.77 123.34,38.77 123.44,38.87 123.44,39.01 123.34,39.11 121.77,39.11 121.67,39.2 121.67,39.34 121.77,39.44 123.11,39.44 123.21,39.54 123.21,39.68 123.11,39.78 121.77,39.78 121.67,39.87 121.67,40.01 121.77,40.11 123.1,40.11 123.2,40.21 123.2,40.35 123.1,40.45 121.77,40.45 121.67,40.54 121.67,40.68 121.77,40.78 123.3,40.78 123.4,40.88 123.4,41.02 123.3,41.12 122.32,41.12 122.22,41.22 122.22,41.35 122.32,41.45 123,41.45 123.5,41.95 123.78,41.95 124.26,42.43 124.65,42.43 125.17,42.95 125.48,42.95 125.69,43.16 125.69,47.65 125.42,47.92 125.08,47.92 124.45,48.55 124.26,48.55 123.84,48.97 123.32,48.97 122.85,49.44 122.48,49.44 122.01,49.91 121.64,49.91 121.13,49.4 120.81,49.4 120.37,48.95 119.96,48.95 119.61,49.3 119.08,49.3 118.62,48.83 118.14,48.83 117.59,49.37 117.24,49.37 116.93,49.05 115.91,49.05 v4(115.78,48.93)
DDR4_DIMM_CH2_A1: length 96.6
  L03_SIG1 w0.081: v4(132.49,32.42) 132.47,32.44 132.47,33.39 133.1,34.02 133.1,35.99 133,36.09 132.87,36.09 132.77,35.99 132.77,34.18 132.67,34.08 132.53,34.08 132.43,34.18 132.43,34.87 132.33,34.97 132.2,34.97 132.1,34.87 132.1,32.89 132.01,32.81 129.97,32.81 129.87,32.91 129.87,33.04 129.97,33.14 130.6,33.14 130.7,33.24 130.7,33.38 130.6,33.48 129.9,33.48 129.75,33.64 129.33,33.64 129.16,33.46 129.16,33.07 129.56,32.67 129.56,31.84 129.46,31.74 129.33,31.74 129.22,31.84 129.22,32.47 129.12,32.57 128.99,32.57 128.89,32.47 128.89,31.9 128.79,31.79 127.95,31.79 127.84,31.9 127.84,33.84 127.95,33.94 128.26,33.94 128.36,33.84 128.36,33.03 128.47,32.93 128.68,32.93 128.78,33.03 128.78,33.87 128.89,33.97 129.56,33.97 129.66,34.07 129.66,34.21 129.56,34.31 128.47,34.31 128.37,34.41 128.37,34.58 128.47,34.68 129.63,34.68 129.73,34.78 129.73,34.91 129.63,35.01 129.21,35.01 129.11,35.11 129.11,35.25 129.21,35.35 129.46,35.35 129.57,35.45 129.57,35.58 129.46,35.68 129.08,35.68 128.98,35.79 128.98,35.92 129.08,36.02 129.92,36.02 130.07,35.87 130.07,35.31 130.25,35.13 130.25,34.74 130.07,34.57 130.07,33.94 130.18,33.83 131.22,33.83 131.41,33.64 131.41,33.41 131.52,33.3 131.64,33.3 131.74,33.4 131.74,34.06 131.64,34.16 130.52,34.16 130.42,34.27 130.42,34.4 130.52,34.5 131.65,34.5 131.75,34.6 131.75,34.73 131.65,34.83 130.84,34.83 130.74,34.94 130.74,35.07 130.84,35.17 131.74,35.17 131.85,35.27 131.85,35.4 131.74,35.5 130.97,35.5 130.86,35.61 130.86,35.74 130.97,35.84 132.29,35.84 132.39,35.94 132.39,36.09 132.29,36.19 130.27,36.19 130.17,36.29 130.17,36.43 130.27,36.53 133.03,36.53 133.13,36.64 133.13,36.78 133.03,36.88 130.82,36.88 130.71,36.98 130.71,37.12 130.82,37.22 131.76,37.22 131.86,37.32 131.86,37.45 131.76,37.55 130.91,37.55 130.81,37.65 130.81,37.79 130.91,37.89 131.9,37.89 132,37.99 132,38.12 131.9,38.22 130.98,38.22 130.88,38.32 130.88,38.46 130.98,38.56 131.51,38.56 131.61,38.66 131.61,38.79 131.51,38.89 130.07,38.89 129.97,38.99 129.97,39.13 130.07,39.23 131.34,39.23 131.44,39.33 131.44,39.46 131.34,39.56 130.07,39.56 129.97,39.67 129.97,39.8 130.07,39.9 131.34,39.9 131.44,40 131.44,40.13 131.34,40.23 130.09,40.23 129.99,40.34 129.99,40.47 130.09,40.57 131.36,40.57 131.47,40.67 131.47,40.81 131.36,40.91 130.86,40.91 130.75,41.01 130.75,41.14 130.86,41.24 131.2,41.24 131.3,41.35 131.3,41.49 131.2,41.59 131.01,41.59 130.92,41.68 130.92,47.7 130.68,47.94 130.3,47.94 129.83,48.41 129.43,48.41 128.89,48.95 128.49,48.95 127.97,49.46 127.64,49.46 127.14,49.96 126.8,49.96 126.35,50.41 125.96,50.41 125.4,50.97 125.07,50.97 124.62,51.43 124.13,51.43 123.75,51.8 123.31,51.8 123.06,51.55 122.25,51.55 122,51.8 121.38,51.8 121.13,51.55 120.55,51.55 120.3,51.8 119.65,51.8 119.41,51.55 119.05,51.55 118.51,51.01 118.21,51.01 117.75,50.55 117.3,50.55 116.79,50.04 115.89,50.04 v4(115.78,49.93)
DDR4_DIMM_CH2_A2: length 91.9
  L14_SIG5 w0.081: v1(116.65,49.43) 117.1,48.97 117.1,48.8 117.35,48.56 117.68,48.56 118.13,49.01 118.13,50.15 117.73,50.55 115.66,50.55 115.16,50.05 114.7,50.05 114.33,50.42 113.9,50.42 113.43,49.95 113.02,49.95 112.54,50.43 112.18,50.43 111.81,50.05 111.14,50.05 110.8,50.39 110.42,50.39 110.13,50.11 110.13,48.71 110.41,48.43 110.76,48.43 111.28,47.91 111.6,47.91 112.07,47.45 112.44,47.45 112.77,47.12 112.77,41.65 112.33,41.21 112.33,40.69 112.23,40.59 111.17,40.59 111.07,40.49 111.07,40.33 111.17,40.23 111.87,40.23 111.97,40.12 111.97,39.96 111.87,39.86 111.19,39.86 111.07,39.73 111.07,36.92 111.16,36.82 111.63,36.82 111.73,36.72 111.73,36.58 111.63,36.48 111.16,36.48 111.07,36.39 111.07,33.78 110.89,33.6 110.89,32.87 111.07,32.69 111.07,32.16 111.33,31.9 111.33,31.1 111.07,30.83 111.07,29.93 111.29,29.7 111.29,26.92 111.57,26.64 112.29,26.64 112.39,26.55 112.39,26.13 112.49,26.03 112.63,26.03 112.73,26.13 112.73,26.55 112.82,26.64 112.96,26.64 113.06,26.55 113.06,26.13 113.16,26.03 113.3,26.03 113.4,26.13 113.4,26.55 113.49,26.64 113.63,26.64 113.73,26.55 113.73,26.13 113.83,26.03 113.97,26.03 114.07,26.13 114.07,26.55 114.16,26.64 114.3,26.64 114.4,26.55 114.4,26.13 114.5,26.03 114.64,26.03 114.74,26.13 114.74,26.55 114.84,26.64 114.97,26.64 115.07,26.55 115.07,26.13 115.17,26.03 115.8,26.03 115.89,26.13 115.89,26.6 115.99,26.7 116.14,26.7 116.23,26.6 116.23,26.13 116.33,26.03 116.84,26.03 117.01,25.86 117.01,25.3 117.1,25.21 117.25,25.21 117.34,25.3 117.34,25.92 117.45,26.03 117.85,26.03 117.95,26.13 117.95,26.59 118.05,26.69 118.19,26.69 118.29,26.59 118.29,25.67 118.38,25.57 118.52,25.57 118.62,25.67 118.62,26.61 118.72,26.71 118.86,26.71 118.96,26.61 118.96,26.1 119.05,26.01 119.27,26.01 119.35,26.1 119.35,26.69 119.48,26.82 120.93,26.82 121.07,26.68 121.78,26.68 121.87,26.59 121.87,26.43 121.78,26.34 121.06,26.34 120.97,26.25 120.97,26.04 121.06,25.95 121.32,25.95 121.44,25.83 121.44,25.27 121.54,25.17 121.68,25.17 121.78,25.27 121.78,25.92 121.87,26.02 122.01,26.02 122.11,25.92 122.11,25.28 122.21,25.19 122.35,25.19 122.45,25.28 122.45,26.01 122.55,26.11 122.68,26.11 122.78,26.01 122.78,25.3 122.88,25.2 123.02,25.2 123.12,25.3 123.12,26.01 123.22,26.11 123.35,26.11 123.45,26.01 123.45,25.58 123.55,25.48 123.69,25.48 123.79,25.58 123.79,26.01 123.89,26.11 124.03,26.11 124.12,26.01 124.12,25.03 124.22,24.93 124.36,24.93 124.46,25.03 124.46,26.01 124.56,26.11 124.7,26.11 124.79,26.01 124.79,25.05 124.89,24.96 125.03,24.96 125.13,25.05 125.13,26.01 125.23,26.11 125.37,26.11 125.46,26.01 125.46,25.01 125.56,24.91 125.7,24.91 125.8,25.01 125.8,26.01 125.9,26.11 126.04,26.11 126.14,26.01 126.14,25.36 126.23,25.26 126.37,25.26 126.47,25.36 126.47,25.59 126.59,25.71 128.59,25.71 128.89,26.01 129.72,26.01 129.88,25.85 130.22,25.85 130.38,26.01 130.72,26.01 130.87,25.85 131.21,25.85 131.37,26.01 131.73,26.01 131.88,25.86 133.29,25.86 133.39,25.95 133.39,26.15 133.29,26.26 132.65,26.26 v1(132.49,26.42)
DDR4_DIMM_CH2_A3: length 96.7
  L03_SIG1 w0.081: v4(116.65,50.43) 116.96,50.74 116.96,51.03 117.34,51.42 117.63,51.42 118.08,51.87 118.43,51.87 118.89,52.33 119.67,52.33 119.95,52.05 120.55,52.05 120.83,52.33 121.4,52.33 121.68,52.05 122.3,52.05 122.57,52.33 123.1,52.33 123.38,52.05 124.01,52.05 124.29,52.33 124.69,52.33 125.07,51.95 125.41,51.95 125.94,51.41 126.37,51.41 126.86,50.93 127.18,50.93 127.68,50.43 128.06,50.43 128.55,49.94 128.9,49.94 129.41,49.43 129.76,49.43 130.23,48.95 130.61,48.95 131.11,48.45 131.51,48.45 131.78,48.17 131.78,41.22 132,41.01 132.58,41.01 132.68,41.11 132.68,44.26 132.78,44.36 133.38,44.36 133.48,44.26 133.48,40.8 133.36,40.67 131.9,40.67 131.8,40.58 131.8,40.44 131.9,40.34 132.75,40.34 132.85,40.24 132.85,40.1 132.75,40 131.86,40 131.76,39.9 131.76,39.77 131.86,39.67 133.48,39.67 133.58,39.57 133.58,39.43 133.48,39.33 131.88,39.33 131.78,39.23 131.78,39.1 131.88,39 132.66,39 132.81,38.85 132.81,37.37 132.91,37.27 133.05,37.27 133.14,37.37 133.14,38.88 133.24,38.98 133.38,38.98 133.48,38.88 133.48,33.4 133.58,33.3 133.71,33.3 133.81,33.4 133.81,33.93 133.92,34.03 134.05,34.03 134.15,33.93 134.15,33.43 134.25,33.33 134.38,33.33 134.48,33.43 134.48,35.71 134.58,35.8 134.72,35.8 134.82,35.71 134.82,33.62 134.92,33.52 135.06,33.52 135.16,33.62 135.16,35.04 135.25,35.14 135.39,35.14 135.49,35.04 135.49,33.7 135.59,33.6 135.73,33.6 135.83,33.7 135.83,35 135.92,35.1 136.06,35.1 136.16,35 136.16,33.49 136.26,33.39 136.4,33.39 136.5,33.49 136.5,35.23 136.59,35.32 136.73,35.32 136.83,35.23 136.83,33.4 136.93,33.3 137.07,33.3 137.17,33.4 137.17,35.24 137.27,35.34 137.4,35.34 137.5,35.24 137.5,34.1 137.6,34 137.74,34 137.84,34.1 137.84,35.24 137.94,35.34 138.07,35.34 138.17,35.24 138.17,34.1 138.27,34 138.41,34 138.51,34.1 138.51,34.81 138.61,34.91 140.34,34.91 140.44,34.81 140.44,34.64 140.34,34.54 138.98,34.54 138.88,34.44 138.88,34.3 138.98,34.2 140.34,34.2 140.44,34.1 140.44,33.97 140.34,33.87 138.95,33.87 138.85,33.77 138.85,33.63 138.95,33.53 140.08,33.53 140.18,33.43 140.18,33.3 140.08,33.2 138.71,33.2 138.28,33.63 137.76,33.63 137.63,33.5 137.63,33.02 137.44,32.83 133.76,32.83 v4(133.34,32.42)
DDR4_DIMM_CH2_A4: length 92
  L14_SIG5 w0.081: v1(117.51,48.93) 117.89,49.3 117.89,50.08 117.67,50.3 116.37,50.3 115.88,49.81 114.75,49.81 114.26,49.32 113.91,49.32 113.62,49.03 112.94,49.03 112.57,49.41 112.1,49.41 111.71,49.8 111.23,49.8 111.02,49.59 111.02,49.08 111.2,48.9 111.7,48.9 112.22,48.39 112.56,48.39 113.02,47.93 113.35,47.93 113.61,47.66 113.61,41.31 113.16,40.86 112.96,40.86 112.76,40.67 112.76,40.23 112.63,40.1 112.42,40.1 112.32,40 112.32,39.86 112.42,39.76 112.68,39.76 112.78,39.66 112.78,39.53 112.68,39.43 111.51,39.43 111.41,39.33 111.41,39.19 111.51,39.09 112.99,39.09 113.09,38.99 113.09,38.86 112.99,38.76 111.92,38.76 111.82,38.66 111.82,38.52 111.92,38.42 113.11,38.42 113.21,38.32 113.21,38.18 113.11,38.09 111.64,38.09 111.54,37.99 111.54,37.85 111.64,37.75 113.09,37.75 113.19,37.65 113.19,37.51 113.09,37.42 111.94,37.42 111.84,37.32 111.84,37.18 111.94,37.08 112.98,37.08 113.08,36.98 113.08,36.84 112.98,36.75 112.19,36.75 112.09,36.65 112.09,36.51 112.19,36.41 112.73,36.41 112.83,36.31 112.83,36.17 112.73,36.07 111.57,36.07 111.47,35.98 111.47,35.84 111.57,35.74 112.72,35.74 112.81,35.64 112.81,35.5 112.72,35.4 111.52,35.4 111.42,35.31 111.42,35.17 111.52,35.07 111.98,35.07 112.08,34.97 112.08,34.83 111.98,34.73 111.52,34.73 111.42,34.64 111.42,34.5 111.52,34.4 111.98,34.4 112.08,34.3 112.08,34.16 111.98,34.06 111.52,34.06 111.42,33.96 111.42,33.83 111.52,33.73 111.98,33.73 112.08,33.63 112.08,33.49 111.98,33.39 111.78,33.39 111.68,33.29 111.68,33.16 111.78,33.06 112.15,33.06 112.25,32.96 112.25,32.82 112.15,32.72 111.52,32.72 111.42,32.62 111.42,32.48 111.52,32.39 112.1,32.39 112.19,32.3 112.19,31.92 112.1,31.83 111.79,31.83 111.71,31.74 111.71,31.13 111.79,31.04 112.11,31.04 112.23,30.92 112.23,30.7 112.13,30.6 111.95,30.6 111.85,30.5 111.85,30.36 111.95,30.26 112.13,30.26 112.23,30.16 112.23,29.89 112.14,29.8 111.86,29.8 111.68,29.62 111.68,27.13 111.77,27.04 111.96,27.04 112.05,27.13 112.05,27.94 112.13,28.03 112.35,28.03 112.44,27.94 112.44,27.11 112.57,26.99 114.2,26.99 114.29,27.07 114.29,27.23 114.2,27.32 113.43,27.32 113.34,27.41 113.34,27.57 113.43,27.66 113.83,27.66 113.92,27.75 113.92,27.9 113.83,27.99 112.87,27.99 112.78,28.08 112.78,28.24 112.87,28.33 114.13,28.33 114.23,28.23 114.23,28.06 114.36,27.92 115.68,27.92 115.97,27.63 115.97,27.47 115.88,27.38 115.1,27.38 115.01,27.29 115.01,27.13 115.1,27.05 119.21,27.05 119.34,27.17 121.05,27.17 121.18,27.04 121.64,27.04 121.87,27.26 122.12,27.26 122.94,26.44 126.49,26.44 126.88,26.05 128.44,26.05 128.85,26.45 129.17,26.45 129.52,26.8 131.13,26.8 131.24,26.69 131.24,26.48 131.35,26.38 131.92,26.38 132.36,26.82 132.63,26.82 132.81,26.64 133.4,26.64 134,26.04 134.42,26.04 134.51,26.13 134.51,26.33 134.42,26.42 v1(134.19,26.42)
DDR4_DIMM_CH2_A5: length 92.2
  L14_SIG5 w0.081: v1(135.04,26.42) 134.65,26.81 134,26.81 133.82,26.99 132.93,26.99 132.77,27.15 132.18,27.15 132.05,27.02 131.45,27.02 131.32,27.16 129.4,27.16 129.06,26.81 123.09,26.81 121.94,27.96 121.11,27.96 121.01,27.86 121.01,27.62 120.91,27.52 120.77,27.52 120.67,27.62 120.67,27.97 120.58,28.06 120.44,28.06 120.34,27.97 120.34,27.62 120.24,27.52 120.1,27.52 120,27.62 120,27.96 119.91,28.06 119.77,28.06 119.67,27.96 119.67,27.62 119.57,27.52 119.43,27.52 119.33,27.62 119.33,27.86 119.23,27.96 118.53,27.96 118.43,27.86 118.43,27.51 118.33,27.41 118.19,27.41 118.09,27.51 118.09,27.93 117.99,28.03 117.86,28.03 117.76,27.93 117.76,27.6 117.66,27.5 117.52,27.5 117.42,27.6 117.42,27.92 117.32,28.02 117.19,28.02 117.09,27.92 117.09,27.61 116.99,27.51 116.85,27.51 116.75,27.61 116.75,27.86 116.65,27.96 116.23,27.96 115.88,28.31 115.28,28.31 114.76,28.83 114.44,28.83 114.29,28.68 112.37,28.68 112.28,28.77 112.28,28.93 112.37,29.01 114.11,29.01 114.19,29.1 114.19,29.26 114.11,29.35 112.6,29.35 112.51,29.44 112.51,29.6 112.6,29.68 114.2,29.68 114.29,29.77 114.29,29.93 114.2,30.02 112.91,30.02 112.6,30.33 112.6,32.76 112.69,32.85 112.84,32.85 112.93,32.76 112.93,30.62 113.02,30.53 113.21,30.53 113.3,30.62 113.3,30.86 113.45,31.01 113.99,31.01 114.18,31.2 114.18,31.57 114,31.75 114,32.96 114.11,33.07 114.2,33.07 114.31,33.17 114.31,33.51 114.23,33.59 113.76,33.59 113.67,33.51 113.67,31.85 113.58,31.77 113.42,31.77 113.33,31.85 113.33,33.5 113.22,33.6 112.54,33.6 112.44,33.7 112.44,33.84 112.54,33.94 114.19,33.94 114.28,34.04 114.28,34.17 114.19,34.27 112.53,34.27 112.43,34.37 112.43,34.91 112.52,35 112.95,35 113.04,34.91 113.04,34.75 113.18,34.61 114.19,34.61 114.28,34.71 114.28,34.85 114.19,34.94 113.63,34.94 113.53,35.04 113.53,35.18 113.63,35.28 114.19,35.28 114.28,35.38 114.28,35.61 114.19,35.7 113.7,35.7 113.62,35.79 113.62,35.96 113.7,36.05 114.1,36.05 114.19,36.14 114.19,36.37 114.1,36.46 113.67,36.46 113.58,36.55 113.58,36.72 113.67,36.81 113.92,36.81 114.01,36.9 114.01,37.05 113.92,37.14 113.61,37.14 113.52,37.23 113.52,37.39 113.61,37.48 114.47,37.48 114.57,37.58 114.57,37.72 114.47,37.81 113.63,37.81 113.53,37.91 113.53,38.05 113.63,38.15 114.44,38.15 114.54,38.25 114.54,38.39 114.44,38.48 113.63,38.48 113.53,38.58 113.53,38.72 113.63,38.82 114.64,38.82 114.74,38.92 114.74,39.06 114.64,39.16 113.67,39.16 113.57,39.25 113.57,39.39 113.67,39.49 114.43,39.49 114.53,39.59 114.53,39.73 114.43,39.83 113.63,39.83 113.53,39.92 113.53,40.06 113.63,40.16 114.43,40.16 114.53,40.26 114.53,40.4 114.43,40.5 113.63,40.5 113.53,40.59 113.53,40.73 113.63,40.83 114.63,40.83 114.73,40.93 114.73,41.07 114.63,41.17 114.05,41.17 113.95,41.27 113.95,41.44 114.05,41.54 114.43,41.54 114.54,41.64 114.54,42.97 114.24,43.27 114.24,43.59 114.42,43.77 114.42,44.09 114.27,44.24 114.27,44.61 114.42,44.76 114.42,45.1 114.26,45.26 114.26,45.61 114.42,45.77 114.42,46.08 114.25,46.25 114.25,46.59 114.42,46.76 114.42,47.09 114.27,47.24 114.27,47.61 114.42,47.76 114.42,48.09 114.26,48.25 114.26,48.61 114.67,49.02 115.7,49.02 116.61,49.93 v1(117.51,49.93)
DDR4_DIMM_CH2_A6: length 93.8
  L03_SIG1 w0.081: v4(118.38,49.43) 118.8,49.85 118.8,51.01 119.09,51.3 119.68,51.3 119.92,51.05 120.41,51.05 120.66,51.3 121.43,51.3 121.67,51.05 122.27,51.05 122.52,51.3 123,51.3 123.33,50.96 123.7,50.96 124.21,50.45 124.53,50.45 125.02,49.97 125.46,49.97 126,49.42 126.37,49.42 126.84,48.96 127.11,48.96 127.57,48.5 128,48.5 128.54,47.96 128.86,47.96 129.38,47.43 129.74,47.43 130.06,47.12 130.06,41.62 129.96,41.52 129.25,41.52 129.15,41.43 129.15,41.29 129.25,41.19 129.96,41.19 130.06,41.09 130.06,40.95 129.96,40.85 128.22,40.85 128.12,40.76 128.12,40.62 128.22,40.52 129.53,40.52 129.62,40.42 129.62,40.28 129.53,40.18 128.22,40.18 128.12,40.09 128.12,39.95 128.22,39.85 129.47,39.85 129.57,39.75 129.57,39.61 129.47,39.51 128.26,39.51 128.16,39.41 128.16,39.28 128.26,39.18 129.52,39.18 129.62,39.08 129.62,38.55 129.51,38.45 129.3,38.45 129.19,38.55 129.19,38.68 129.03,38.84 128.36,38.84 128.26,38.74 128.26,38.15 128.36,38.05 129.95,38.05 130.05,37.95 130.05,36.85 129.95,36.75 129.82,36.75 129.72,36.85 129.72,37.6 129.62,37.7 129.48,37.7 129.38,37.6 129.38,36.68 129.28,36.58 129.15,36.58 129.05,36.68 129.05,37.59 128.95,37.7 128.8,37.7 128.7,37.59 128.7,36.86 128.6,36.76 128.47,36.76 128.36,36.86 128.36,37.59 128.26,37.7 128.13,37.7 128.03,37.59 128.03,36.47 127.95,36.39 127.49,36.39 127.39,36.29 127.39,36.16 127.49,36.06 128.53,36.06 128.63,35.96 128.63,35.82 128.53,35.72 127.51,35.72 127.41,35.62 127.41,35.49 127.51,35.39 128.31,35.39 128.41,35.29 128.41,35.15 128.31,35.05 125.47,35.05 125.37,34.95 125.37,34.81 125.47,34.72 127.89,34.72 127.99,34.62 127.99,34.48 127.89,34.38 125.46,34.38 125.36,34.28 125.36,34.14 125.46,34.05 127.39,34.05 127.49,33.95 127.49,33.81 127.39,33.71 125.45,33.71 125.36,33.61 125.36,33.47 125.45,33.37 127.34,33.37 127.44,33.27 127.44,33.14 127.34,33.04 125.54,33.04 125.44,32.94 125.44,32.81 125.54,32.7 126.74,32.7 126.84,32.6 126.84,32.47 126.74,32.37 126.62,32.37 126.52,32.27 126.52,32.04 126.77,31.79 126.77,31.56 126.52,31.3 126.52,30.51 126.62,30.41 126.75,30.41 126.85,30.51 126.85,30.97 126.95,31.07 127.09,31.07 127.19,30.97 127.19,30.47 127.29,30.36 127.42,30.36 127.52,30.47 127.52,31.17 127.62,31.27 127.76,31.27 127.86,31.17 127.86,30.47 127.96,30.37 128.09,30.37 128.19,30.47 128.19,30.95 128.3,31.05 128.43,31.05 128.53,30.95 128.53,30.51 128.63,30.4 128.76,30.4 128.86,30.51 128.86,30.93 128.97,31.03 129.1,31.03 129.2,30.93 129.2,30.5 129.3,30.4 129.43,30.4 129.53,30.5 129.53,31.28 129.64,31.38 129.77,31.38 129.87,31.28 129.87,30.56 129.97,30.46 130.1,30.46 130.21,30.56 130.21,32.1 130.31,32.2 130.44,32.2 130.54,32.1 130.54,31.31 130.64,31.21 130.77,31.21 130.88,31.31 130.88,31.84 131.29,32.25 132.12,32.25 132.44,31.93 132.44,31.72 132.54,31.62 132.68,31.62 132.78,31.72 132.78,31.93 132.88,32.03 133.01,32.03 133.11,31.93 133.11,31.72 133.21,31.62 133.35,31.62 133.45,31.72 133.45,31.93 133.93,32.42 v4(135.04,32.42)
DDR4_DIMM_CH2_A7: length 91.4
  L14_SIG5 w0.081: v1(118.38,50.43) 118.38,48.96 117.76,48.34 117.26,48.34 116.79,48.81 114.77,48.81 114.54,48.58 114.54,48.28 114.7,48.11 114.7,47.75 114.54,47.58 114.54,47.28 114.68,47.14 114.68,46.72 114.51,46.55 114.51,46.3 114.7,46.11 114.7,45.76 114.53,45.59 114.53,45.28 114.7,45.11 114.7,44.74 114.52,44.56 114.52,44.29 114.7,44.1 114.7,43.74 114.54,43.58 114.54,43.28 114.86,42.96 115.05,42.96 115.31,42.71 115.31,37.1 115.21,37 114.47,37 114.37,36.9 114.37,36.76 114.47,36.67 115.21,36.67 115.31,36.57 115.31,36.43 115.21,36.33 114.68,36.33 114.58,36.23 114.58,36.09 114.68,36 115.21,36 115.31,35.9 115.31,35.13 115.2,35.02 114.72,35.02 114.63,34.93 114.63,33.65 114.72,33.56 114.88,33.56 114.97,33.65 114.97,34.48 115.06,34.57 115.22,34.57 115.31,34.48 115.31,33.57 115.44,33.43 115.44,32.92 115.34,32.82 114.45,32.82 114.35,32.72 114.35,32.59 114.45,32.49 115.34,32.49 115.44,32.39 115.44,32.25 115.34,32.15 114.45,32.15 114.36,32.05 114.36,31.91 114.45,31.82 115.36,31.82 115.45,31.73 115.45,31.57 115.36,31.48 114.64,31.48 114.55,31.39 114.55,31.24 114.64,31.15 116.04,31.15 116.13,31.06 116.13,30.88 116.04,30.79 114.75,30.79 114.62,30.67 114.62,29.48 114.71,29.39 114.87,29.39 114.96,29.48 114.96,30.35 115.05,30.44 115.21,30.44 115.3,30.35 115.3,28.79 115.38,28.7 115.54,28.7 115.63,28.79 115.63,30.35 115.72,30.43 115.88,30.43 115.97,30.35 115.97,28.88 116.05,28.79 116.23,28.79 116.32,28.88 116.32,29.77 116.41,29.86 116.57,29.86 116.66,29.77 116.66,28.61 116.75,28.52 116.9,28.52 116.99,28.61 116.99,29.64 117.08,29.73 117.24,29.73 117.33,29.64 117.33,28.45 117.43,28.35 117.57,28.35 117.66,28.45 117.66,29.76 117.76,29.86 117.9,29.86 118,29.76 118,28.45 118.1,28.35 118.24,28.35 118.33,28.45 118.33,29.48 118.43,29.58 118.57,29.58 118.67,29.48 118.67,28.93 118.77,28.83 118.91,28.83 119.01,28.93 119.01,29.51 119.1,29.6 119.24,29.6 119.34,29.51 119.34,28.45 119.44,28.35 119.58,28.35 119.68,28.45 119.68,29.51 119.77,29.61 119.91,29.61 120.01,29.51 120.01,28.45 120.11,28.35 120.25,28.35 120.35,28.45 120.35,29.43 120.44,29.52 120.58,29.52 120.68,29.43 120.68,28.45 120.78,28.35 120.92,28.35 121.02,28.45 121.02,29.24 121.11,29.33 121.55,29.33 121.64,29.24 121.64,28.8 121.73,28.71 121.89,28.71 121.98,28.8 121.98,29.24 122.07,29.33 122.22,29.33 122.31,29.24 122.31,28.18 123.21,27.28 124.62,27.28 124.85,27.51 124.99,27.51 125.09,27.42 125.09,27.29 125.19,27.19 125.33,27.19 125.43,27.29 125.43,27.74 125.53,27.84 125.66,27.84 125.76,27.74 125.76,27.28 125.86,27.19 126,27.19 126.1,27.28 126.1,27.74 126.2,27.84 126.34,27.84 126.43,27.74 126.43,27.27 126.53,27.17 126.67,27.17 126.77,27.27 126.77,27.74 126.87,27.84 129.47,27.84 129.57,27.74 129.57,27.59 129.67,27.5 129.81,27.5 129.9,27.59 129.9,27.74 130,27.84 130.14,27.84 130.24,27.74 130.24,27.59 130.34,27.5 130.48,27.5 130.58,27.59 130.58,27.74 130.67,27.84 130.81,27.84 130.91,27.74 130.91,27.59 131.01,27.5 131.15,27.5 131.25,27.59 131.25,27.74 131.34,27.84 131.79,27.84 132.09,27.53 132.92,27.53 133.17,27.79 133.65,27.79 134.29,27.15 135.11,27.15 135.85,26.42 v1(136.74,26.42)
DDR4_DIMM_CH2_A8: length 92.1
  L14_SIG5 w0.081: v1(119.24,48.93) 119.24,49.89 119.33,49.98 119.6,49.98 119.69,49.89 119.69,49.3 120.01,48.98 120.27,48.98 120.53,48.72 120.53,47.25 120.25,46.98 119.92,46.98 119.83,46.89 119.83,46.56 119.94,46.45 121.01,46.45 121.4,46.07 121.4,40.24 122.8,38.84 123.91,38.84 124.07,39 124.07,41.44 124.16,41.52 124.33,41.52 124.42,41.44 124.42,39.48 124.51,39.39 124.66,39.39 124.75,39.48 124.75,40.54 124.84,40.63 125,40.63 125.09,40.54 125.09,39.91 125.18,39.82 125.33,39.82 125.42,39.91 125.42,40.52 125.51,40.61 125.67,40.61 125.76,40.52 125.76,39.94 125.99,39.7 125.99,39.23 125.76,39 125.76,38.44 125.85,38.35 126,38.35 126.09,38.44 126.09,38.75 126.18,38.84 126.34,38.84 126.43,38.75 126.43,38.29 126.03,37.9 126.03,36.85 126.12,36.76 126.28,36.76 126.37,36.85 126.37,37.72 126.46,37.81 126.62,37.81 126.7,37.72 126.7,36.95 126.79,36.87 126.95,36.87 127.04,36.95 127.04,37.87 127.13,37.96 127.29,37.96 127.38,37.87 127.38,36.64 127.46,36.55 127.62,36.55 127.71,36.64 127.71,36.95 127.8,37.04 127.96,37.04 128.05,36.95 128.05,33.83 128.14,33.74 128.28,33.74 128.38,33.83 128.38,34.96 128.48,35.06 128.62,35.06 128.72,34.96 128.72,33.06 128.81,32.96 128.95,32.96 129.05,33.06 129.05,35.16 129.15,35.26 129.29,35.26 129.39,35.16 129.39,33.7 129.49,33.6 129.62,33.6 129.72,33.7 129.72,34.82 129.82,34.92 129.96,34.92 130.06,34.82 130.06,32.85 130.16,32.76 130.29,32.76 130.39,32.85 130.39,34.59 130.49,34.69 130.63,34.69 130.73,34.59 130.73,33.7 130.83,33.6 130.97,33.6 131.06,33.7 131.06,34.28 131.16,34.38 131.3,34.38 131.4,34.28 131.4,33.43 131.5,33.34 131.64,33.34 131.73,33.43 131.73,34.16 131.83,34.26 131.97,34.26 132.07,34.16 132.07,32.97 131.97,32.87 131.26,32.87 131.14,32.75 131.14,32.61 131.24,32.51 131.96,32.51 132.06,32.41 132.06,32.28 131.96,32.18 131.2,32.18 131.11,32.09 131.11,31.88 131.2,31.79 132.31,31.79 132.4,31.89 132.4,34.17 132.5,34.27 132.64,34.27 132.74,34.17 132.74,33.73 132.84,33.63 132.98,33.63 133.08,33.73 133.08,33.87 133.16,33.95 133.32,33.95 133.72,33.56 133.72,33.28 133.63,33.19 133.41,33.19 132.77,32.55 132.77,31.88 132.86,31.79 133.38,31.79 133.47,31.88 133.47,32.74 133.56,32.83 133.71,32.83 133.8,32.74 133.8,31.86 133.89,31.78 134.05,31.78 134.14,31.86 134.14,33.54 134.23,33.63 134.38,33.63 134.47,33.54 134.47,31.72 134.56,31.64 134.72,31.64 134.81,31.72 134.81,32.88 134.9,32.96 135.05,32.96 135.14,32.88 135.14,31.42 135.23,31.34 135.39,31.34 135.48,31.42 135.48,32.67 136.11,33.31 137.13,33.31 137.22,33.22 137.22,33.06 137.13,32.97 136.26,32.97 136.17,32.89 136.17,32.73 136.26,32.64 137.49,32.64 137.58,32.55 137.58,32.39 137.49,32.3 136,32.3 v1(135.89,32.42)
DDR4_DIMM_CH2_A9: length 94
  L03_SIG1 w0.081: v4(137.59,32.42) 136.53,32.42 136.16,32.05 134.09,32.05 133.81,31.76 133.81,31.5 133.58,31.27 132.22,31.27 132.05,31.44 132.05,31.57 131.78,31.84 131.48,31.84 131.23,31.58 131.23,31.09 130.17,30.03 126.44,30.03 126.12,30.34 126.12,32.22 126.02,32.32 125.89,32.32 125.79,32.22 125.79,30.83 125.68,30.73 125.55,30.73 125.45,30.83 125.45,32.19 125.35,32.29 125.22,32.29 125.12,32.19 125.12,31.7 125.01,31.6 124.14,31.6 124.04,31.7 124.04,31.91 124.14,32.01 124.63,32.01 124.74,32.11 124.74,32.24 124.63,32.34 124.14,32.34 124.04,32.44 124.04,32.58 124.14,32.68 124.99,32.68 125.08,32.78 125.08,32.92 124.99,33.01 124.16,33.01 124.06,33.11 124.06,33.25 124.16,33.35 124.91,33.35 125.01,33.45 125.01,33.59 124.91,33.68 124.15,33.68 124.06,33.78 124.06,33.92 124.15,34.02 124.91,34.02 125.01,34.12 125.01,34.26 124.91,34.35 124.13,34.35 124.03,34.45 124.03,34.59 124.13,34.69 124.77,34.69 124.89,34.8 124.89,36.13 125.01,36.26 125.44,36.26 125.59,36.11 125.59,35.67 125.69,35.57 125.82,35.57 125.92,35.67 125.92,36.18 126.02,36.28 126.16,36.28 126.26,36.18 126.26,35.58 126.36,35.48 126.49,35.48 126.59,35.58 126.59,36.54 126.49,36.64 125.14,36.64 125.04,36.74 125.04,36.88 125.14,36.98 127.55,36.98 127.65,37.09 127.65,37.23 127.55,37.33 125.78,37.33 125.68,37.43 125.68,37.58 125.78,37.68 127.6,37.68 127.7,37.78 127.7,37.92 127.6,38.02 126.53,38.02 126.36,38.19 126.36,39.2 126.26,39.3 126.13,39.3 126.03,39.2 126.03,38.16 125.93,38.06 125.79,38.06 125.69,38.16 125.69,39.61 125.79,39.71 126.78,39.71 126.88,39.81 126.88,39.94 126.78,40.04 125.82,40.04 125.72,40.14 125.72,40.28 125.82,40.38 126.56,40.38 126.66,40.48 126.66,40.61 126.56,40.71 125.59,40.71 125.49,40.82 125.49,40.95 125.59,41.05 125.74,41.05 125.84,41.15 125.84,41.43 125.94,41.53 126.08,41.53 126.18,41.43 126.18,41.15 126.27,41.05 127.31,41.05 127.41,40.95 127.41,38.52 127.51,38.42 127.66,38.42 127.76,38.52 127.76,41.08 127.87,41.19 128.28,41.19 128.37,41.29 128.37,41.43 128.28,41.52 127.66,41.52 127.41,41.78 127.41,42.26 127.59,42.44 128.12,42.44 128.66,41.9 128.98,41.9 129.28,42.19 129.28,42.53 128.83,42.98 128.58,42.98 128.13,43.43 127.8,43.43 127.41,43.82 127.41,44.23 127.59,44.42 128.09,44.42 128.59,43.92 128.99,43.92 129.26,44.19 129.26,44.61 128.87,44.99 128.48,44.99 128.03,45.45 127.71,45.45 127.46,45.7 127.46,46.15 127.67,46.36 128.16,46.36 128.62,45.91 129.1,45.91 129.34,46.16 129.34,46.52 128.88,46.98 128.53,46.98 128.03,47.49 127.7,47.49 127.24,47.95 126.76,47.95 126.25,48.46 125.92,48.46 125.46,48.92 125.07,48.92 124.53,49.46 124.25,49.46 123.76,49.95 123.38,49.95 122.89,50.44 122.55,50.44 122.19,50.8 121.44,50.8 121.19,50.55 120.63,50.55 120.38,50.8 119.9,50.8 119.61,50.51 119.61,50.29 v4(119.24,49.93)
DDR4_DIMM_CH2_A10: length 88.8
  L14_SIG5 w0.081: v1(119.74,26.42) 120.07,26.09 120.29,26.09 120.38,26 120.38,25.85 120.29,25.76 119.72,25.76 119.63,25.67 119.63,25.51 119.72,25.42 120.43,25.42 120.52,25.33 120.52,25.18 120.43,25.09 120.2,25.09 120.13,25.01 120.13,24.83 120.2,24.75 120.91,24.75 120.99,24.66 120.99,24.51 120.91,24.42 120.15,24.42 120.02,24.28 120.02,23.6 119.93,23.52 119.74,23.52 119.65,23.6 119.65,24.08 119.57,24.17 119.41,24.17 119.32,24.08 119.32,23.15 119.23,23.06 118.35,23.06 118.26,23.15 118.26,23.41 118.35,23.5 118.82,23.5 118.95,23.62 118.95,24.29 119.33,24.67 119.33,25.08 119.23,25.18 118.54,25.18 118.44,25.08 118.44,24.25 118.35,24.15 118.2,24.15 118.1,24.25 118.1,25.13 118.01,25.23 117.81,25.23 117.73,25.15 117.73,24.03 117.64,23.94 117.48,23.94 117.39,24.03 117.39,24.31 117.3,24.4 117.14,24.4 117.06,24.31 117.06,23.12 116.97,23.03 116.81,23.03 116.72,23.12 116.72,25.1 116.63,25.18 116.35,25.18 116.26,25.1 116.26,24.85 116.17,24.76 116.01,24.76 115.92,24.85 115.92,25.58 115.83,25.67 115.66,25.67 115.57,25.58 115.57,25.31 115.46,25.2 114.79,25.2 114.69,25.3 114.69,25.58 114.59,25.68 114.45,25.68 114.35,25.58 114.35,25.12 114.25,25.02 114.11,25.02 114.01,25.12 114.01,25.58 113.91,25.68 113.77,25.68 113.67,25.58 113.67,24.78 113.82,24.63 114.09,24.63 114.31,24.41 115.86,24.41 115.95,24.32 115.95,24.12 115.86,24.03 114.1,24.03 113.95,24.19 113.6,24.19 113.06,23.65 112.88,23.65 112.71,23.83 112.71,24.01 113.33,24.63 113.33,25.52 113.2,25.65 113.06,25.65 112.96,25.55 112.96,25.3 112.86,25.2 112.58,25.2 112.44,25.06 112.44,24.26 112.35,24.17 112.11,24.17 112.02,24.26 112.02,26.15 111.93,26.24 111.77,26.24 111.68,26.15 111.68,25.57 111.6,25.49 111.44,25.49 111.35,25.57 111.35,26.39 110.96,26.78 110.96,29.56 110.73,29.79 110.73,30.97 111,31.24 111,31.56 110.71,31.84 110.71,32.53 110.55,32.7 110.55,33.76 110.71,33.92 110.71,40.84 110.92,41.05 111.64,41.05 111.89,41.3 111.89,41.77 111.72,41.94 111.22,41.94 111,42.16 111,42.65 111.29,42.94 111.69,42.94 111.9,43.14 111.9,43.6 111.59,43.91 111.25,43.91 111.05,44.11 111.05,44.74 111.27,44.97 111.67,44.97 111.9,45.2 111.9,45.68 111.65,45.92 111.24,45.92 111.03,46.13 111.03,47.15 110.76,47.42 110.44,47.42 109.94,47.91 109.51,47.91 109.28,48.14 109.28,50.64 109.53,50.89 109.88,50.89 110.37,51.38 110.85,51.38 111.31,50.92 111.65,50.92 112.16,51.42 112.58,51.42 113.05,50.94 113.42,50.94 113.86,51.38 114.27,51.38 114.67,50.98 115.18,50.98 115.6,51.4 115.88,51.4 116.32,50.97 116.79,50.97 117.22,51.4 117.67,51.4 118.07,51.01 118.6,51.01 119,51.41 119.46,51.41 119.94,50.93 120.29,50.93 120.54,50.68 120.54,50.14 120.11,49.71 v1(120.11,49.43)
DDR4_DIMM_CH2_A11: length 89.7
  L14_SIG5 w0.081: v1(120.11,50.43) 119.24,50.43 118.85,50.04 118.85,48.27 118.64,48.05 116.5,48.05 116.01,48.54 115.56,48.54 115.15,48.13 115.15,47.73 115.3,47.58 115.3,47.28 115.15,47.13 115.15,46.72 115.32,46.55 115.32,46.28 115.1,46.07 115.1,45.77 115.32,45.56 115.32,43.65 115.55,43.42 115.91,43.42 116.21,43.12 116.21,41.58 116.12,41.48 115.76,41.48 115.67,41.38 115.67,41.24 115.76,41.15 116.12,41.15 116.21,41.05 116.21,40.91 116.12,40.81 115.76,40.81 115.67,40.71 115.67,40.57 115.76,40.47 116.12,40.47 116.21,40.38 116.21,40.24 116.12,40.14 115.76,40.14 115.67,40.04 115.67,39.9 115.76,39.8 116.12,39.8 116.21,39.71 116.21,39.57 116.12,39.47 115.76,39.47 115.67,39.37 115.67,39.23 115.76,39.13 116.12,39.13 116.21,39.04 116.21,38.9 116.12,38.8 115.76,38.8 115.67,38.7 115.67,38.56 115.76,38.46 116.12,38.46 116.21,38.37 116.21,38.23 116.12,38.13 115.76,38.13 115.67,38.03 115.67,37.89 115.76,37.79 116.12,37.79 116.21,37.69 116.21,37.56 116.12,37.46 115.76,37.46 115.67,37.36 115.67,37.22 115.76,37.12 116.12,37.12 116.21,37.02 116.21,36.89 116.12,36.79 115.76,36.79 115.67,36.69 115.67,36.55 115.76,36.45 116.12,36.45 116.21,36.35 116.21,36.21 116.12,36.12 115.76,36.12 115.67,36.02 115.67,35.88 115.76,35.78 116.12,35.78 116.21,35.68 116.21,35.54 116.12,35.45 115.76,35.45 115.67,35.35 115.67,35.21 115.76,35.11 116.12,35.11 116.21,35.01 116.21,34.87 116.12,34.78 115.76,34.78 115.67,34.68 115.67,34.54 115.76,34.44 116.12,34.44 116.21,34.34 116.21,34.2 116.12,34.1 115.76,34.1 115.67,34.01 115.67,33.87 115.76,33.77 116.46,33.77 116.55,33.67 116.55,33.53 116.46,33.43 115.93,33.43 115.83,33.34 115.83,33.2 115.93,33.1 116.72,33.1 116.82,33 116.82,32.86 116.72,32.76 115.87,32.76 115.78,32.67 115.78,31.88 115.87,31.79 116.1,31.79 116.19,31.88 116.19,32.28 116.28,32.37 116.5,32.37 116.59,32.28 116.59,31.72 116.67,31.63 116.83,31.63 116.92,31.72 116.92,32.45 117.01,32.54 117.17,32.54 117.26,32.45 117.26,31.22 117.16,31.12 116.58,31.12 116.48,31.02 116.48,30.88 116.58,30.78 117.16,30.78 117.26,30.68 117.26,30.54 117.16,30.44 116.83,30.44 116.74,30.35 116.74,30.17 116.83,30.08 117.5,30.08 117.59,30.17 117.59,32.88 117.68,32.97 117.9,32.97 117.98,32.88 117.98,31.92 118.07,31.83 118.23,31.83 118.32,31.92 118.32,32.71 118.41,32.8 118.57,32.8 118.66,32.71 118.66,31.18 118.56,31.08 118.23,31.08 118.13,30.98 118.13,30.84 118.23,30.74 118.56,30.74 118.66,30.64 118.66,29.99 118.74,29.9 118.9,29.9 118.99,29.99 118.99,31.83 119.08,31.92 119.24,31.92 119.33,31.83 119.33,29.99 119.41,29.9 119.57,29.9 119.66,29.99 119.66,31.51 119.75,31.6 119.91,31.6 120,31.51 120,30.02 120.13,29.89 120.91,29.89 121,29.98 121,30.77 121.09,30.86 121.29,30.86 121.38,30.77 121.38,29.76 121.47,29.67 121.63,29.67 121.72,29.76 121.72,30.57 121.81,30.66 121.97,30.66 122.05,30.57 122.05,29.78 122.14,29.69 122.3,29.69 122.39,29.78 122.39,30.58 122.48,30.67 122.64,30.67 122.72,30.58 122.72,28.27 123.35,27.64 124.47,27.64 125.04,28.2 131.93,28.2 132.21,27.92 132.82,27.92 133.02,28.13 133.79,28.13 134.4,27.52 135.22,27.52 135.93,26.8 137.2,26.8 v1(137.59,26.42)
DDR4_DIMM_CH2_A12: length 87
  L14_SIG5 w0.081: v1(122.71,47.93) 122.54,48.09 122.54,49.44 122.64,49.54 122.78,49.54 122.88,49.44 122.88,48.34 122.98,48.23 123.1,48.23 123.2,48.34 123.2,48.9 123.35,49.05 123.93,49.05 124.03,48.94 124.03,48.36 123.69,48.01 123.69,47.87 124,47.56 124,46.78 124.12,46.65 124.32,46.65 124.41,46.74 124.41,48.42 124.51,48.52 124.81,48.52 124.92,48.42 124.92,48.25 125.62,47.55 126.19,47.55 126.83,46.91 127.22,46.91 127.69,46.44 128.12,46.44 128.62,45.95 128.95,45.95 129.47,45.43 129.87,45.43 130.38,45.94 130.66,45.94 131.19,45.41 131.51,45.41 132,45.9 132.38,45.9 132.83,46.35 133.32,46.35 133.61,46.06 133.61,45.8 133.33,45.52 133.33,45.27 133.53,45.07 133.53,44.73 133.32,44.51 133.32,44.29 133.53,44.07 133.53,43.59 133.27,43.33 132.93,43.33 132.66,43.6 132.66,44.07 132.86,44.27 132.86,44.6 132.43,45.03 132.04,45.03 131.65,44.63 131.65,44.24 131.88,44.01 131.88,43.59 131.61,43.32 131.15,43.32 130.79,43.68 130.79,43.91 131.1,44.22 131.1,44.62 130.69,45.03 130.24,45.03 130.06,44.86 130.06,44.42 129.95,44.31 129.27,44.31 129.16,44.42 129.16,44.85 129.07,44.94 128.46,44.94 128.07,44.54 128.07,44.34 128.34,44.07 128.34,43.49 128.19,43.34 127.63,43.34 127.48,43.49 127.48,44.53 127.25,44.76 127.25,45.09 127.48,45.31 127.48,45.81 127.24,46.05 126.76,46.05 126.61,45.9 126.61,45.33 126.79,45.15 126.79,44.75 126.57,44.53 126.57,44.32 126.81,44.08 126.81,43.76 126.36,43.31 125.97,43.31 125.5,43.77 125.5,44.05 125.75,44.3 125.75,44.52 125.47,44.81 125.47,45.05 125.75,45.34 125.75,46.05 125.98,46.28 125.98,46.58 125.75,46.8 125.75,47.16 125.65,47.26 125.51,47.26 125.42,47.17 125.42,45.95 125.33,45.86 125.17,45.86 125.08,45.95 125.08,47.5 124.99,47.59 124.84,47.59 124.75,47.5 124.75,46.5 124.57,46.33 124.2,46.33 124.03,46.15 124.03,45.52 124.14,45.4 124.66,45.4 124.88,45.18 124.88,44.62 124.7,44.44 124.13,44.44 123.86,44.17 123.86,43.68 124.04,43.5 124.72,43.5 124.85,43.37 124.85,43.01 125.05,42.81 125.22,42.81 125.41,43 125.56,43 125.89,42.67 125.89,42.41 125.49,42.01 125.49,41.82 126.61,40.7 126.61,40.15 126.79,39.97 127.24,39.97 127.43,39.78 127.43,39.41 127.58,39.26 127.95,39.26 128.29,38.92 128.29,37.73 129.18,36.84 129.18,36.46 129.33,36.31 129.71,36.31 130.04,35.98 130.67,35.98 131.69,34.95 132.32,34.95 132.58,35.21 132.73,35.21 132.99,34.95 133.14,34.95 133.41,35.22 133.63,35.22 133.9,34.95 134.14,34.95 135.06,34.03 137.57,34.03 137.79,33.81 138.07,33.81 138.3,34.03 140.06,34.03 140.22,33.87 140.22,33.24 140.13,33.15 139.86,33.15 139.77,33.24 139.77,33.5 139.64,33.62 138.54,33.62 138.44,33.52 v1(138.44,32.42)
DDR4_DIMM_CH2_A13: length 88.7
  L03_SIG1 w0.081: v4(123.57,46.43) 123.24,46.43 123.11,46.3 122.43,46.3 122,45.87 121.56,45.87 121.22,45.53 120.75,45.53 120.26,45.04 119.94,45.04 119.68,45.3 119.05,45.3 118.76,45.02 118.3,45.02 117.71,44.43 117.36,44.43 117.07,44.14 117.07,42.21 116.77,41.91 116.38,41.91 116.22,42.07 116.22,44.04 115.96,44.31 115.52,44.31 115.3,44.09 115.3,41.67 115.42,41.55 116.17,41.55 116.27,41.45 116.27,41.31 116.17,41.21 115.22,41.21 115.13,41.11 115.13,40.97 115.22,40.88 116.24,40.88 116.34,40.78 116.34,40.64 116.24,40.54 115.39,40.54 115.29,40.44 115.29,40.3 115.39,40.21 116.34,40.21 116.44,40.11 116.44,39.97 116.34,39.87 115.33,39.87 115.23,39.77 115.23,39.63 115.33,39.53 116.17,39.53 116.27,39.44 116.27,39.3 116.17,39.2 115.21,39.2 115.12,39.1 115.12,38.96 115.21,38.86 115.76,38.86 115.86,38.77 115.86,38.63 115.76,38.53 115.39,38.53 115.29,38.43 115.29,38.29 115.39,38.19 115.75,38.19 115.85,38.1 115.85,37.96 115.75,37.86 115.35,37.86 115.25,37.76 115.25,37.62 115.35,37.52 115.74,37.52 115.84,37.42 115.84,37.29 115.74,37.19 115.23,37.19 115.14,37.09 115.14,36.95 115.23,36.85 115.75,36.85 115.85,36.75 115.85,36.62 115.75,36.52 114.23,36.52 114.13,36.62 114.13,36.75 114.23,36.85 114.36,36.85 114.46,36.95 114.46,37.06 114.36,37.16 113.67,37.16 113.57,37.27 113.57,37.4 113.67,37.5 114.46,37.5 114.56,37.6 114.56,37.73 114.46,37.84 113.32,37.84 113.21,37.94 113.21,38.07 113.32,38.17 114.43,38.17 114.53,38.27 114.53,38.4 114.43,38.51 113.34,38.51 113.24,38.61 113.24,38.74 113.34,38.84 114.63,38.84 114.74,38.94 114.74,39.07 114.63,39.18 113.66,39.18 113.55,39.28 113.55,39.41 113.66,39.51 114.48,39.51 114.58,39.61 114.58,39.75 114.48,39.85 113.47,39.85 113.37,39.95 113.37,40.08 113.47,40.18 114.44,40.18 114.54,40.28 114.54,40.42 114.44,40.52 113.61,40.52 113.51,40.62 113.51,40.75 113.61,40.85 114.61,40.85 114.71,40.95 114.71,41.09 114.61,41.19 113.65,41.19 113.55,41.29 113.55,41.42 113.65,41.52 114.39,41.52 114.6,41.74 114.6,42.21 114.36,42.45 113.78,42.45 113.28,41.94 113.09,41.94 112.79,41.64 112.79,36.98 112.91,36.86 113.35,36.86 113.58,36.63 113.58,36.34 113.74,36.18 115.74,36.18 115.84,36.08 115.84,35.94 115.74,35.85 115.38,35.85 115.28,35.75 115.28,35.61 115.38,35.51 116.06,35.51 116.15,35.41 116.15,35.27 116.06,35.18 115.2,35.18 115.1,35.08 115.1,34.94 115.2,34.84 116.19,34.84 116.28,34.74 116.28,34.6 116.19,34.51 115.3,34.51 115.2,34.41 115.2,34.27 115.3,34.17 116.19,34.17 116.28,34.07 116.28,33.93 116.19,33.83 115.38,33.83 115.28,33.74 115.28,33.57 115.38,33.47 116.71,33.47 116.81,33.37 116.81,33.24 116.71,33.14 115.5,33.14 115.4,33.04 115.4,32.89 115.5,32.79 117.5,32.79 117.61,32.68 117.61,32.2 116.73,31.32 116.73,30.93 116.61,30.81 116.17,30.81 115.58,30.23 114.2,30.23 113.83,29.86 113.83,26.46 v4(113.79,26.42)
DDR4_DIMM_CH2_A14: length 88.1
  L12_SIG4 w0.089: v1(117.19,26.42) 116.72,26.88 105.86,26.88 105.56,27.18 105.56,28.9 105.65,28.99 105.82,28.99 105.91,28.9 105.91,28.23 106,28.14 106.16,28.14 106.25,28.23 106.25,28.81 106.34,28.9 106.5,28.9 106.59,28.81 106.59,27.95 106.68,27.86 106.85,27.86 106.94,27.95 106.94,28.95 107.02,29.04 107.19,29.04 107.28,28.95 107.28,27.96 107.37,27.87 107.53,27.87 107.62,27.96 107.62,28.96 107.71,29.05 107.87,29.05 107.96,28.96 107.96,27.84 108.05,27.75 108.22,27.75 108.31,27.84 108.31,28.81 108.4,28.9 109.22,28.9 109.31,28.81 109.31,27.51 109.41,27.41 109.55,27.41 109.65,27.51 109.65,28.92 109.75,29.02 109.89,29.02 109.99,28.92 109.99,27.89 110.1,27.79 110.24,27.79 110.34,27.89 110.34,28.87 110.44,28.97 110.58,28.97 110.68,28.87 110.68,27.69 110.78,27.59 110.92,27.59 111.02,27.69 111.02,28.87 111.12,28.97 111.27,28.97 111.37,28.87 111.37,27.41 111.47,27.31 111.61,27.31 111.71,27.41 111.71,28.79 111.8,28.87 112.39,28.87 112.47,28.79 112.47,27.86 112.57,27.76 112.73,27.76 112.83,27.86 112.83,28.83 112.93,28.93 113.07,28.93 113.17,28.83 113.17,27.83 113.27,27.73 113.43,27.73 113.53,27.83 113.53,28.83 113.63,28.93 113.78,28.93 113.88,28.83 113.88,27.47 113.98,27.37 114.17,27.37 114.27,27.47 114.27,28.83 114.37,28.93 114.98,28.93 115.08,28.83 115.08,27.44 115.18,27.34 115.46,27.34 115.56,27.44 115.56,28.83 115.66,28.93 115.85,28.93 115.95,28.83 115.95,27.9 116.05,27.8 116.65,27.8 116.75,27.9 116.75,28.83 116.86,28.93 117.03,28.93 117.13,28.83 117.13,27.11 117.23,27.01 117.38,27.01 117.48,27.11 117.48,28.83 117.58,28.93 121.04,28.93 123.98,31.87 123.98,32.57 126.42,35.01 126.42,35.52 126.84,35.94 127.15,35.94 127.41,36.2 127.41,40.61 127.2,40.82 126.76,40.82 126.45,41.12 126.45,41.63 126.55,41.84 126.55,42.08 126.45,42.18 126.45,42.6 126.55,42.84 126.55,43.08 126.45,43.18 126.45,43.67 126.55,43.78 126.55,44.04 126.45,44.29 126.45,44.58 126.55,44.82 126.55,45.08 126.33,45.3 126.11,45.3 125.58,45.84 125.06,45.84 124.64,45.42 124.24,45.42 123.57,46.09 v1(123.57,47.43)
DDR4_DIMM_CH2_A15: length 86.5
  L03_SIG1 w0.081: v4(115.49,32.42) 115.26,32.42 114.61,33.07 114.12,33.07 114.02,33.17 114.02,33.37 114.12,33.47 114.77,33.47 114.87,33.57 114.87,33.7 114.77,33.8 113.5,33.8 113.4,33.91 113.4,34.04 113.5,34.14 114.74,34.14 114.84,34.24 114.84,34.37 114.74,34.48 113.21,34.48 113.11,34.58 113.11,34.71 113.21,34.81 114.64,34.81 114.74,34.91 114.74,35.04 114.64,35.15 113.67,35.15 113.57,35.25 113.57,35.38 113.67,35.48 114.47,35.48 114.57,35.58 114.57,35.71 114.47,35.82 112.79,35.82 112.69,35.72 112.69,34.27 112.59,34.17 112.45,34.17 112.35,34.27 112.35,35.72 112.25,35.82 112.12,35.82 112.02,35.72 112.02,34.75 111.92,34.66 111.78,34.66 111.68,34.75 111.68,35.72 111.58,35.82 111.45,35.82 111.35,35.72 111.35,34.75 111.25,34.65 111.11,34.65 111.01,34.75 111.01,35.72 110.91,35.82 110.61,35.82 110.51,35.72 110.51,34.75 110.42,34.65 110.28,34.65 110.18,34.75 110.18,35.72 110.08,35.82 109.52,35.82 109.42,35.92 109.42,36.1 109.52,36.2 112.68,36.2 112.78,36.3 112.78,36.43 112.68,36.53 112.54,36.53 112.37,36.7 112.37,38.4 112.27,38.51 112.04,38.51 111.94,38.4 111.94,36.79 111.68,36.53 109.63,36.53 109.52,36.64 109.52,36.77 109.63,36.87 111.14,36.87 111.24,36.97 111.24,37.1 111.14,37.2 110.19,37.2 110.09,37.31 110.09,37.44 110.19,37.54 111.04,37.54 111.14,37.64 111.14,37.77 111.04,37.87 110.14,37.87 110.04,37.98 110.04,38.11 110.14,38.21 110.97,38.21 111.07,38.31 111.07,38.44 110.97,38.55 110.15,38.55 110.05,38.65 110.05,38.78 110.15,38.88 112.36,38.88 112.45,38.98 112.45,39.12 112.36,39.22 110.19,39.22 110.1,39.31 110.1,39.45 110.19,39.55 112.36,39.55 112.45,39.65 112.45,39.79 112.36,39.89 110.06,39.89 109.96,39.98 109.96,40.12 110.06,40.22 112.36,40.22 112.45,40.32 112.45,40.46 112.36,40.56 110.31,40.56 110.21,40.66 110.21,40.79 110.31,40.89 112.36,40.89 112.45,40.99 112.45,41.22 111.78,41.9 111.14,41.9 111,42.04 111,43.84 111.16,43.99 111.77,43.99 111.89,43.87 111.89,42.6 112.02,42.46 112.57,42.46 113.01,42.9 113.33,42.9 113.85,43.42 114.18,43.42 114.46,43.69 114.46,44.64 114.73,44.92 115.06,44.92 115.43,44.54 116.13,44.54 116.58,44.99 116.88,44.99 117.33,45.44 117.67,45.44 118.12,45.89 118.63,45.89 118.97,45.56 119.42,45.56 119.87,46 120.29,46 120.77,46.49 121.33,46.49 121.65,46.81 122.24,46.81 122.5,46.55 122.9,46.55 123.27,46.93 v4(124.44,46.93)
DDR4_DIMM_CH2_A16: length 87.2
  L03_SIG1 w0.081: v4(118.89,32.42) 118.43,31.95 118.43,31.15 118.2,30.92 118,30.92 117.66,30.58 117.66,29.57 116.93,28.84 116.23,28.84 115.29,27.9 115.29,27.51 114.68,26.91 114.68,26.17 114.19,25.67 113.34,25.67 112.77,26.24 112.58,26.24 112.48,26.34 112.48,26.47 112.58,26.57 112.84,26.57 112.94,26.68 112.94,26.81 112.84,26.91 112.64,26.91 112.47,27.08 112.47,30.18 112.57,30.28 112.7,30.28 112.8,30.18 112.8,27.9 112.9,27.8 113.04,27.8 113.14,27.9 113.14,30.19 113.24,30.29 113.37,30.29 113.47,30.19 113.47,26.96 113.38,26.86 113.38,26.28 113.62,26.04 114.03,26.04 114.23,26.24 114.23,27.73 114.48,27.98 114.79,27.98 115.18,28.37 115.18,28.69 115.02,28.84 114.31,28.84 114.21,28.95 114.21,29.08 114.31,29.18 115.1,29.18 115.2,29.28 115.2,29.41 115.1,29.51 114.42,29.51 114.32,29.62 114.32,29.75 114.42,29.85 115.51,29.85 115.61,29.75 115.61,29.07 115.71,28.97 115.84,28.97 115.94,29.07 115.94,29.88 116.04,29.98 116.19,29.98 116.29,29.88 116.29,29.29 116.39,29.19 116.53,29.19 116.63,29.29 116.63,30.12 116.73,30.23 116.86,30.23 116.96,30.12 116.96,29.69 117.06,29.59 117.2,29.59 117.3,29.69 117.3,31.22 118.04,31.96 118.04,32.97 117.63,33.38 117.63,33.51 117.73,33.61 118.01,33.61 118.11,33.71 118.11,33.85 118.01,33.95 116.73,33.95 116.63,34.05 116.63,34.18 116.73,34.28 118.04,34.28 118.14,34.38 118.14,34.52 118.04,34.62 116.74,34.62 116.63,34.72 116.63,34.85 116.74,34.95 117.99,34.95 118.09,35.06 118.09,35.19 117.99,35.29 117.12,35.29 117.02,35.39 117.02,35.52 117.12,35.62 118.03,35.62 118.13,35.73 118.13,35.86 118.03,35.96 116.97,35.96 116.86,36.07 116.86,36.94 116.76,37.05 116.63,37.05 116.53,36.94 116.53,35.86 116.43,35.76 116.29,35.76 116.19,35.86 116.19,38.57 116.45,38.84 118.08,38.84 118.18,38.94 118.18,39.07 118.08,39.17 117.13,39.17 117.03,39.27 117.03,39.41 117.13,39.51 117.94,39.51 118.04,39.61 118.04,39.74 117.94,39.84 116.93,39.84 116.83,39.94 116.83,40.08 116.93,40.18 117.9,40.18 118,40.28 118,40.41 117.9,40.51 117.08,40.51 116.98,40.61 116.98,40.75 117.08,40.85 118.09,40.85 118.2,40.95 118.2,41.08 118.09,41.18 117.12,41.18 117.02,41.29 117.02,41.42 117.12,41.52 117.86,41.52 117.98,41.64 117.98,43.75 118.16,43.93 118.53,43.93 119.01,44.41 119.53,44.41 119.93,44.81 120.27,44.81 120.54,44.54 121.26,44.54 121.67,44.95 122.01,44.95 122.46,45.4 122.88,45.4 123.53,46.06 123.73,46.06 124.22,46.54 124.58,46.54 124.83,46.79 124.83,47.35 124.72,47.45 124.31,47.45 123.81,47.95 123.81,48.09 123.97,48.25 124.12,48.25 v4(124.44,47.93)
DDR4_DIMM_CH2_A17: length 87
  L03_SIG1 w0.081: v4(125.31,46.43) 124.89,46.01 124.89,45.31 125.12,45.08 125.12,44.77 124.89,44.54 124.89,44.2 125.03,44.06 125.03,43.68 124.66,43.31 124.29,43.31 123.78,42.8 123.2,42.8 122.82,42.42 122.66,42.42 122.05,41.81 121.53,41.81 121.34,41.62 121.34,37.96 121.14,37.76 120.46,37.76 120.21,37.51 120.21,37.13 119.71,36.63 119.71,35.25 120.19,34.78 120.19,32.79 120.39,32.59 120.9,32.59 121,32.48 121,32.32 120.9,32.22 120.37,32.22 119.85,31.7 119.85,31.27 119.54,30.96 119.54,30.29 119.25,30 119.25,29.32 118.46,28.53 118.46,28.26 115.39,25.19 113.88,25.19 113.78,25.09 113.78,24.75 113.69,24.65 113.55,24.65 113.45,24.75 113.45,25.09 113.35,25.19 112.6,25.19 112.46,25.04 112.46,24.76 112.36,24.65 112.2,24.65 112.1,24.76 112.1,25.56 112,25.66 111.87,25.66 111.77,25.56 111.77,25.28 111.67,25.19 110.61,25.19 110.4,25.4 110.4,26.75 109.95,27.2 108.61,27.2 108.31,26.91 105.89,26.91 105.52,27.28 105.52,29.39 105.62,29.49 105.75,29.49 105.85,29.39 105.85,27.8 105.95,27.7 106.09,27.7 106.19,27.8 106.19,29.46 106.29,29.56 106.42,29.56 106.52,29.46 106.52,27.38 106.62,27.28 106.76,27.28 106.86,27.38 106.86,29.46 106.96,29.56 107.09,29.56 107.19,29.46 107.19,27.71 107.29,27.61 107.47,27.61 107.57,27.71 107.57,29.46 107.68,29.56 107.81,29.56 107.91,29.46 107.91,27.86 108.01,27.76 108.14,27.76 108.24,27.86 108.24,28.93 108.35,29.04 109.13,29.04 109.23,28.93 109.23,28.2 109.05,28.01 108.72,28.01 108.61,27.91 108.61,27.67 108.72,27.57 109.49,27.57 109.59,27.67 109.59,30.12 109.69,30.22 109.83,30.22 109.93,30.12 109.93,27.85 110.03,27.75 110.16,27.75 110.26,27.85 110.26,30.92 110.36,31.03 110.5,31.03 110.6,30.92 110.6,27.8 110.7,27.7 110.83,27.7 110.93,27.8 110.93,30.03 111.03,30.13 111.17,30.13 111.27,30.03 111.27,28.06 111.56,27.76 111.56,27.35 110.8,26.58 110.8,26.23 111.13,25.9 111.57,25.9 v4(112.09,26.42)
DDR4_DIMM_CH2_ACT_N: length 89.9
  L14_SIG5 w0.081: v1(116.65,47.43) 117.05,47.43 117.13,47.34 117.13,47.12 117.22,47.03 117.46,47.03 117.55,47.12 117.55,47.72 117.64,47.81 118.68,47.81 118.9,47.6 118.9,47.1 118.68,46.88 118.28,46.88 117.91,46.52 117.91,46.16 118.16,45.91 118.67,45.91 119.18,45.4 119.38,45.4 119.67,45.11 119.67,37.79 119.87,37.6 122.08,37.6 122.54,38.06 122.8,38.06 123.13,37.73 123.13,34.22 123.74,33.61 127.02,33.61 127.64,32.98 127.64,32.39 128.1,31.94 129.11,31.94 130.52,30.53 133.46,30.53 134.15,29.84 134.56,29.84 134.65,29.94 134.65,30.49 134.75,30.58 134.89,30.58 134.99,30.49 134.99,29.94 135.09,29.84 135.23,29.84 135.33,29.94 135.33,30.45 135.42,30.55 135.56,30.55 135.66,30.45 135.66,29.94 135.76,29.84 135.9,29.84 136,29.94 136,30.59 136.09,30.68 136.23,30.68 136.33,30.59 136.33,29.99 136.48,29.84 140.11,29.84 140.26,29.7 140.26,29.05 140.52,28.79 141.15,28.79 141.72,28.21 143.07,28.21 144.09,29.23 144.65,29.23 144.74,29.32 144.74,30.61 144.64,30.71 144.5,30.71 144.4,30.61 144.4,29.69 144.3,29.6 144.16,29.6 144.07,29.69 144.07,31.34 143.97,31.44 143.83,31.44 143.73,31.34 143.73,29.45 143.63,29.36 143.49,29.36 143.4,29.45 143.4,31.3 143.3,31.4 143.16,31.4 143.06,31.3 143.06,28.73 142.96,28.64 142.82,28.64 142.73,28.73 142.73,31.49 142.63,31.59 142.49,31.59 142.39,31.49 142.39,28.72 142.29,28.63 142.15,28.63 142.05,28.72 142.05,30.94 141.96,31.04 141.82,31.04 141.72,30.94 141.72,29.19 141.62,29.09 141.48,29.09 141.38,29.19 141.38,30.9 141.29,30.99 141.15,30.99 141.05,30.9 141.05,29.26 140.95,29.16 140.81,29.16 140.71,29.26 140.71,31.05 140.62,31.15 140.48,31.15 140.38,31.05 140.38,30.35 140.28,30.25 140.14,30.25 140.04,30.35 140.04,31.32 140.22,31.5 141.31,31.5 141.78,31.97 142.95,31.97 143.15,32.17 143.15,32.55 142.86,32.84 141.49,32.84 v1(141.07,32.41)
