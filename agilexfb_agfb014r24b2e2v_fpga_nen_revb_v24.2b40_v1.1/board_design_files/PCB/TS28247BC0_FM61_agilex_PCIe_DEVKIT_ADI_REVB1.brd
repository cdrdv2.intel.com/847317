# Allegro board TS28247BC0_FM61_agilex_PCIe_DEVKIT_ADI_REVB1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_DIMM_CH2_DQ57: length 73.3
  L16_SIG6 w0.081: v1(116.65,44.43) 116.19,43.98 116.19,43.81 115.93,43.55 115.62,43.55 115.14,44.04 114.68,44.04 114.42,44.3 113.71,44.3 113.47,44.05 112.88,44.05 112.52,44.41 112.1,44.41 111.62,43.92 111.33,43.92 110.95,44.3 110.28,44.3 109.97,44 109.52,44 109.11,44.41 108.64,44.41 108.17,43.93 107.78,43.93 107.28,43.43 106.88,43.43 106.4,42.95 106.06,42.95 105.58,43.43 105.26,43.43 104.78,42.95 104.41,42.95 103.89,42.43 103.49,42.43 103.21,42.15 103.21,41.18 102.48,40.44 101.88,40.44 101.36,39.93 100.86,39.93 100.34,39.41 100.34,39.23 99.41,38.29 99.15,38.29 97.78,36.92 90.34,36.92 89.99,36.58 89.99,35.1 89.72,34.83 77.4,34.83 76.77,35.46 75.32,35.46 73.39,33.53 73.39,32.26 73.38,32.25 73.38,26.74 74.77,25.34 81.91,25.34 82.01,25.45 82.01,25.8 81.91,25.9 77.76,25.9 v1(77.24,26.42)
DDR4_DIMM_CH2_DQ58: length 72.6
  L16_SIG6 w0.081: v1(72.14,32.41) 72.26,32.54 72.26,33.83 75.14,36.71 75.14,37.65 80.52,43.03 83.76,43.03 86.04,40.74 86.04,39.84 86.2,39.69 86.95,39.69 87.05,39.58 87.05,39.45 86.95,39.35 86.2,39.35 86.1,39.25 86.1,39.12 86.2,39.02 88.87,39.02 88.97,38.92 88.97,38 89.06,37.9 89.2,37.9 89.3,38 89.3,38.92 89.4,39.02 89.54,39.02 89.64,38.92 89.64,38 89.73,37.9 89.87,37.9 89.97,38 89.97,38.92 90.07,39.02 90.21,39.02 90.31,38.92 90.31,38 90.4,37.9 90.54,37.9 90.64,38 90.64,38.92 90.74,39.02 90.88,39.02 90.98,38.92 90.98,37.93 91.07,37.84 91.21,37.84 91.31,37.93 91.31,38.92 91.41,39.02 91.69,39.02 91.79,38.92 91.79,38.49 91.89,38.39 92.03,38.39 92.12,38.49 92.12,38.92 92.22,39.02 92.36,39.02 92.46,38.92 92.46,38.49 92.56,38.39 92.7,38.39 92.79,38.49 92.79,38.92 92.89,39.02 93.03,39.02 93.13,38.92 93.13,38.49 93.23,38.39 93.37,38.39 93.47,38.49 93.47,38.92 93.56,39.02 94.23,39.02 95.07,38.18 96.78,38.18 97.99,39.39 98.7,39.39 99.28,39.97 99.52,39.97 100.39,40.84 100.39,41.43 100.84,41.87 101.07,41.87 101.49,42.29 101.49,43.13 101.79,43.43 102.09,43.43 102.59,43.93 102.89,43.93 103.39,44.43 103.89,44.43 104.41,44.95 104.78,44.95 105.26,45.43 105.58,45.43 106.06,44.95 106.4,44.95 106.88,45.43 107.28,45.43 107.65,45.8 108.38,45.8 108.62,45.56 109.12,45.56 109.36,45.8 110.18,45.8 110.45,45.53 110.88,45.53 111.15,45.8 111.88,45.8 112.12,45.56 112.5,45.56 112.75,45.8 113.48,45.8 113.87,45.41 114.21,45.41 114.66,45.87 115.13,45.87 115.56,45.44 115.91,45.44 116.22,45.13 116.22,44.82 115.78,44.38 v1(115.78,43.93)
DDR4_DIMM_CH2_DQ59: length 72.8
  L16_SIG6 w0.081: v1(115.78,44.93) 114.66,44.93 114.28,44.54 113.85,44.54 113.52,44.87 112.93,44.87 112.5,45.3 112.06,45.3 111.67,44.91 111.32,44.91 110.96,44.56 110.36,44.56 109.97,44.94 109.48,44.94 109.12,45.3 108.55,45.3 108.18,44.93 107.78,44.93 107.28,44.43 106.88,44.43 106.4,43.95 106.06,43.95 105.58,44.43 105.26,44.43 104.78,43.95 104.31,43.95 103.79,43.43 103.49,43.43 102.99,42.93 102.69,42.93 102.37,42.61 102.37,41.71 101.52,40.86 100.94,40.86 99.85,39.77 99.85,39.3 99.23,38.69 98.51,38.69 97.49,37.67 94.64,37.67 94.4,37.92 92.17,37.92 91.61,37.36 89.81,37.36 89.33,36.88 89.33,35.98 89.23,35.88 88.51,35.88 88.41,35.98 88.41,38.14 88.3,38.24 88.02,38.24 87.92,38.14 87.92,35.93 87.82,35.83 87.2,35.83 87.1,35.93 87.1,38.18 87,38.28 86.71,38.28 86.61,38.18 86.61,35.59 86.51,35.49 86.23,35.49 86.13,35.59 86.13,37.59 86.03,37.7 85.8,37.7 85.7,37.59 85.7,36.18 84.7,35.18 77.7,35.18 76.66,36.22 75.34,36.22 72.6,33.48 72.6,31.08 71.29,29.78 v1(71.29,26.42)
DDR4_DIMM_CH2_DQ60: length 72.2
  L16_SIG6 w0.081: v1(79.79,32.42) 80.39,31.81 83.26,31.81 83.37,31.71 83.37,31.58 83.26,31.48 81.12,31.48 81.02,31.38 81.02,31.25 81.12,31.14 83.77,31.14 83.87,31.04 83.87,30.91 83.77,30.81 81.2,30.81 81.1,30.71 81.1,30.57 81.2,30.47 83.77,30.47 83.87,30.37 83.87,30.24 83.77,30.14 82.75,30.14 82.65,30.04 82.65,29.9 82.75,29.8 83.8,29.8 83.9,29.7 83.9,29.57 83.8,29.47 82.5,29.47 82.39,29.37 82.39,29.18 82.5,29.07 83.9,29.07 84,28.97 84,28.84 83.9,28.74 83.46,28.74 83.36,28.64 83.36,28.26 83.46,28.16 85.14,28.16 85.31,28.32 85.8,28.32 86.76,29.28 93.1,29.28 93.47,29.65 93.61,29.65 94.03,29.23 94.17,29.23 94.27,29.33 94.27,29.47 93.85,29.89 93.85,30.03 93.95,30.13 94.09,30.13 94.5,29.71 94.64,29.71 94.74,29.8 94.74,29.94 94.32,30.36 94.32,30.5 94.42,30.6 94.56,30.6 94.98,30.18 95.12,30.18 95.22,30.28 95.22,30.42 94.8,30.84 94.8,30.98 94.89,31.07 95.03,31.07 95.45,30.66 95.59,30.66 95.69,30.75 95.69,30.89 95.27,31.31 95.27,31.45 96.72,32.9 98.37,32.9 101.16,35.7 101.53,35.7 102.78,36.95 103.48,36.95 104.45,37.93 104.82,37.93 105.82,38.92 106.88,38.92 107.85,39.89 113.74,39.89 114.65,40.81 117.03,40.81 118.17,41.94 118.53,41.94 118.99,42.4 119.24,42.4 119.62,42.77 119.62,43.08 119.5,43.2 119.5,43.67 v1(119.24,43.93)
DDR4_DIMM_CH2_DQ61: length 72.1
  L16_SIG6 w0.081: v1(78.94,26.42) 79.33,26.81 81.12,26.81 81.67,27.35 85.54,27.35 85.69,27.49 86.19,27.49 86.43,27.73 88.35,27.73 88.45,27.83 88.45,27.97 88.35,28.07 87,28.07 86.9,28.17 86.9,28.31 87,28.4 88.73,28.4 88.83,28.31 88.83,27.83 88.93,27.73 90.79,27.73 90.88,27.83 90.88,27.97 90.79,28.07 89.26,28.07 89.16,28.17 89.16,28.31 89.26,28.4 91.18,28.4 91.28,28.31 91.28,27.83 91.38,27.73 92.89,27.73 92.98,27.83 92.98,27.97 92.89,28.07 91.75,28.07 91.66,28.17 91.66,28.31 91.75,28.4 93.32,28.4 93.42,28.31 93.42,27.83 93.52,27.73 96.15,27.73 96.25,27.83 96.25,27.97 96.15,28.07 93.85,28.07 93.76,28.17 93.76,28.31 93.85,28.4 96.17,28.4 96.28,28.51 96.28,28.64 96.17,28.74 95.23,28.74 95.12,28.84 95.12,28.97 95.23,29.07 96.1,29.07 96.2,29.18 96.2,29.31 96.1,29.41 95.85,29.41 95.75,29.51 95.75,29.71 97.5,31.45 98.74,31.45 99.38,32.08 99.38,32.22 102.69,35.53 103.18,35.53 104.09,36.44 104.64,36.44 105.25,37.05 106.66,37.05 107.65,38.04 113.91,38.04 114.85,38.98 116.83,38.98 117.75,39.9 118.45,39.9 119.45,40.9 120.24,40.9 120.54,41.2 120.54,43.71 120.11,44.14 v1(120.11,44.43)
DDR4_DIMM_CH2_DQ62: length 72.2
  L16_SIG6 w0.081: v1(73.84,32.42) 73.84,32.72 75.61,34.48 90.26,34.48 90.4,34.62 90.4,36.33 90.5,36.42 90.63,36.42 90.73,36.33 90.73,34.63 90.83,34.53 90.97,34.53 91.07,34.63 91.07,36.33 91.17,36.43 91.3,36.43 91.4,36.33 91.4,34.58 91.5,34.48 91.64,34.48 91.74,34.58 91.74,36.35 91.84,36.45 91.98,36.45 92.07,36.35 92.07,34.6 92.17,34.5 92.31,34.5 92.41,34.6 92.41,36.37 92.51,36.46 92.65,36.46 92.74,36.37 92.74,34.59 92.84,34.49 92.98,34.49 93.08,34.59 93.08,36.35 93.18,36.45 93.32,36.45 93.41,36.35 93.41,35 93.51,34.9 93.65,34.9 93.75,35 93.75,35.64 94.02,35.92 97.31,35.92 99.24,37.85 99.63,37.85 100.7,38.93 101.13,38.93 102.23,40.03 102.59,40.03 104.52,41.96 104.78,41.96 105.25,42.43 105.58,42.43 106.05,41.96 106.48,41.96 106.95,42.43 107.28,42.43 107.81,42.96 108.16,42.96 108.6,43.4 109.02,43.4 109.45,42.96 109.95,42.96 110.42,43.43 110.88,43.43 111.32,42.99 111.68,42.99 112.14,43.45 112.53,43.45 112.93,43.05 113.47,43.05 113.91,43.5 114.37,43.5 114.68,43.8 115.06,43.8 115.57,43.3 115.99,43.3 116.52,43.83 116.62,43.83 117.03,44.25 117.03,45.21 117.33,45.51 117.68,45.51 117.96,45.8 118.69,45.8 119.24,45.24 v1(119.24,44.93)
DDR4_DIMM_CH2_DQ63: length 72.2
  L16_SIG6 w0.081: v1(120.11,45.43) 120.11,45.9 119.48,46.53 118.98,46.53 118.71,46.8 116.61,46.8 116.29,46.47 115.62,46.47 115.26,46.83 114.72,46.83 114.31,46.42 113.86,46.42 113.46,46.82 112.88,46.82 112.6,46.54 112.09,46.54 111.84,46.8 111.26,46.8 111.01,46.54 110.25,46.54 109.98,46.81 109.43,46.81 108.99,46.36 108.58,46.36 108.28,46.06 107.65,46.06 107.28,46.43 106.88,46.43 106.4,45.95 106.06,45.95 105.58,46.43 105.26,46.43 104.78,45.95 104.41,45.95 103.89,45.43 103.49,45.43 102.99,44.93 102.59,44.93 102.09,44.43 101.8,44.43 101.27,43.9 100.93,43.9 100.64,43.61 100.64,42.78 100.28,42.41 99.98,42.41 99.76,42.19 99.76,41.29 99.37,40.89 99.18,40.89 98.39,40.11 98.08,40.11 96.91,38.94 94.93,38.94 94.42,39.45 87.91,39.45 83.85,43.51 80.02,43.51 75.24,38.74 75.24,38.23 74.76,37.75 74.76,36.83 71.63,33.7 71.63,31.01 70.92,30.3 70.92,26.2 71.13,25.99 71.89,25.99 72.02,26.01 v1(72.99,26.42)
DDR4_DIMM_CH2_DQ64: length 44.5
  L12_SIG4 w0.089: v1(152.04,32.42) 152.04,27.84 150.6,26.4 149.58,25.97 148.61,25.97 148.5,26.02 148.22,26.31 148.22,27.24 147.91,27.54 147.43,27.54 147.15,27.82 147.15,29.26 147.06,29.36 146.93,29.36 146.83,29.26 146.83,27.8 146.73,27.7 146.61,27.7 146.51,27.8 146.51,29.34 145.4,30.46 141.16,30.46 140.6,31.02 139.09,31.02 137.87,32.24 136.45,32.24 136.2,31.99 135.72,31.99 133.17,34.54 133.17,35.12 131.33,36.97 131.33,38.65 130.01,39.97 130.01,41.04 129.89,41.16 129.89,41.65 130.02,41.78 130.02,42.08 129.77,42.33 129.41,42.33 129.05,42.69 129.05,43.18 129.14,43.27 129.14,43.58 128.77,43.96 v1(128.77,44.43)
DDR4_DIMM_CH2_DQ65: length 44.8
  L12_SIG4 w0.089: v1(127.9,44.93) 128.28,44.55 128.28,44.29 128.34,44.23 128.34,43.32 128.5,43.17 128.5,42.69 128.39,42.58 128.39,42.27 128.61,42.05 128.98,42.05 129.54,41.49 129.54,41.06 129.66,40.94 129.66,39.83 130.89,38.6 130.89,36.22 135.54,31.57 136.3,31.57 136.57,31.84 137.33,31.84 139.16,30.01 143.46,30.01 143.69,29.78 143.69,28.73 143.79,28.63 143.93,28.63 144.03,28.73 144.03,29.92 144.13,30.02 144.26,30.02 144.36,29.92 144.36,28.95 144.46,28.85 144.6,28.85 144.7,28.95 144.7,29.97 144.8,30.06 144.94,30.06 145.03,29.97 145.03,27.89 145.13,27.79 145.27,27.79 145.37,27.89 145.37,29.63 145.47,29.73 145.61,29.73 145.7,29.63 145.7,28.11 146.79,27.02 147.19,27.02 147.76,26.46 147.76,26.23 148.24,25.74 148.55,25.62 149.68,25.62 150.9,26.12 v1(151.19,26.42)
DDR4_DIMM_CH2_DQ66: length 44.5
  L12_SIG4 w0.089: v1(146.09,32.42) 145.83,32.16 145.18,32.16 144.9,31.88 144.9,31.36 145.06,31.19 145.56,31.19 145.66,31.09 145.66,30.9 145.56,30.8 144.69,30.8 144.59,30.9 144.59,31.92 144.48,32.02 144.35,32.02 144.25,31.92 144.25,30.95 144.15,30.85 144.02,30.85 143.92,30.95 143.92,32.49 143.81,32.59 143.22,32.59 143.12,32.49 143.12,30.91 143.02,30.81 142.89,30.81 142.79,30.91 142.79,31.39 142.68,31.49 142.55,31.49 142.45,31.39 142.45,30.92 142.35,30.82 141.5,30.82 141.39,30.92 141.39,31.64 141.56,31.8 142.41,31.8 142.51,31.9 142.51,32.03 142.41,32.13 141.55,32.13 141.44,32.24 141.44,32.39 141.55,32.49 142.21,32.49 142.31,32.59 142.31,32.79 142.21,32.89 140.8,32.89 140.59,32.68 140.59,31.88 140.48,31.78 139.77,31.78 139.67,31.88 139.67,32.76 139.56,32.86 139.38,32.86 139.28,32.76 139.28,31.91 139.18,31.81 139.04,31.81 138.94,31.91 138.94,32.74 138.84,32.84 136.31,32.84 134.14,35 133.8,35 131.67,37.14 131.67,38.79 130.36,40.1 130.36,41.03 130.11,41.27 130.11,41.57 130.27,41.73 130.27,42.13 129.85,42.55 129.49,42.55 129.26,42.77 129.26,43.09 129.35,43.19 129.35,43.67 129.2,43.83 129.2,44.66 129.13,44.73 129.13,45.07 v1(128.77,45.43)
DDR4_DIMM_CH2_DQ67: length 44.6
  L12_SIG4 w0.089: v1(145.24,26.42) 145.88,26.42 145.98,26.52 145.98,26.75 145.88,26.85 143.52,26.85 143.42,26.95 143.42,27.09 143.52,27.18 143.92,27.18 144.02,27.28 144.02,27.42 143.92,27.52 143.17,27.52 143.08,27.42 143.08,26.95 142.98,26.85 142.3,26.85 142.2,26.95 142.2,27.57 142.8,28.17 142.8,29.4 142.7,29.5 142.37,29.5 142.27,29.4 142.27,28.27 142.16,28.17 141.92,28.17 141.82,28.27 141.82,29.4 141.72,29.5 141.48,29.5 141.38,29.4 141.38,26.96 141.28,26.86 140.71,26.86 140.61,26.96 140.61,27.97 140.51,28.07 140.38,28.07 140.27,27.97 140.27,26.91 140.17,26.81 140.04,26.81 139.94,26.91 139.94,28.75 138.48,30.2 137.55,30.2 136.92,30.83 134.9,30.83 134.65,31.08 134.65,31.97 131.95,34.67 131.01,34.67 130.88,34.8 130.88,35.74 130.39,36.23 130.39,36.96 130.12,37.23 130.12,37.62 130.33,37.83 130.33,38.07 130.12,38.28 130.12,38.86 129.32,39.66 129.32,40.85 129.19,40.98 129.19,41.54 128.9,41.83 128.53,41.83 128.18,42.18 128.18,42.67 128.29,42.78 128.29,43.08 127.9,43.47 v1(127.9,43.93)
DDR4_DIMM_CH2_DQ68: length 41.6
  L12_SIG4 w0.089: v1(131.37,44.93) 132.26,44.93 132.88,44.31 133.25,44.31 133.48,44.07 133.48,43.78 133.34,43.64 133.34,43.21 133.5,43.06 133.5,42.79 133.38,42.67 133.38,42.18 133.47,42.08 133.47,41.77 133.32,41.62 133.32,41.22 133.73,40.81 133.97,40.81 134.36,40.65 135.07,39.94 137.67,39.55 138.96,39.02 139.75,39.02 140.85,37.92 141.24,37.92 141.34,38.02 141.34,38.41 141.44,38.51 141.58,38.51 141.68,38.41 141.68,38.02 141.77,37.92 141.91,37.92 142.01,38.02 142.01,38.23 142.11,38.33 142.25,38.33 142.35,38.23 142.35,38.02 142.45,37.92 143.72,37.92 143.82,37.82 143.82,37.68 143.72,37.58 143.34,37.58 143.24,37.48 143.24,37.35 143.34,37.25 144.43,37.25 144.65,37.03 146.37,37.03 147.59,35.81 151.08,33.95 151.44,33.8 152.1,33.44 152.93,32.89 153.29,32.21 153.29,31.17 153.37,31.09 153.37,29.16 153.29,29.08 153.29,27.56 153.39,27.46 153.58,27.46 153.68,27.56 v1(153.68,32.41)
DDR4_DIMM_CH2_DQ69: length 40.8
  L12_SIG4 w0.089: v1(132.23,44.43) 132.67,43.99 132.67,43.82 132.86,43.63 132.86,43.22 132.72,43.08 132.72,42.77 132.85,42.65 132.85,42.22 132.72,42.09 132.72,41.76 132.89,41.6 132.89,41.09 133.06,40.92 133.2,40.92 133.6,40.52 134,40.52 135.64,38.87 136.08,38.87 136.18,38.97 136.18,39.27 136.28,39.37 136.41,39.37 136.51,39.27 136.51,38.9 136.61,38.81 136.75,38.81 136.85,38.9 136.85,39.15 136.95,39.24 137.09,39.24 137.18,39.15 137.18,38.49 137.28,38.39 137.42,38.39 137.52,38.49 137.52,38.99 137.62,39.09 137.76,39.09 137.85,38.99 137.85,38.57 137.99,38.43 138.14,38.43 138.24,38.53 138.24,38.73 138.34,38.83 138.48,38.83 138.58,38.73 138.58,38.08 138.68,37.98 138.82,37.98 138.92,38.08 138.92,38.51 139.02,38.61 139.17,38.61 139.27,38.51 139.27,38 139.37,37.9 139.52,37.9 139.62,38 139.62,38.17 139.72,38.27 139.92,38.27 140.02,38.17 140.02,37.22 140.16,37.07 142.74,37.07 143.15,36.66 146.2,36.66 147.33,35.54 152.13,32.97 152.48,32.62 152.48,31.2 152.95,30.73 152.95,29.56 152.71,29.31 152.71,27.16 152.26,26.71 151.7,26.71 151.6,26.61 151.6,26.39 151.7,26.29 152.33,26.29 152.45,26.42 v1(152.89,26.42)
DDR4_DIMM_CH2_DQ70: length 41.4
  L12_SIG4 w0.089: v1(147.76,32.41) 147.76,31.94 147.66,31.84 147.43,31.84 147.33,31.74 147.33,31.61 147.43,31.5 148.52,31.5 148.62,31.4 148.62,31.27 148.52,31.17 147.49,31.17 147.39,31.07 147.39,30.93 147.49,30.83 150,30.83 150.73,31.56 150.73,31.94 151.02,32.22 151.53,32.22 151.63,32.32 151.63,32.45 151.53,32.55 150.78,32.55 150.27,33.06 149.75,33.06 149.66,33.15 149.66,33.3 149.75,33.39 149.97,33.39 150.07,33.5 150.07,33.63 149.97,33.73 147.89,33.73 147.8,33.82 147.8,33.98 147.89,34.06 148.72,34.06 148.82,34.17 148.82,34.3 148.72,34.4 147.61,34.4 147.41,34.6 147.41,34.91 146.03,36.3 142.93,36.3 142.5,36.73 140.12,36.73 140.02,36.63 140.02,36.19 139.92,36.09 139.78,36.09 139.68,36.19 139.68,36.63 139.58,36.73 139.33,36.73 138.02,38.04 136.6,38.04 136.5,37.94 136.5,37.69 136.4,37.59 136.26,37.59 136.16,37.69 136.16,37.94 136.06,38.04 135.46,38.04 135.25,38.25 135.25,38.78 134.4,39.63 134.01,39.63 132.64,41 132.64,41.55 132.49,41.71 132.49,42.15 132.64,42.3 132.64,42.56 132.51,42.69 132.51,43.18 132.61,43.27 132.61,43.58 132.26,43.93 v1(131.37,43.93)
DDR4_DIMM_CH2_DQ71: length 41.6
  L12_SIG4 w0.089: v1(146.94,26.54) 148.02,25.46 148.49,25.27 149.86,25.27 153.07,26.07 153.09,26.08 153.96,26.79 154.07,26.9 154.1,26.99 154.13,27.11 154.19,27.7 154.19,30.17 154.07,32.45 154.05,32.54 153.98,32.65 153.88,32.76 152.37,33.77 149.45,35.33 148.89,35.56 148.11,36.03 146.96,36.97 146.57,37.36 146.09,37.76 145.93,37.82 144.97,38.01 140.76,39.07 140.32,39.26 139.51,39.7 139.29,39.79 138.97,39.87 137.38,40.03 136.65,40.13 135.2,40.28 134.62,40.85 134.17,41.04 133.82,41.04 133.58,41.29 133.58,41.57 133.68,41.68 133.68,42.17 133.59,42.26 133.59,42.58 133.71,42.7 133.71,43.15 133.59,43.27 133.59,43.59 133.7,43.69 133.7,44.16 133.32,44.54 133.04,44.54 132.89,44.61 132.79,44.7 132.41,45.17 v1(132.23,45.43)
DDR4_DIMM_CH2_DQS_N0: length 76.1
  L12_SIG4 w0.085: v1(135.7,50.43) 135.7,50.13 135.79,50.04 135.91,50.04 135.98,50.11 136.08,50.34 136.08,50.52 135.96,50.8 135.96,51.06 136.05,51.28 136.21,51.44 136.45,51.54 136.6,51.54 arc(136.73,51.57) 136.84,51.64 136.84,51.64 arc(136.87,51.69) 136.9,51.74 136.93,51.81 arc(136.97,51.88) 137.02,51.94 arc(137.14,52.02) 137.29,52.05 137.5,52.05 arc(137.59,52.07) 137.66,52.12 137.7,52.15 137.76,52.24 137.76,52.25 arc(137.79,52.31) 137.83,52.35 137.89,52.41 arc(138.04,52.51) 138.21,52.55 138.31,52.55 arc(138.45,52.57) 138.58,52.65 138.6,52.68 arc(138.62,52.7) 138.62,52.71 138.64,52.74 arc(138.68,52.83) 138.74,52.9 138.74,52.9 arc(138.9,53.01) 139.08,53.04 139.25,53.04 arc(139.43,53.01) 139.58,52.91 arc(139.65,52.82) 139.7,52.73 arc(139.74,52.67) 139.78,52.61 arc(139.85,52.56) 139.93,52.55 140.08,52.55 arc(140.2,52.57) 140.29,52.64 140.3,52.64 arc(140.33,52.67) 140.35,52.71 140.39,52.78 arc(140.58,52.96) 140.83,53.03 140.99,53.03 arc(141.02,53.04) 141.05,53.06 141.19,53.19 141.24,53.27 arc(141.48,53.47) 141.77,53.54 141.87,53.54 arc(141.95,53.56) 142.01,53.6 arc(142.04,53.63) 142.05,53.66 142.08,53.72 arc(142.12,53.79) 142.17,53.86 arc(142.38,53.99) 142.62,54.04 148.04,54.04 148.65,54.65 152.04,54.65 152.64,54.05 158.17,54.05 158.78,53.44 159.33,53.44 160.02,52.75 160.02,51.96 160.41,51.57 161.16,51.57 167.36,45.37 169.67,45.37 170.29,44.75 170.29,44.24 171.2,43.34 172.41,43.34 173.08,43.06 174.89,41.25 178.52,41.25 181.75,38.02 184.32,38.02 187.23,35.11 187.23,34.05 189.2,32.08 189.2,29.83 188.73,29.36 187.92,29.36 187.4,29.87 186.92,29.87 186.62,29.58 186.62,26.68 v1(186.89,26.42)
DDR4_DIMM_CH2_DQS_N1: length 66.8
  L14_SIG5 w0.079: v1(135.7,45.43) 135.7,45.14 135.78,45.05 135.88,45.05 136,45.16 136.07,45.34 136.07,45.54 135.95,45.82 135.95,46.05 136.07,46.32 136.19,46.45 136.43,46.54 136.6,46.54 arc(136.7,46.56) 136.79,46.63 137.05,46.9 arc(137.2,47.01) 137.38,47.04 137.46,47.04 arc(137.57,47.06) 137.66,47.13 137.92,47.4 arc(138.07,47.51) 138.24,47.54 138.33,47.54 arc(138.53,47.5) 138.69,47.39 138.95,47.11 arc(139.02,47.06) 139.11,47.04 139.2,47.04 arc(139.3,47.06) 139.39,47.13 139.65,47.4 arc(139.8,47.51) 139.98,47.54 140.06,47.54 arc(140.26,47.5) 140.42,47.39 140.68,47.11 arc(140.75,47.06) 140.84,47.04 140.93,47.04 arc(141.03,47.06) 141.12,47.13 141.38,47.4 arc(141.53,47.51) 141.71,47.54 141.79,47.54 arc(141.9,47.56) 141.99,47.63 142.25,47.9 arc(142.4,48.01) 142.57,48.04 143.89,48.04 145.01,49.15 145.01,49.7 145.34,50.03 154.1,50.03 155.2,48.92 155.2,48.19 155.59,47.8 160.86,47.8 164.25,44.42 165.22,44.42 166.66,42.97 166.66,42.07 169.03,39.7 169.21,39.7 170.2,38.7 170.2,38.23 170.74,37.7 176.05,37.7 177.12,36.63 177.12,36.4 177.85,35.67 178.22,35.67 179.05,34.85 179.05,31.76 178.85,31.57 178.85,30.24 178.44,29.83 177.74,29.83 177.64,29.73 177.64,29.31 177.74,29.2 178.59,29.2 178.82,28.97 178.82,28.07 178.59,27.84 177.56,27.84 177.22,27.49 177.22,26.74 v1(177.54,26.42)
DDR4_DIMM_CH2_DQS_N2: length 56.7
  L12_SIG4 w0.085: v1(168.19,26.42) 167.87,26.74 167.87,27.25 168.21,27.59 168.67,27.59 169.07,27.98 169.07,28.48 168.71,28.83 167.5,28.83 167.3,29.03 167.3,29.34 167.5,29.54 169.23,29.54 169.5,29.81 169.5,31.55 169.68,31.73 169.68,33.01 167.07,35.61 166.92,35.61 166.01,36.52 166.01,36.67 164.69,38 160.32,38 159.1,39.21 159.1,42.08 154.98,46.2 154.25,46.2 153.4,47.05 146.05,47.05 145.58,46.57 145.58,45.83 144.8,45.05 142.57,45.05 arc(142.47,45.07) 142.38,45.13 142.35,45.16 142.34,45.18 arc(142.27,45.27) 142.19,45.36 142.17,45.38 arc(141.99,45.5) 141.77,45.54 arc(141.48,45.47) 141.24,45.27 141.19,45.19 141.05,45.06 arc(141.02,45.04) 140.99,45.03 140.89,45.03 arc(140.76,45.06) 140.65,45.13 140.62,45.16 140.53,45.29 140.41,45.42 arc(140.27,45.51) 140.11,45.54 140.04,45.54 arc(139.8,45.49) 139.59,45.36 139.57,45.33 139.49,45.22 139.48,45.19 139.45,45.15 arc(139.31,45.07) 139.16,45.03 139.16,45.03 arc(138.9,44.98) 138.7,44.82 138.56,44.65 138.55,44.63 arc(138.45,44.57) 138.34,44.55 138.21,44.55 arc(138.04,44.51) 137.89,44.41 137.83,44.35 arc(137.79,44.31) 137.76,44.25 137.76,44.24 137.7,44.15 137.66,44.12 arc(137.59,44.07) 137.5,44.05 137.29,44.05 arc(137.14,44.02) 137.02,43.94 arc(136.97,43.88) 136.93,43.81 136.9,43.74 arc(136.87,43.69) 136.84,43.64 136.84,43.64 arc(136.73,43.57) 136.6,43.54 136.45,43.54 136.21,43.44 136.05,43.28 135.96,43.06 135.96,42.8 136.08,42.52 136.08,42.34 135.98,42.11 135.91,42.04 135.8,42.04 135.7,42.14 v1(135.7,42.43)
DDR4_DIMM_CH2_DQS_N3: length 56.3
  L14_SIG5 w0.079: v1(129.64,42.93) 129.64,42.64 129.74,42.54 129.93,42.54 130.12,42.35 130.24,42.07 130.24,41.78 130,41.19 130,40.9 131.57,39.32 132.21,39.32 133.48,38.05 141.14,38.05 143.3,35.89 144.88,35.89 145.72,35.04 146.27,35.04 147.64,33.67 157.17,33.67 157.7,33.15 157.7,31.82 157.5,31.62 157.5,31.06 157.76,30.79 162.64,30.79 162.9,30.53 162.9,29.88 162.64,29.62 158.86,29.62 158.73,29.5 158.73,29.04 158.86,28.91 162.13,28.91 162.39,28.65 162.39,28 162.13,27.74 158.67,27.74 158.54,27.61 158.54,26.66 v1(158.79,26.42)
DDR4_DIMM_CH2_DQS_N4: length 45.8
  L16_SIG6 w0.079: 118.82,36.1 119.7,36.99 120.43,36.99 121.42,37.97 121.42,38.55 123.18,40.31 123.18,41.47 123.25,41.64 123.37,41.76 123.48,41.8 123.67,41.8 123.91,41.91 124.08,42.07 124.17,42.3 124.17,42.57 124.05,42.87 124.05,42.99 124.18,43.29 124.18,43.58 124.06,43.85 124.06,44.02 124.17,44.28 124.17,44.57 124.06,44.84 123.81,45.1 v1(123.57,45.43) ; v1(103.59,26.42) 103.27,26.74 103.27,27.28 102.99,27.56 100.31,27.56 100.2,27.66 100.2,28.05 100.31,28.15 102.98,28.15 103.22,28.38 103.22,28.96 102.98,29.19 100.72,29.19 100.62,29.29 100.62,29.68 100.72,29.78 101.94,29.78 102.28,30.12 102.28,31.92 103.22,32.85 104.47,32.85 105.68,34.06 109.32,34.06 110.03,34.78 113.41,34.78 114.43,35.8
  L16_SIG6 w0.081: 118.82,36.1 117.85,36.1 117.55,35.8 114.43,35.8
DDR4_DIMM_CH2_DQS_N5: length 52.3
  L12_SIG4 w0.085: v1(123.57,42.43) 123.57,42.09 123.68,41.99 123.81,41.99 123.93,41.94 124.09,41.78 124.18,41.55 124.18,41.31 124.09,41.09 123.92,40.92 123.69,40.82 123.43,40.82 123.2,40.59 123.2,39.34 122.51,38.65 122.51,38.09 120.78,36.36 120.78,35.25 119.21,33.68 95.53,33.68 94.78,32.93 94.22,32.93 92.97,31.68 92.97,30.98 93.1,30.85 94.96,30.85 95.22,30.59 95.22,29.94 94.96,29.68 93.1,29.68 92.97,29.55 92.97,29.17 93.1,29.04 94.88,29.04 95.17,28.75 95.17,28.19 94.88,27.9 93.24,27.9 93.12,27.77 93.12,27.38 93.22,27.28 93.75,27.28 94,27.03 94,26.66 v1(94.24,26.42)
DDR4_DIMM_CH2_DQS_N6: length 59.8
  L12_SIG4 w0.085: v1(117.51,42.93) 117.51,42.64 117.61,42.54 117.73,42.54 117.8,42.62 117.87,42.78 118.05,42.96 118.25,43.04 118.52,43.04 118.71,42.97 118.89,42.79 118.98,42.57 118.98,42.3 118.87,42.03 118.87,41.86 118.99,41.56 118.99,40.19 118.6,39.8 118.18,39.8 117.2,38.82 93.97,38.82 93.08,37.93 93.08,37.22 92.39,36.54 92.08,36.54 88.53,32.99 88.53,32.46 88.99,32 88.99,27.86 88.55,27.42 87.13,27.42 86.29,26.58 86.29,25.3 87.22,24.37 87.22,23.62 86.84,23.24 83.82,23.24 83.35,23.71 83.35,24.33 84.45,25.43 84.45,25.58 84.66,25.79 84.81,25.79 85.24,26.22 85.24,26.62 84.93,26.93 84.68,26.93 84.58,26.83 84.58,26.7 v1(84.87,26.42)
DDR4_DIMM_CH2_DQS_N7: length 72.5
  L16_SIG6 w0.079: v1(117.51,44.93) 117.51,44.69 117.66,44.54 117.82,44.54 117.99,44.37 118.12,44.06 118.12,43.8 118.04,43.61 117.91,43.48 arc(117.73,43.36) 117.51,43.31 117.46,43.31 arc(117.34,43.28) 117.24,43.2 117.08,43.01 arc(116.9,42.87) 116.68,42.81 116.6,42.81 arc(116.47,42.78) 116.37,42.7 116.22,42.51 arc(116.04,42.37) 115.82,42.31 115.74,42.31 arc(115.52,42.37) 115.34,42.51 115.19,42.7 arc(115.09,42.79) 114.96,42.81 114.88,42.81 arc(114.76,42.78) 114.66,42.7 114.51,42.51 arc(114.33,42.37) 114.1,42.31 114.01,42.31 arc(113.88,42.28) 113.78,42.2 113.63,42.01 arc(113.45,41.87) 113.22,41.81 113.14,41.81 arc(112.91,41.87) 112.73,42.01 112.58,42.2 arc(112.48,42.29) 112.36,42.31 112.28,42.31 arc(112.16,42.28) 112.06,42.2 111.91,42.01 arc(111.73,41.87) 111.5,41.81 111.42,41.81 arc(111.19,41.87) 111.01,42.01 110.86,42.2 arc(110.76,42.29) 110.63,42.31 110.54,42.31 arc(110.41,42.28) 110.31,42.2 110.16,42.01 arc(109.98,41.87) 109.76,41.81 109.66,41.81 arc(109.44,41.87) 109.26,42.01 109.11,42.2 arc(109.01,42.29) 108.88,42.31 108.81,42.31 arc(108.68,42.28) 108.58,42.2 108.43,42.01 arc(108.25,41.87) 108.03,41.81 107.94,41.81 arc(107.81,41.79) 107.71,41.7 107.59,41.54 107.32,41.27 107,41.27 106.54,40.82 105.04,40.82 102.93,38.71 102.19,38.71 101.29,37.81 100.79,37.81 100.21,37.23 100.21,36.78 99.23,35.8 98.83,35.8 97.84,34.82 94.74,34.82 93.58,33.65 76.88,33.65 76.22,33 75.29,33 74.19,31.9 74.19,30.28 74.71,29.76 74.71,29.18 74.82,29.07 75.35,29.07 75.45,29.18 75.45,30.69 75.71,30.95 76.47,30.95 76.73,30.69 ; v1(75.54,26.42) 75.24,26.71 75.24,27.2 75.45,27.41 80.65,27.41 80.89,27.65 80.89,28.81 80.65,29.04
  L16_SIG6 w0.081: 80.65,29.04 76.91,29.04 76.73,29.22 76.73,30.69
DDR4_DIMM_CH2_DQS_N8: length 43.3
  L12_SIG4 w0.085: v1(129.64,44.93) 129.93,44.54 130.12,44.35 130.24,44.06 130.24,43.79 130.12,43.51 130.12,43.34 130.18,43.2 130.27,43.12 130.44,43.05 130.62,43.05 130.85,42.95 131.01,42.79 131.11,42.55 131.11,42.32 130.99,42.03 130.99,41.85 131.11,41.56 131.11,41.3 131.21,41.07 131.21,40.42 132.89,38.73 132.89,37.42 136.35,33.97 143.65,33.97 144.5,33.13 146.26,33.13 146.71,32.68 146.71,31.85 146.55,31.69 146.55,30.7 147.04,30.21 147.58,30.21 147.99,29.8 147.99,28.52 148.13,28.39 148.47,28.39 148.6,28.51 148.6,29.77 148.82,29.99 149.46,29.99 149.68,29.77 149.68,28.72 149.78,28.62 150.24,28.62 150.34,28.72 150.34,30.2 150.57,30.44 151.2,30.44 151.43,30.21 151.43,28.25 150.68,27.5 149.39,27.5 149.24,27.35 149.24,26.67 v1(149.49,26.42)
DDR4_DIMM_CH2_DQS_P0: length 75.9
  L12_SIG4 w0.085: v1(186.04,26.42) 186.39,26.77 186.39,29.68 186.82,30.1 187.5,30.1 188.01,29.59 188.64,29.59 188.98,29.93 188.98,31.99 187,33.96 187,35.01 186.8,35.22 186.54,35.22 186.32,35.44 186.32,35.69 184.22,37.79 181.65,37.79 178.42,41.02 174.79,41.02 172.95,42.86 172.36,43.11 171.1,43.11 170.06,44.15 170.06,44.65 169.58,45.14 167.27,45.14 161.06,51.34 160.32,51.34 159.8,51.87 159.8,52.66 159.24,53.22 158.68,53.22 158.07,53.83 152.54,53.83 151.94,54.43 148.75,54.43 148.13,53.81 142.62,53.81 arc(142.46,53.78) 142.33,53.69 arc(142.31,53.67) 142.29,53.63 142.26,53.57 arc(142.23,53.5) 142.18,53.44 arc(142.04,53.35) 141.87,53.31 141.77,53.31 arc(141.58,53.27) 141.43,53.14 141.36,53.05 141.21,52.9 arc(141.11,52.83) 140.99,52.8 140.83,52.8 arc(140.69,52.77) 140.59,52.66 140.55,52.59 arc(140.51,52.53) 140.46,52.48 140.46,52.47 arc(140.29,52.36) 140.08,52.32 139.93,52.32 arc(139.76,52.35) 139.62,52.45 arc(139.55,52.54) 139.49,52.64 139.49,52.64 arc(139.46,52.7) 139.42,52.74 arc(139.34,52.8) 139.25,52.81 139.08,52.81 arc(138.98,52.8) 138.9,52.74 arc(138.87,52.7) 138.85,52.66 138.83,52.63 arc(138.81,52.57) 138.77,52.52 138.74,52.49 arc(138.54,52.36) 138.31,52.32 138.21,52.32 arc(138.12,52.3) 138.05,52.25 137.99,52.19 arc(137.98,52.18) 137.97,52.16 137.96,52.14 137.88,52.01 137.83,51.96 arc(137.67,51.86) 137.5,51.82 137.29,51.82 arc(137.23,51.81) 137.18,51.77 arc(137.16,51.75) 137.14,51.72 137.11,51.65 arc(137.06,51.56) 137,51.48 arc(136.81,51.36) 136.6,51.31 136.5,51.31 136.34,51.25 136.25,51.16 136.19,51.01 136.19,50.85 136.3,50.57 136.3,50.3 136.17,49.98 136.01,49.81 135.8,49.81 135.7,49.71 v1(135.7,49.43)
DDR4_DIMM_CH2_DQS_P1: length 66.6
  L14_SIG5 w0.079: v1(135.7,44.43) 135.7,44.72 135.79,44.82 135.98,44.82 136.19,45.03 136.3,45.3 136.3,45.58 136.18,45.87 136.18,46 136.26,46.19 136.32,46.25 136.47,46.31 136.6,46.31 arc(136.79,46.35) 136.96,46.47 137.22,46.74 arc(137.29,46.8) 137.38,46.81 137.46,46.81 arc(137.66,46.85) 137.82,46.97 138.08,47.24 arc(138.16,47.3) 138.24,47.31 138.33,47.31 arc(138.44,47.29) 138.52,47.23 138.78,46.96 arc(138.93,46.85) 139.11,46.81 139.2,46.81 arc(139.39,46.85) 139.56,46.97 139.81,47.24 arc(139.89,47.3) 139.98,47.31 140.06,47.31 arc(140.17,47.29) 140.26,47.23 140.51,46.96 arc(140.66,46.85) 140.84,46.81 140.93,46.81 arc(141.12,46.85) 141.29,46.97 141.55,47.24 arc(141.62,47.3) 141.71,47.31 141.79,47.31 arc(141.99,47.35) 142.15,47.47 142.41,47.74 arc(142.49,47.8) 142.57,47.81 143.99,47.81 145.23,49.06 145.23,49.6 145.43,49.8 154,49.8 154.97,48.83 154.97,48.09 155.49,47.57 160.77,47.57 164.15,44.19 165.12,44.19 166.43,42.88 166.43,41.97 168.94,39.47 169.11,39.47 169.98,38.61 169.98,38.14 170.64,37.47 175.96,37.47 176.9,36.53 176.9,36.31 177.76,35.44 178.12,35.44 178.82,34.75 178.82,33.44 178.63,33.26 178.63,32.91 178.82,32.73 178.82,31.85 178.62,31.66 178.62,30.33 178.35,30.06 177.64,30.06 177.41,29.83 177.41,29.21 177.64,28.98 178.49,28.98 178.59,28.87 178.59,28.17 178.49,28.06 177.47,28.06 176.99,27.59 176.99,26.72 v1(176.69,26.42)
DDR4_DIMM_CH2_DQS_P2: length 56.3
  L12_SIG4 w0.085: v1(135.7,41.43) 135.7,41.66 135.85,41.81 136.01,41.81 136.17,41.98 136.3,42.3 136.3,42.56 136.19,42.85 136.19,43.01 136.25,43.16 136.34,43.25 136.5,43.31 136.6,43.31 arc(136.81,43.36) 137,43.48 arc(137.06,43.56) 137.11,43.65 137.14,43.72 arc(137.16,43.75) 137.18,43.77 arc(137.23,43.81) 137.29,43.82 137.5,43.82 arc(137.67,43.86) 137.83,43.96 137.88,44.01 137.96,44.14 137.97,44.16 arc(137.98,44.18) 137.99,44.19 138.05,44.25 arc(138.12,44.3) 138.21,44.32 138.34,44.32 arc(138.54,44.36) 138.71,44.47 138.73,44.49 138.88,44.68 arc(139,44.77) 139.16,44.81 139.16,44.81 arc(139.4,44.85) 139.61,44.99 139.67,45.06 139.69,45.11 139.75,45.19 139.76,45.19 arc(139.89,45.28) 140.04,45.31 140.11,45.31 arc(140.18,45.3) 140.25,45.26 140.35,45.15 140.45,45.01 140.49,44.97 arc(140.67,44.85) 140.89,44.8 140.99,44.8 arc(141.11,44.83) 141.21,44.9 141.36,45.05 141.43,45.14 arc(141.58,45.27) 141.77,45.31 arc(141.9,45.29) 142.01,45.22 142.03,45.19 arc(142.09,45.13) 142.15,45.05 142.17,45.01 142.22,44.97 arc(142.38,44.86) 142.57,44.82 144.89,44.82 145.8,45.74 145.8,46.48 146.15,46.82 153.31,46.82 154.15,45.97 154.88,45.97 158.87,41.98 158.87,39.12 160.22,37.77 164.59,37.77 165.78,36.58 165.78,36.42 166.82,35.38 166.98,35.38 169.45,32.91 169.45,31.83 169.27,31.65 169.27,29.91 169.14,29.77 167.41,29.77 167.08,29.43 167.08,28.94 167.41,28.6 168.62,28.6 168.84,28.38 168.84,28.08 168.58,27.82 168.11,27.82 167.64,27.35 167.64,26.72 v1(167.34,26.42)
DDR4_DIMM_CH2_DQS_P3: length 56
  L14_SIG5 w0.079: v1(129.64,41.93) 129.64,42.21 129.74,42.31 129.84,42.31 129.93,42.22 130.01,42.02 130.01,41.83 129.77,41.24 129.77,40.8 131.48,39.09 132.12,39.09 133.39,37.82 141.05,37.82 143.21,35.66 144.78,35.66 145.63,34.82 146.18,34.82 147.55,33.45 157.08,33.45 157.47,33.05 157.47,31.91 157.27,31.71 157.27,30.96 157.67,30.57 162.54,30.57 162.67,30.44 162.67,29.98 162.54,29.85 158.76,29.85 158.5,29.59 158.5,28.94 158.76,28.68 162.04,28.68 162.17,28.55 162.17,28.09 162.04,27.97 158.58,27.97 158.32,27.71 158.32,26.69 v1(158.04,26.42)
DDR4_DIMM_CH2_DQS_P4: length 45.5
  L16_SIG6 w0.079: v1(102.74,26.42) 103.04,26.71 103.04,27.19 102.9,27.33 100.21,27.33 99.98,27.57 99.98,28.14 100.21,28.38 102.89,28.38 102.99,28.48 102.99,28.86 102.89,28.96 100.63,28.96 100.39,29.2 100.39,29.77 100.63,30.01 101.85,30.01 102.05,30.21 102.05,32.01 103.12,33.08 104.37,33.08 105.59,34.29 109.23,34.29 109.94,35 113.31,35 114.34,36.03 ; 118.73,36.33 119.61,37.21 120.33,37.21 121.19,38.07 121.19,38.64 122.95,40.41 122.95,41.51 123.06,41.77 123.24,41.95 123.43,42.03 123.62,42.03 123.78,42.1 123.89,42.2 123.95,42.35 123.95,42.53 123.82,42.83 123.82,43.03 123.95,43.33 123.95,43.53 123.84,43.8 123.84,44.06 123.95,44.33 123.95,44.52 123.87,44.71 123.81,44.78 123.67,44.78 123.57,44.68 v1(123.57,44.43)
  L16_SIG6 w0.081: 114.34,36.03 117.42,36.03 117.71,36.33 118.73,36.33
DDR4_DIMM_CH2_DQS_P5: length 51.9
  L12_SIG4 w0.085: v1(123.57,41.43) 123.57,41.67 123.66,41.76 123.77,41.76 123.8,41.74 123.89,41.65 123.95,41.51 123.95,41.36 123.89,41.22 123.79,41.11 123.64,41.05 123.34,41.05 122.97,40.68 122.97,39.43 122.29,38.75 122.29,38.18 120.56,36.45 120.56,35.35 119.11,33.9 95.44,33.9 94.69,33.16 94.12,33.16 92.74,31.77 92.74,30.88 93,30.62 94.86,30.62 94.99,30.49 94.99,30.03 94.86,29.91 93,29.91 92.74,29.65 92.74,29.07 93,28.81 94.79,28.81 94.94,28.66 94.94,28.28 94.79,28.13 93.15,28.13 92.89,27.87 92.89,27.29 93.12,27.05 93.66,27.05 93.77,26.94 93.77,26.79 v1(93.39,26.42)
DDR4_DIMM_CH2_DQS_P6: length 59.3
  L12_SIG4 w0.085: v1(117.51,41.93) 117.51,42.21 117.61,42.31 117.82,42.31 118,42.49 118.06,42.65 118.18,42.77 118.3,42.81 118.48,42.81 118.58,42.77 118.69,42.66 118.75,42.52 118.75,42.34 118.64,42.08 118.64,41.81 118.77,41.51 118.77,40.29 118.51,40.03 118.09,40.03 117.1,39.05 93.87,39.05 92.85,38.02 92.85,37.32 92.3,36.76 91.99,36.76 88.31,33.08 88.31,32.36 88.76,31.91 88.76,27.95 88.45,27.65 87.04,27.65 86.06,26.67 86.06,25.2 86.99,24.28 86.99,23.71 86.75,23.47 83.92,23.47 83.58,23.81 83.58,24.24 85.47,26.13 85.47,26.72 85.03,27.16 84.59,27.16 84.35,26.93 84.35,26.73 v1(84.04,26.42)
DDR4_DIMM_CH2_DQS_P7: length 72.7
  L16_SIG6 w0.079: v1(74.69,26.42) 75.02,26.74 75.02,27.3 75.36,27.64 80.56,27.64 80.66,27.74 80.66,28.71 80.56,28.82 76.77,28.82 76.5,29.08 76.5,30.59 76.38,30.72 75.81,30.72 75.68,30.59 75.68,29.08 75.45,28.85 74.72,28.85 74.49,29.08 74.49,29.66 73.96,30.18 73.96,32 75.19,33.23 76.13,33.23 76.78,33.88 93.49,33.88 94.65,35.05 97.75,35.05 98.73,36.03 99.14,36.03 99.98,36.88 99.98,37.33 100.69,38.04 101.19,38.04 102.1,38.94 102.84,38.94 104.94,41.05 105.39,41.05 105.49,41.14 105.49,41.31 105.59,41.4 105.72,41.4 105.82,41.31 105.82,41.14 105.92,41.05 106.45,41.05 106.9,41.5 107.22,41.5 107.42,41.7 107.53,41.85 arc(107.71,41.99) 107.94,42.04 108.03,42.04 arc(108.15,42.07) 108.25,42.15 108.4,42.34 arc(108.58,42.49) 108.81,42.54 108.88,42.54 arc(109.11,42.49) 109.29,42.35 109.44,42.15 arc(109.54,42.07) 109.66,42.04 109.76,42.04 arc(109.88,42.07) 109.98,42.15 110.13,42.34 arc(110.31,42.49) 110.54,42.54 110.63,42.54 arc(110.86,42.49) 111.04,42.35 111.19,42.15 arc(111.29,42.07) 111.42,42.04 111.5,42.04 arc(111.63,42.07) 111.73,42.15 111.88,42.34 arc(112.06,42.49) 112.28,42.54 112.36,42.54 arc(112.58,42.49) 112.76,42.35 112.91,42.15 arc(113.01,42.07) 113.14,42.04 113.22,42.04 arc(113.35,42.07) 113.45,42.15 113.6,42.34 arc(113.78,42.49) 114.01,42.54 114.1,42.54 arc(114.23,42.57) 114.33,42.65 114.48,42.84 arc(114.66,42.99) 114.88,43.04 114.96,43.04 arc(115.19,42.99) 115.37,42.85 115.52,42.65 arc(115.62,42.57) 115.74,42.54 115.82,42.54 arc(115.94,42.57) 116.04,42.65 116.19,42.84 arc(116.37,42.99) 116.6,43.04 116.68,43.04 arc(116.8,43.07) 116.9,43.15 117.06,43.34 arc(117.24,43.49) 117.46,43.54 117.51,43.54 arc(117.64,43.57) 117.75,43.64 117.85,43.74 117.89,43.84 117.89,44.02 117.8,44.24 117.72,44.31 117.61,44.31 117.51,44.21 v1(117.51,43.93)
DDR4_DIMM_CH2_DQS_P8: length 43.2
  L12_SIG4 w0.085: v1(148.64,26.42) 149.01,26.78 149.01,27.45 149.29,27.73 150.59,27.73 151.2,28.35 151.2,30.12 151.11,30.21 150.67,30.21 150.57,30.11 150.57,28.63 150.33,28.39 149.69,28.39 149.45,28.63 149.45,29.67 149.37,29.76 148.91,29.76 148.82,29.67 148.82,28.42 148.56,28.16 148.04,28.16 147.77,28.43 147.77,29.7 147.49,29.98 146.95,29.98 146.32,30.61 146.32,31.78 146.48,31.94 146.48,32.58 146.16,32.9 144.4,32.9 143.56,33.74 136.25,33.74 132.66,37.33 132.66,38.64 130.98,40.32 130.98,41.03 130.88,41.25 130.88,41.51 130.76,41.8 130.76,42.08 130.88,42.36 130.88,42.5 130.82,42.66 130.72,42.76 130.58,42.82 130.39,42.82 130.14,42.92 129.99,43.07 129.89,43.29 129.89,43.55 130.01,43.83 130.01,44.02 129.93,44.22 129.83,44.31 129.74,44.31 129.64,44.21 v1(129.64,43.93)
DDR4_DIMM_CH2_ODT0: length 91
  L03_SIG1 w0.081: v4(114.64,32.42) 114.29,32.42 113.09,33.61 112.5,33.61 111.81,34.3 109.98,34.3 109.71,34.56 106.05,34.56 105.95,34.66 105.95,34.8 106.05,34.9 109.34,34.9 109.44,35 109.44,35.13 109.34,35.23 108.47,35.23 108.37,35.33 108.37,35.47 108.47,35.57 108.94,35.57 109.04,35.67 109.04,35.8 108.94,35.9 107.09,35.9 106.99,35.81 106.99,35.35 106.89,35.25 106.75,35.25 106.66,35.35 106.66,35.81 106.56,35.9 106.15,35.9 106.05,36.01 106.05,36.14 106.15,36.24 108.97,36.24 109.08,36.34 109.08,36.47 108.97,36.57 106.06,36.57 105.86,36.77 105.86,39.88 105.69,40.05 103.64,40.05 103.54,40.15 103.54,41.03 103.64,41.13 103.81,41.13 103.91,41.03 103.91,40.5 104.02,40.39 105.75,40.39 105.85,40.49 105.85,40.62 105.75,40.72 104.56,40.72 104.45,40.82 104.45,40.96 104.56,41.06 106,41.06 106.08,40.98 106.38,40.98 106.45,41.06 107.7,41.06 107.8,40.96 107.8,40.82 107.7,40.72 106.72,40.72 106.62,40.62 106.62,40.49 106.72,40.39 107.54,40.39 107.64,40.29 107.64,40.15 107.54,40.05 106.5,40.05 106.4,39.95 106.4,39.82 106.5,39.72 107.51,39.72 107.61,39.62 107.61,39.48 107.51,39.38 106.7,39.38 106.6,39.28 106.6,39.15 106.7,39.05 107.72,39.05 107.82,38.94 107.82,38.81 107.72,38.71 106.73,38.71 106.63,38.61 106.63,38.48 106.73,38.38 107.54,38.38 107.64,38.27 107.64,38.14 107.54,38.04 106.51,38.04 106.4,37.94 106.4,37.81 106.51,37.71 107.51,37.71 107.62,37.6 107.62,37.47 107.51,37.37 106.69,37.37 106.59,37.27 106.59,37.08 106.69,36.97 109.22,36.97 109.33,37.08 109.33,37.21 109.22,37.31 108.5,37.31 108.39,37.41 108.39,37.55 108.5,37.66 109.4,37.66 109.5,37.76 109.5,37.89 109.4,37.99 108.4,37.99 108.3,38.09 108.3,38.23 108.4,38.33 109.23,38.33 109.33,38.43 109.33,38.56 109.23,38.66 108.28,38.66 108.18,38.76 108.18,38.9 108.28,39 109.3,39 109.4,39.1 109.4,39.23 109.3,39.33 108.46,39.33 108.36,39.43 108.36,39.57 108.46,39.67 109.43,39.67 109.53,39.77 109.53,39.9 109.43,40 108.42,40 108.32,40.11 108.32,40.27 108.42,40.37 109.24,40.37 109.34,40.47 109.34,40.6 109.24,40.7 108.25,40.7 108.15,40.8 108.15,40.94 108.25,41.04 109.9,41.04 110.07,41.21 110.95,41.21 111.05,41.31 111.05,41.45 110.95,41.56 110.25,41.56 110.12,41.69 110.12,44.12 110.46,44.46 110.74,44.46 111.27,44.99 111.62,44.99 112.24,44.37 112.46,44.37 112.97,43.86 113.32,43.86 113.65,44.19 113.65,45.06 114.11,45.53 114.45,45.53 114.73,45.81 115.1,45.81 115.38,45.53 116.21,45.53 116.67,45.99 116.89,45.99 117.51,46.61 v4(117.51,46.93)
DDR4_DIMM_CH2_ODT1: length 91.9
  L03_SIG1 w0.081: v4(111.24,32.42) 110.73,31.9 110.03,31.9 109.93,32 109.93,32.26 110.03,32.36 110.53,32.36 110.63,32.46 110.63,32.69 110.53,32.79 109.28,32.79 109.13,32.64 109.13,31.29 108.11,30.28 105.17,30.28 104.68,29.79 104.68,27.52 104.58,27.42 104.44,27.42 104.35,27.52 104.35,29.2 104.25,29.3 104.11,29.3 104.01,29.2 104.01,26.89 103.91,26.79 103.77,26.79 103.68,26.89 103.68,29.21 103.58,29.31 103.44,29.31 103.34,29.21 103.34,26.75 103.24,26.65 103.1,26.65 103.01,26.75 103.01,29.21 102.91,29.3 102.77,29.3 102.67,29.21 102.67,27.22 102.57,27.13 102.43,27.13 102.33,27.22 102.33,29.21 102.24,29.31 102.1,29.31 102,29.21 102,28.39 101.9,28.3 101.67,28.3 101.57,28.39 101.57,30.85 101.48,30.95 101.34,30.95 101.24,30.85 101.24,28.41 101.14,28.31 101,28.31 100.9,28.41 100.9,30.83 100.81,30.93 100.67,30.93 100.57,30.83 100.57,28.45 100.47,28.35 100.33,28.35 100.23,28.45 100.23,31.26 100.14,31.36 100,31.36 99.9,31.26 99.9,28.47 99.8,28.37 99.66,28.37 99.56,28.47 99.56,30.92 99.46,31.02 99.33,31.02 99.23,30.92 99.23,28.47 99.13,28.36 98.98,28.36 98.88,28.47 98.88,32.53 99.77,33.42 99.77,42.07 100.15,42.45 100.41,42.45 100.89,42.93 101.18,42.93 101.71,43.45 102.13,43.45 102.57,43.89 103,43.89 103.55,44.44 103.83,44.44 104.3,44.9 104.57,44.9 105.09,45.43 105.57,45.43 106.16,46.02 106.64,46.02 107.04,46.42 107.33,46.42 107.85,46.94 108.24,46.94 108.72,47.42 109,47.42 109.48,47.89 109.84,47.89 110.32,47.41 110.68,47.41 111.15,47.88 111.59,47.88 112.03,47.43 112.47,47.43 112.87,47.83 113.51,47.83 113.79,47.55 114.24,47.55 114.49,47.8 115.29,47.8 115.54,47.55 116.07,47.55 116.32,47.8 117.38,47.8 v4(117.51,47.93)
DDR4_DIMM_CH2_PAR: length 89.1
  L03_SIG1 w0.081: v1(122.29,26.42) 122.29,26.74 121.9,27.14 121.9,27.5 121.57,27.83 118.77,27.83 117.63,26.7 117.63,26.14 115.77,24.28 110.12,24.28 109.97,24.43 109.97,26.56 109.7,26.83 109.27,26.83 109.08,26.64 109.08,26.21 108.59,25.72 108.59,25.05 108.5,24.95 108.36,24.95 108.26,25.05 108.26,26.43 108.16,26.52 108.02,26.52 107.92,26.43 107.92,25.27 107.83,25.17 107.69,25.17 107.59,25.27 107.59,26.14 107.49,26.24 107.35,26.24 107.25,26.14 107.25,25.27 107.16,25.17 107.02,25.17 106.92,25.27 106.92,25.97 106.82,26.07 106.68,26.07 106.58,25.97 106.58,25.21 106.48,25.11 106.35,25.11 106.25,25.21 106.25,26.44 106.15,26.54 106.01,26.54 105.91,26.44 105.91,25.16 105.81,25.06 105.68,25.06 105.58,25.16 105.58,25.94 105.48,26.04 105.34,26.04 105.24,25.94 105.24,24.95 104.68,24.39 97.48,24.39 97.22,24.65 97.22,26.63 97.61,27.02 97.61,30.4 97.22,30.79 97.22,31.15 97.64,31.57 97.64,32.95 98.02,33.34 98.02,43.14 98.31,43.43 98.62,43.43 99.13,43.94 99.57,43.94 100.03,44.4 100.34,44.4 100.86,44.91 101.25,44.91 101.73,45.39 102.05,45.39 102.54,45.89 102.9,45.89 103.4,46.39 103.8,46.39 104.41,46.99 104.74,46.99 105.18,47.43 105.59,47.43 106.08,47.93 106.44,47.93 106.93,48.43 107.29,48.43 107.79,48.92 108.15,48.92 108.68,49.45 109.04,49.45 109.46,49.86 109.97,49.86 110.36,49.46 110.81,49.46 111.24,49.9 111.64,49.9 112.06,49.48 112.58,49.48 112.98,49.88 113.4,49.88 113.78,49.49 114.14,49.49 114.66,48.97 115.15,48.97 115.57,48.55 116.13,48.55 116.38,48.8 117,48.8 117.24,48.55 117.72,48.55 118.22,48.05 118.64,48.05 119.01,48.43 119.46,48.43 120.11,47.79 v1(120.11,47.43)
DDR4_DIMM_CH2_RESET_N: length 93.1
  L14_SIG5 w0.081: v1(144.38,32.41) 144.38,31.47 145.1,30.75 145.1,29.85 145.19,29.76 146.77,29.76 146.86,29.67 146.86,29.41 146.77,29.32 145.7,29.32 145.02,28.64 144.82,28.64 144.56,28.9 144.23,28.9 143.21,27.88 142.61,27.88 141.43,26.7 141.31,26.7 141.17,26.84 141.17,26.96 141.84,27.63 141.84,27.77 141.73,27.88 140.74,27.88 140.45,28.16 138.94,28.16 138.85,28.25 138.85,28.41 138.94,28.5 139.82,28.5 139.91,28.59 139.91,28.75 139.82,28.83 138.55,28.83 138.46,28.92 138.46,29.08 138.55,29.17 139.79,29.17 139.88,29.26 139.88,29.42 139.79,29.5 134.01,29.5 133.32,30.19 130.38,30.19 129.53,31.04 127.94,31.04 127.77,31.21 127.77,31.76 127.63,31.9 127.07,31.9 126.86,32.1 126.86,32.6 127.09,32.83 127.09,33.06 126.88,33.27 123.6,33.27 122.8,34.08 122.8,34.55 122.7,34.65 122.56,34.65 122.46,34.55 122.46,33.7 122.36,33.6 122.22,33.6 122.13,33.7 122.13,34.55 122.03,34.65 121.89,34.65 121.79,34.55 121.79,33.71 121.69,33.61 121.55,33.61 121.45,33.71 121.45,34.54 121.36,34.64 121.22,34.64 121.12,34.54 121.12,33.75 121.02,33.65 120.88,33.65 120.78,33.75 120.78,34.94 120.88,35.04 122.7,35.04 122.8,35.14 122.8,36.34 122.71,36.43 122.46,36.43 122.37,36.34 122.37,36.06 122.23,35.92 121.63,35.92 121.53,35.83 121.53,35.65 121.43,35.55 121.3,35.55 121.2,35.65 121.2,35.9 121.1,36 120.96,36 120.86,35.9 120.86,35.48 120.76,35.38 120.62,35.38 120.53,35.48 120.53,35.76 120.45,35.84 118.41,35.84 118.32,35.93 118.32,36.12 118.41,36.21 119.63,36.21 119.71,36.3 119.71,36.46 119.63,36.55 118.38,36.55 118.29,36.63 118.29,36.8 118.38,36.89 120.39,36.89 120.49,36.8 120.49,36.36 120.59,36.26 120.73,36.26 120.83,36.36 120.83,36.8 120.92,36.89 121.06,36.89 121.16,36.8 121.16,36.63 121.26,36.53 121.4,36.53 121.5,36.63 121.5,36.8 121.59,36.89 122.68,36.89 122.77,36.98 122.77,37.14 122.68,37.23 118.86,37.23 118.77,37.32 118.77,37.62 118.86,37.71 119.23,37.71 119.33,37.81 119.33,37.94 119.23,38.04 118.87,38.04 118.77,38.14 118.77,38.28 118.87,38.38 119.23,38.38 119.33,38.48 119.33,38.62 119.23,38.71 118.74,38.71 118.64,38.81 118.64,38.95 118.74,39.05 119.23,39.05 119.33,39.15 119.33,39.29 119.23,39.38 118.86,39.38 118.76,39.48 118.76,39.62 118.86,39.72 119.23,39.72 119.33,39.82 119.33,39.96 119.23,40.05 118.83,40.05 118.73,40.15 118.73,40.29 118.83,40.39 119.23,40.39 119.33,40.49 119.33,40.63 119.23,40.73 118.67,40.73 118.58,40.82 118.58,40.96 118.67,41.06 119.23,41.06 119.33,41.16 119.33,41.4 119.21,41.52 118.97,41.52 118.77,41.72 118.77,42.01 119.06,42.3 119.06,42.51 118.82,42.74 118.82,43.07 119.05,43.3 119.05,43.56 118.87,43.74 118.87,44.09 119.11,44.33 119.11,44.47 118.58,45 118.14,45 117.69,45.46 117.34,45.46 116.23,46.57 116.23,47 115.95,47.28 115.95,47.75 v1(115.78,47.93)
  BOTTOM w0.149: v1(144.38,32.41) 144.4,32.4 R61.1
DDR4_DIMM_CH2_RZQ: length 3.8
  BOTTOM w0.149: v1(122.71,46.93) 123.16,47.38 123.16,48.75 R66.2
DDR4_DIMM_CH2_SA0:
  vias: v1(70.44,31.33)
DDR4_DIMM_CH2_SA1:
  vias: v1(69.59,32.41)
DDR4_DIMM_CH2_SA2: length 0.6
  BOTTOM w0.149: R60.2 v1(108.69,26.42)
DDR4_DIMM_CH2_TDQS_N9: length 74.7
  L12_SIG4 w0.085: v1(136.56,49.93) 136.56,49.63 136.65,49.54 136.78,49.54 136.84,49.61 136.94,49.85 136.94,50.01 136.82,50.3 136.82,50.56 136.92,50.78 137.08,50.94 137.32,51.04 137.46,51.04 arc(137.59,51.07) 137.7,51.14 arc(137.74,51.19) 137.77,51.24 137.8,51.31 arc(137.83,51.38) 137.88,51.44 arc(138.01,51.52) 138.16,51.55 138.36,51.55 arc(138.45,51.57) 138.53,51.62 138.57,51.65 138.63,51.74 138.63,51.75 arc(138.66,51.81) 138.7,51.85 138.76,51.91 arc(138.9,52.01) 139.07,52.05 139.26,52.05 arc(139.42,52.01) 139.55,51.93 139.59,51.89 arc(139.66,51.81) 139.7,51.72 arc(139.74,51.65) 139.79,51.59 139.79,51.58 arc(139.84,51.55) 139.9,51.54 140.08,51.54 arc(140.2,51.56) 140.3,51.63 arc(140.31,51.65) 140.33,51.67 140.34,51.69 arc(140.4,51.81) 140.48,51.91 arc(140.63,52.01) 140.81,52.05 140.95,52.05 arc(141.06,52.07) 141.16,52.14 141.16,52.14 arc(141.19,52.17) 141.22,52.21 141.26,52.28 arc(141.45,52.46) 141.7,52.53 141.85,52.53 arc(141.89,52.54) 141.92,52.56 142.05,52.69 142.11,52.77 arc(142.34,52.97) 142.64,53.04 157.87,53.04 158.32,52.6 158.32,52.12 158.82,51.62 159.17,51.62 160.02,50.76 160.02,50.28 160.68,49.62 161.35,49.62 167.58,43.39 169.62,43.39 170.25,42.76 170.25,42.05 170.77,41.53 172.63,41.53 174.61,39.55 176.46,39.55 177.17,38.84 177.17,35.94 177.72,35.38 180.38,35.38 180.6,35.61 180.6,36.84 180.92,37.16 181.42,37.16 181.74,36.84 181.74,35.42 181.84,35.32 182.31,35.32 182.41,35.42 182.41,36.69 182.74,37.02 183.23,37.02 183.55,36.69 183.55,35.43 183.65,35.32 184.04,35.32 184.14,35.43 184.14,35.92 184.37,36.16 184.95,36.16 185.18,35.92 185.18,34.34 185.75,33.77 186.16,33.77 186.41,33.52 186.41,33.41 186.51,33.31 186.63,33.31 186.72,33.21 186.72,33.08 186.63,32.98 186.51,32.98 186.41,32.88 186.41,32.22 186.75,31.88 187.1,31.88 187.19,31.97 187.19,32.31 187.09,32.42 v1(186.89,32.42)
DDR4_DIMM_CH2_TDQS_N10: length 65.8
  L14_SIG5 w0.079: v1(177.54,32.42) 177.85,32.11 177.85,31.99 177.74,31.88 177.33,31.88 177.15,32.05 177.15,32.93 177.25,33.03 177.43,33.03 177.52,33.13 177.52,33.26 177.43,33.36 177.25,33.36 177.15,33.46 177.15,34.94 176.58,35.52 175.92,35.52 175.32,36.12 170.59,36.12 168.07,38.64 168.07,39.46 166.16,41.37 164.58,41.37 160.61,45.35 155.71,45.35 155.61,45.45 155.61,45.83 155.71,45.93 159.91,45.93 160.17,46.19 160.17,46.72 159.91,46.98 154.36,46.98 154.22,47.12 154.22,48.7 153.87,49.05 146.08,49.05 144.07,47.04 142.57,47.04 arc(142.4,47.01) 142.25,46.9 141.99,46.63 arc(141.9,46.56) 141.79,46.54 141.71,46.54 arc(141.53,46.51) 141.38,46.4 141.12,46.13 arc(141.03,46.06) 140.93,46.04 140.84,46.04 arc(140.75,46.06) 140.68,46.11 140.42,46.39 arc(140.26,46.5) 140.06,46.54 139.98,46.54 arc(139.8,46.51) 139.65,46.4 139.39,46.13 arc(139.3,46.06) 139.2,46.04 139.11,46.04 arc(139.02,46.06) 138.95,46.11 138.69,46.39 arc(138.53,46.5) 138.33,46.54 138.24,46.54 arc(138.07,46.51) 137.92,46.4 137.66,46.13 arc(137.57,46.06) 137.46,46.04 137.37,46.04 137.23,46.01 137.07,45.95 136.93,45.81 136.83,45.56 136.83,45.28 136.94,45 136.94,44.86 136.85,44.63 136.76,44.54 136.66,44.54 136.56,44.64 v1(136.56,44.93)
DDR4_DIMM_CH2_TDQS_N11: length 56.6
  L12_SIG4 w0.085: v1(168.19,32.42) 168.5,32.11 168.5,31.99 168.34,31.82 167.94,31.82 167.73,32.04 167.73,33.04 167.82,33.14 167.97,33.14 168.06,33.24 168.06,33.38 167.97,33.47 167.82,33.47 167.73,33.57 167.73,33.67 167.46,33.93 166.67,33.93 166.42,34.19 166.42,34.9 165.68,35.64 164.9,35.64 164.06,34.8 160.33,34.8 160.23,34.9 160.23,35.7 160.35,35.81 162.8,35.81 163.18,35.43 163.82,35.43 164.28,35.89 164.28,36.82 164.05,37.05 158.83,37.05 157.98,37.9 157.98,38.83 158.25,39.09 158.25,41.66 154.6,45.31 153.95,45.31 153.23,46.03 147.32,46.03 147,45.72 147,45.22 146.79,45 146,45 144.81,43.81 144.81,43.54 144.56,43.3 144.12,43.3 143.36,44.05 142.57,44.05 arc(142.47,44.07) 142.38,44.13 142.35,44.16 142.34,44.18 arc(142.27,44.27) 142.19,44.36 142.17,44.38 arc(141.99,44.5) 141.77,44.54 arc(141.48,44.47) 141.24,44.27 141.19,44.19 141.05,44.06 arc(141.02,44.04) 140.99,44.03 140.89,44.03 arc(140.76,44.06) 140.65,44.13 140.62,44.16 140.53,44.29 140.41,44.42 arc(140.27,44.51) 140.11,44.54 140.04,44.54 arc(139.8,44.49) 139.59,44.36 139.57,44.33 139.49,44.22 139.48,44.19 139.45,44.15 arc(139.31,44.07) 139.16,44.03 139.16,44.03 arc(138.9,43.98) 138.7,43.82 138.56,43.65 138.55,43.63 arc(138.45,43.57) 138.34,43.55 138.21,43.55 arc(138.04,43.51) 137.89,43.41 137.83,43.35 arc(137.79,43.31) 137.76,43.25 137.76,43.24 137.7,43.15 137.66,43.12 arc(137.57,43.06) 137.47,43.04 137.36,43.04 137.24,43.01 137.16,42.98 137.05,42.91 136.92,42.77 136.85,42.63 136.81,42.57 136.72,42.53 136.65,42.53 136.56,42.61 v1(136.56,42.93)
DDR4_DIMM_CH2_TDQS_N12: length 54.6
  L14_SIG5 w0.079: v1(130.5,42.43) 130.5,42.12 130.6,42.02 130.78,42.02 131,41.8 131.24,41.23 132.13,40.34 132.45,40.34 133.74,39.05 143.79,39.05 145.04,40.31 145.38,40.31 145.81,39.87 145.81,39.54 145.51,39.23 145.51,38.06 145.27,37.83 143.39,37.83 143.19,37.62 143.19,37.23 143.39,37.02 145.47,37.02 147.93,34.57 153.95,34.57 154.08,34.7 154.08,36.21 154.34,36.48 154.99,36.48 155.25,36.21 155.25,34.7 155.38,34.57 155.84,34.57 155.96,34.7 155.96,37.78 156.23,38.04 156.97,38.04 157.24,37.78 157.24,37.19 157.37,37.06 158,37.06 158.24,36.81 158.24,36.1 157.94,35.8 157.35,35.8 157.24,35.69 157.24,34.7 157.36,34.57 158.18,34.57 158.51,34.24 158.51,33.46 158.61,33.36 158.84,33.36 158.93,33.26 158.93,33.12 158.84,33.02 158.61,33.02 158.51,32.92 158.51,32.04 158.68,31.87 159.02,31.87 159.15,32 159.15,32.15 v1(158.89,32.42)
DDR4_DIMM_CH2_TDQS_N13: length 44.3
  L16_SIG6 w0.079: v1(124.44,44.93) 124.7,44.59 124.93,44.36 125.04,44.09 125.04,43.77 124.93,43.51 124.93,43.35 125.04,43.08 125.04,42.79 124.92,42.49 124.92,42.37 125.05,42.06 125.05,41.8 124.93,41.51 124.93,39.91 123.84,38.82 123.31,38.82 122.45,37.96 122.45,37.6 120.68,35.83 119.91,35.83 118.91,34.83 114.71,34.83 113.58,33.7 110.17,33.7 109.69,33.23 106.03,33.23 105.6,32.79 105.6,32.4 105.91,32.08 105.91,31.24 106.63,30.52 106.63,27.97 106.39,27.73 105.82,27.73 105.58,27.97 105.58,29.68 105.48,29.78 105.1,29.78 105,29.68 105,27.97 104.76,27.73 104.15,27.73 103.92,27.97 103.92,32.09 v1(103.59,32.42)
DDR4_DIMM_CH2_TDQS_N14: length 51.9
  L12_SIG4 w0.085: v1(124.44,42.93) 124.44,42.64 124.54,42.54 124.67,42.54 124.81,42.48 124.92,42.37 125.04,42.08 125.04,41.81 124.91,41.49 124.91,41.41 124.29,39.9 124.29,38.27 123.82,37.81 123.41,37.81 123.17,37.57 123.17,36.54 122.47,35.85 122.47,35.18 122.08,34.79 121.7,34.79 119.39,32.48 109.51,32.48 109.14,32.85 105.77,32.85 101.62,28.7 101.29,28.7 100.84,29.14 100.84,29.48 102.33,30.97 102.33,31.11 102.05,31.39 101.91,31.39 99.95,29.43 99.61,29.43 99.11,29.94 99.11,30.27 100.15,31.31 100.15,31.83 100.64,32.32 100.64,32.66 100.45,32.85 96.63,32.85 95.33,31.54 94.84,31.54 94.54,31.84 94.54,32.12 v1(94.24,32.42)
