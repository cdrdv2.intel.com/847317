# Allegro board TS28247BC0_FM61_agilex_PCIe_DEVKIT_ADI_REVB1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FPGA_NSTATUS: length 11.3
  BOTTOM w0.149: v1(140.03,48.93) 139.6,48.5 139.6,48.21 139.34,47.95 139.01,47.95 138.44,47.38 138.05,47.38 137.6,46.93 137.3,46.93 136.84,46.46 136.42,46.46 135.89,45.93 135.57,45.93 135.25,45.61 135.25,40.97 R120.2
FPGA_OSC_CLK_1: length 107
  L07_SIG3 w0.089: v1(140.89,51.43) 140.47,51 140.47,49.78 140.17,49.48 139.81,49.48 139.36,49.03 139.1,49.03 138.51,48.44 138.08,48.44 137.5,47.86 137.22,47.86 136.68,48.39 136.38,48.39 135.95,47.96 135.47,47.96 135.03,48.39 134.63,48.39 134.2,47.96 133.71,47.96 133.26,48.42 132.9,48.42 132.49,48.01 132.06,48.01 131.66,48.42 131.27,48.42 130.74,48.95 130.28,48.95 129.78,49.46 129.52,49.46 129.01,49.96 128.56,49.96 128.07,50.45 127.67,50.45 127.13,50.98 126.88,50.98 126.4,50.5 125.99,50.5 125.53,50.96 125.2,50.96 124.72,51.44 124.21,51.44 123.76,50.98 123.43,50.98 123.04,51.36 122.64,51.36 122.03,51.97 121.62,51.97 121.24,52.35 120.81,52.35 120.43,51.97 119.87,51.97 119.41,52.43 119.06,52.43 118.52,52.96 118.09,52.96 117.58,52.45 117.3,52.45 116.76,53 116.34,53 115.98,53.37 115.49,53.37 115.06,52.94 114.68,52.94 114.21,53.41 113.83,53.41 113.36,53.87 112.91,53.87 112.48,53.44 112.02,53.44 111.66,53.8 111.16,53.8 110.81,53.45 110.35,53.45 109.94,53.04 109.61,53.04 108.97,52.4 108.72,52.4 108.26,51.95 107.86,51.95 107.32,51.41 106.97,51.41 106.51,50.96 106.1,50.96 105.65,51.41 105.29,51.41 104.83,50.96 104.38,50.96 103.87,51.46 103.56,51.46 103.05,50.96 102.65,50.96 102.22,51.39 101.73,51.39 101.35,51.01 100.85,51.01 100.46,51.39 99.96,51.39 99.58,51.01 99.19,51.01 98.7,51.5 98.15,51.5 97.81,51.85 97.4,51.85 96.9,52.34 96.48,52.34 95.99,52.83 95.54,52.83 95.21,52.51 94.72,52.51 94.43,52.8 93.97,52.8 93.47,52.3 93.11,52.3 92.74,51.94 92.15,51.94 91.74,52.35 91.28,52.35 90.82,52.81 90.42,52.81 90.07,52.46 88.36,52.46 87.83,51.93 86.57,51.93 85.7,51.06 83.79,51.06 83.27,50.54 83.27,49.91 82.75,49.4 76.46,49.4 73.55,46.48 72.42,46.48 70.29,44.35 70.29,43.46 68.9,42.07 68.27,42.07 67.89,41.69 67.89,41.42 67.58,41.11 67.31,41.11 67.06,40.86 67.06,40.59 66.81,40.34 65.39,40.34 60.93,35.88 59.62,35.88 v1(55.95,32.21)
FPGA_PCIE_PERSTN: length 138.1
  L07_SIG3 w0.089: v1(39.25,22.81) 39.25,23.08 46.75,30.58 49.46,30.58 50.71,31.83 51.39,31.83 55.46,35.89 55.46,37.11 57.23,38.89 57.23,41.81 57.92,42.5 61.09,42.5 65.16,46.56 65.16,52.28 65.77,52.89 66.06,52.89 66.07,52.9 77.07,52.9 77.08,52.89 77.5,52.89 78.07,52.32 82.42,52.32 83.17,53.07 83.17,53.38 83.6,53.81 86.3,53.81 86.8,54.31 88.16,54.31 88.65,54.8 89.14,54.8 89.71,55.37 90.04,55.37 90.51,55.85 91.03,55.85 91.32,55.55 91.9,55.55 92.15,55.8 92.82,55.8 93.2,55.43 93.48,55.43 93.85,55.8 94.29,55.8 94.77,55.33 95.24,55.33 95.55,55.02 96.21,55.02 96.54,55.36 96.8,55.36 97.26,55.82 97.94,55.82 98.26,55.5 98.46,55.5 99,54.96 99.46,54.96 99.86,54.55 100.51,54.55 100.82,54.87 101.43,54.87 101.74,54.55 102.23,54.55 102.55,54.87 102.88,54.87 103.41,55.4 103.82,55.4 104.35,54.87 104.68,54.87 105.26,55.45 105.65,55.45 106.13,55.93 106.41,55.93 106.8,56.33 107.45,56.33 107.73,56.05 108.24,56.05 108.51,56.33 109.2,56.33 109.48,56.05 109.93,56.05 110.21,56.33 110.64,56.33 111.54,57.23 119.34,57.23 119.59,56.97 120.21,56.97 120.86,56.33 121.53,56.33 122.31,55.55 123.07,55.55 123.32,55.8 123.81,55.8 124.22,55.39 124.52,55.39 124.98,54.94 125.53,54.94 125.92,54.55 128.21,54.55 128.56,54.21 128.91,54.21 129.29,53.83 129.7,53.83 130.21,53.32 131.6,53.32 132.01,52.91 132.39,52.91 132.85,52.45 133.26,52.45 133.69,52.89 134.12,52.89 134.55,52.45 135.03,52.45 135.52,52.94 135.85,52.94 136.41,52.38 136.71,52.38 137.27,52.94 137.69,52.94 138.16,53.41 138.49,53.41 139.16,54.08 v1(139.16,54.43)
  BOTTOM w0.149: R357.1 38.91,22.47 v1(39.25,22.81) ; v1(139.16,54.43) 139.16,54.43 138.07,54.43 137.62,53.99 137.23,53.99 136.83,54.39 136.36,54.39 135.95,53.98 135.47,53.98 135.05,54.4 134.64,54.4 134.21,53.96 133.77,53.96 133.34,54.4 132.88,54.4 132.41,53.93 131.77,53.93 R89.2
FPGA_PMBUS_EN: length 65.4
  L03_SIG1 w0.127: v4(31.63,26.02) 32.03,26.42 32.03,26.98 32.27,27.22 32.59,27.22 32.83,27.46 32.83,29.62 33.23,30.02 33.23,30.34 32.83,30.74 32.59,30.74 32.35,30.98 32.35,32 29.6,34.75 29.6,43.78 29.09,44.29 v1(29.09,47.45)
  L05_SIG2 w0.127: v1(29.09,47.45) 28.71,47.07 25.56,47.07 21.93,50.7 21.93,56.39 20.68,57.64 19.16,57.64 9.6,67.2 v1(2.67,67.2)
  BOTTOM w0.149: v1(2.67,67.2) 3.58,66.3 SW3.4 ; U20.5 v1(29.09,47.45)
FPGA_SDM_SCL: length 138.8
  L05_SIG2 w0.081: v1(27.5,48.59) 29.89,50.98 31.31,50.98 35.54,55.22 39.65,55.22 40.65,56.21 41.92,56.21 v1(42.43,55.7)
  L07_SIG3 w0.089: v1(42.43,55.7) 43.05,55.7 43.1,55.65 43.11,55.65 48.07,50.7 53.14,50.7 53.81,50.04 62.34,50.04 63.76,51.46 63.76,52.4 65.45,54.09 78.2,54.09 79.25,53.05 82.08,53.05 82.42,53.4 82.42,53.7 83.22,54.49 85.97,54.49 86.48,55 87.7,55 88.74,56.04 89.44,56.04 89.95,56.54 91.95,56.54 92.24,56.82 92.64,56.82 92.92,56.54 93.7,56.54 94,56.84 94.55,56.84 94.84,56.55 96.99,56.55 97.27,56.84 97.8,56.84 98.1,56.53 98.69,56.53 99.17,56.05 99.57,56.05 99.95,56.44 100.51,56.44 100.9,56.05 101.27,56.05 101.68,56.46 102.18,56.46 102.6,56.87 102.88,56.87 103.39,57.38 103.97,57.38 104.38,56.97 104.81,56.97 105.21,57.38 105.54,57.38 106.05,57.89 106.38,57.89 106.86,58.37 107.37,58.37 107.72,58.03 108.3,58.03 108.67,58.4 109.05,58.4 109.47,57.98 109.9,57.98 110.27,58.35 111.07,58.35 111.34,58.09 112.71,58.09 113.73,59.11 118.13,59.11 118.74,58.5 121.32,58.5 122.36,57.46 122.74,57.46 123.27,56.92 123.78,56.92 124.21,57.36 124.72,57.36 125.23,56.85 125.46,56.85 125.94,56.37 126.32,56.37 126.8,55.88 127.16,55.88 127.5,55.54 128.09,55.54 128.61,55.02 129.06,55.02 129.37,55.32 129.98,55.32 130.33,54.97 130.64,54.97 131.15,54.46 131.6,54.46 132.01,54.87 132.47,54.87 132.93,54.41 133.23,54.41 133.74,54.92 134.14,54.92 134.6,54.46 135.06,54.46 135.47,54.87 135.93,54.87 136.34,54.46 136.84,54.46 137.19,54.82 137.6,54.82 138.11,55.32 138.67,55.32 138.95,55.04 139.38,55.04 140.01,54.41 140.27,54.41 140.82,53.85 141.07,53.85 141.45,53.47 141.84,53.47 142.19,53.11 142.19,50.73 141.87,50.41 141.57,50.41 141.31,50.16 141.31,49.85 v1(140.89,49.43)
  BOTTOM w0.149: v1(27.5,48.59) U20.7
FPGA_SDM_SDA: length 135.6
  L05_SIG2 w0.081: v1(27.5,47.7) 30.29,50.49 31.69,50.49 35.39,54.18 39.89,54.18 v1(41.41,55.7)
  L07_SIG3 w0.089: v1(140.89,50.43) 141.33,50.87 141.33,52.62 141.04,52.91 140.74,52.91 140.24,53.42 139.86,53.42 139.58,53.7 139.58,54.54 139.31,54.82 138.87,54.82 138.51,54.46 138.11,54.46 137.6,53.95 137.24,53.95 136.71,53.42 136.33,53.42 135.9,53.85 135.47,53.85 135.11,53.5 134.55,53.5 134.2,53.85 133.74,53.85 133.34,53.46 132.87,53.46 132.38,53.95 130.23,53.95 129.89,54.3 129.61,54.3 129.18,54.73 128.47,54.73 128.23,54.97 126.78,54.97 126.27,55.48 125.86,55.48 125.43,55.91 125.1,55.91 124.67,56.34 124.29,56.34 124,56.05 123.36,56.05 123.07,56.34 122.54,56.34 121.48,57.39 119.98,57.39 119.34,58.04 114.01,58.04 113.66,57.69 111.24,57.69 110.98,57.43 110.42,57.43 110.01,57.03 109.4,57.03 109.02,57.41 108.57,57.41 108.18,57.02 107.67,57.02 107.35,57.33 106.86,57.33 106.46,56.92 106.1,56.92 105.59,56.42 105.24,56.42 104.83,56.01 104.22,56.01 103.87,56.37 103.44,56.37 102.98,55.91 102.6,55.91 102.12,55.43 101.68,55.43 101.31,55.8 100.85,55.8 100.52,55.48 99.85,55.48 99.53,55.8 99.12,55.8 98.62,56.3 98.01,56.3 97.76,56.05 97.38,56.05 97.12,56.3 96.46,56.3 96.21,56.05 93.96,56.05 93.71,56.31 92.96,56.31 92.71,56.05 92.06,56.05 91.79,56.32 90.36,56.32 89.09,55.05 88.42,55.05 88.01,54.64 86.6,54.64 86.12,54.16 83.47,54.16 82.77,53.46 82.77,53.14 82.32,52.69 78.84,52.69 77.84,53.69 65.6,53.69 64.13,52.22 64.13,51.33 62.51,49.71 48.59,49.71 42.98,55.32 42.96,55.32 42.96,55.32 41.79,55.32 v1(41.41,55.7)
  BOTTOM w0.149: U20.6 28.15,47.7 v1(27.5,47.7)
FPGA_TEMP0N: length 100.9
  L14_SIG5 w0.203: v1(70.94,79.64) 70.66,79.92 70.66,80.25 70.92,80.52 84.85,80.52 87.62,83.28 96.2,83.28 96.54,82.95 96.54,82.46 96.29,82.22 96.29,80.7 96.58,80.42 96.58,79.63 97.96,78.25 97.96,77.73 98.27,77.41 98.79,77.41 99.22,76.99 100.28,76.99 101.46,75.82 102.07,75.82 102.24,75.64 102.24,75.26 102.62,74.88 103.02,74.88 103.5,74.41 103.9,74.41 104.31,73.99 104.77,73.99 105.18,74.4 105.61,74.4 106.05,73.96 106.49,73.96 106.93,74.39 107.31,74.39 107.76,73.95 108.21,73.95 108.68,74.41 109.03,74.41 109.5,73.94 111.67,73.94 111.88,73.74 111.88,67.67 112.17,67.39 112.17,65.44 112.91,64.69 112.91,58.11 112.17,57.37 112.17,56.48 111.88,56.19 111.88,54.75 112.2,54.44 112.53,54.44 113.03,53.93 113.42,53.93 113.93,53.42 114.21,53.42 114.66,52.98 115.19,52.98 115.63,53.42 115.98,53.42 116.42,52.98 116.91,52.98 117.32,53.38 117.77,53.38 118.18,52.97 118.56,52.97 119.03,53.45 119.42,53.45 119.95,52.91 120.35,52.91 120.77,52.49 121.24,52.49 121.73,52.97 122.08,52.97 122.52,53.41 122.81,53.41 123.35,53.95 123.7,53.95 124.23,53.42 124.59,53.42 125.03,52.98 125.41,52.98 125.94,52.46 126.29,52.46 126.82,51.93 127.22,51.93 127.66,51.49 128.01,51.49 128.34,51.16 128.34,50.19 128.57,49.96 128.9,49.96 129.41,49.45 129.82,49.45 130.24,49.88 130.72,49.88 131.15,49.45 131.57,49.45 132.02,49.9 132.36,49.9 132.92,50.46 133.33,50.46 133.74,50.88 134.12,50.88 134.48,51.24 134.48,51.66 133.97,52.18 v1(133.97,52.43)
FPGA_TEMP0P: length 98.9
  L14_SIG5 w0.203: v1(70.05,79.64) 70.33,79.92 70.33,80.39 70.79,80.85 84.72,80.85 87.48,83.62 96.34,83.62 96.87,83.09 96.87,82.53 97.16,82.24 97.16,80.72 96.91,80.47 96.91,79.77 98.25,78.43 98.66,78.43 98.98,78.11 98.98,77.7 99.35,77.32 100.42,77.32 101.59,76.15 102.24,76.15 102.49,75.9 102.97,75.9 103.43,75.44 103.84,75.44 104.34,74.94 104.72,74.94 105.19,75.41 105.61,75.41 106.05,74.98 106.53,74.98 106.94,75.39 107.36,75.39 107.81,74.94 108.15,74.94 108.61,75.39 109.11,75.39 109.55,74.95 109.88,74.95 110.41,74.43 110.78,74.43 111.26,74.91 111.68,74.91 112.17,74.42 112.53,74.42 112.75,74.21 112.75,67.64 112.5,67.39 112.5,65.57 113.24,64.83 113.24,57.97 112.5,57.23 112.5,56.5 112.75,56.25 112.75,55.23 113.04,54.94 113.42,54.94 113.93,54.43 114.23,54.43 114.7,53.97 115.15,53.97 115.58,54.39 116,54.39 116.44,53.94 116.84,53.94 117.33,54.43 117.75,54.43 118.25,53.93 118.57,53.93 119.02,54.38 119.44,54.38 119.89,53.93 120.29,53.93 120.76,53.45 121.19,53.45 121.69,53.95 122.03,53.95 122.48,54.4 122.79,54.4 123.3,54.9 123.78,54.9 124.28,54.41 124.63,54.41 125.13,53.91 125.46,53.91 125.94,53.43 126.34,53.43 126.87,52.89 127.21,52.89 127.66,52.44 128.05,52.44 129.14,51.35 129.14,50.74 129.44,50.44 129.77,50.44 130.2,50.87 130.74,50.87 131.17,50.44 131.54,50.44 131.97,50.88 132.31,50.88 132.87,51.43 133.96,51.43 v1(133.97,51.43)
FPGA_TEMP1N: length 66.3
  L07_SIG3 w0.203: v1(126.17,68.93) 125.08,68.93 124.54,68.39 124.21,68.39 123.72,67.91 123.32,67.91 122.8,67.4 122.54,67.4 122.08,66.93 121.72,66.93 121.24,67.41 120.73,67.41 120.3,66.98 111.23,66.98 110.78,67.44 110.34,67.44 109.91,67.87 109.46,67.87 109.02,67.44 108.62,67.44 108.11,67.95 107.83,67.95 107.35,67.47 106.89,67.47 106.41,67.95 106.13,67.95 105.67,68.4 105.19,68.4 104.68,67.9 104.38,67.9 103.87,68.4 103.41,68.4 102.93,67.92 102.62,67.92 102.14,68.4 101.73,68.4 101.23,67.9 100.92,67.9 100.44,68.38 99.91,68.38 99.41,67.88 99.06,67.88 98.64,67.46 98.4,67.46 97.68,67.88 97.34,67.88 96.85,67.39 96.57,67.39 96.03,67.93 93.91,67.93 93.45,67.47 93.18,67.47 91.51,68.44 89.61,68.44 89.12,68.93 88.68,68.93 88.31,69.3 79.86,69.3 79.48,69.67 79.48,73.64 77.22,75.9 75.55,75.9 72.56,78.89 72.56,79.37 v1(72.84,79.64)
FPGA_TEMP1P: length 69
  L07_SIG3 w0.203: v1(126.17,69.93) 126.6,69.5 126.6,68.63 126.38,68.41 125.97,68.41 125.55,67.99 125.21,67.99 124.69,67.47 124.33,67.47 123.83,66.96 123.49,66.96 122.97,66.45 120.58,66.45 120.38,66.65 114.05,66.65 113.37,65.97 112.96,65.97 112.28,66.65 111.18,66.65 110.98,66.45 110.42,66.45 109.91,66.96 109.56,66.96 109.07,66.47 108.62,66.47 108.13,66.96 107.78,66.96 107.27,66.45 106.92,66.45 106.43,66.93 104.32,66.93 103.87,67.39 103.39,67.39 102.98,66.98 102.57,66.98 102.12,67.44 101.73,67.44 101.2,66.91 100.87,66.91 100.34,67.44 99.98,67.44 99.45,66.91 99.17,66.91 98.72,66.47 98.39,66.47 97.69,66.87 97.32,66.87 96.93,66.48 94.76,66.48 94.33,66.92 93.96,66.92 93.53,66.48 93.17,66.48 91.07,67.7 90.9,67.86 88.84,67.86 88.45,68.25 88.45,68.69 88.17,68.97 85.19,68.97 79.72,68.97 79.15,69.54 79.15,73.5 77.08,75.57 75.41,75.57 72.23,78.76 72.23,79.37 v1(71.95,79.64)
FPGA_TEMP2N: length 69.1
  L07_SIG3 w0.203: v1(74.75,79.64) 74.75,79.03 74.77,79 74.77,78.77 75.64,77.9 78.77,77.9 79.08,77.6 79.08,76.84 79.69,76.23 82.28,76.23 83.04,75.47 83.04,74.17 84,73.21 84,72.5 85.58,70.93 89,70.93 89.52,70.42 90.01,70.42 90.46,69.97 90.82,69.97 91.24,70.39 91.75,70.39 92.16,69.98 92.67,69.98 93.1,70.41 93.46,70.41 93.94,69.93 94.24,69.93 94.72,70.41 95.13,70.41 95.66,69.88 96,69.88 96.48,70.36 97.04,70.36 97.42,69.98 97.9,69.98 98.28,70.36 98.77,70.36 99.24,69.88 99.53,69.88 100.01,70.36 100.44,70.36 100.9,69.9 101.2,69.9 101.71,70.41 102.14,70.41 102.6,69.95 102.93,69.95 103.36,70.39 103.92,70.39 104.35,69.95 104.68,69.95 105.11,70.39 105.57,70.39 106.05,69.9 106.43,69.9 106.92,69.42 107.3,69.42 107.78,69.9 108.24,69.9 108.74,69.4 108.97,69.4 109.48,69.9 109.91,69.9 110.34,69.47 110.67,69.47 111.23,68.91 111.67,68.91 112.17,69.42 112.5,69.42 112.99,68.94 113.44,68.94 113.9,69.4 114.28,69.4 114.71,68.96 115.15,68.96 115.63,69.45 115.96,69.45 116.47,68.94 116.87,68.94 117.38,69.45 117.69,69.45 118.19,68.94 118.55,68.94 119.06,69.45 119.41,69.45 119.9,68.96 120.38,68.96 120.81,69.4 121.25,69.4 121.7,68.95 122.04,68.95 122.57,69.48 122.9,69.48 123.37,69.95 123.75,69.95 124.28,70.48 124.68,70.48 125.19,70.99 125.53,70.99 125.93,71.4 126.38,71.4 126.83,70.95 127.2,70.95 127.67,70.48 128.01,70.48 128.52,69.96 128.52,69.67 v1(128.77,69.43)
FPGA_TEMP2P: length 69.3
  L07_SIG3 w0.203: v1(73.86,79.64) 74.42,79.09 74.42,78.9 74.44,78.87 74.44,78.63 75.5,77.57 78.64,77.57 78.75,77.46 78.75,76.7 79.55,75.9 82.14,75.9 82.71,75.33 82.71,74.03 83.67,73.07 83.67,72.37 85.44,70.6 88.87,70.6 89.3,70.17 89.3,69.62 89.5,69.42 89.95,69.42 90.44,68.94 90.91,68.94 91.37,69.4 91.68,69.4 92.16,68.92 92.57,68.92 93.02,69.37 93.5,69.37 93.96,68.91 94.37,68.91 94.83,69.37 95.31,69.37 95.71,68.96 96.15,68.96 96.58,69.4 96.93,69.4 97.37,68.96 97.77,68.96 98.2,69.4 98.69,69.4 99.14,68.94 99.58,68.94 100.03,69.4 100.39,69.4 100.85,68.94 101.23,68.94 101.68,69.4 102.09,69.4 102.55,68.94 102.95,68.94 103.41,69.4 103.92,69.4 104.38,68.94 104.71,68.94 105.16,69.4 105.54,69.4 106.23,68.71 106.56,68.71 106.89,68.38 107.25,68.38 107.75,68.89 108.24,68.89 108.64,68.48 109.1,68.48 109.48,68.86 109.99,68.86 110.37,68.48 110.78,68.48 111.28,67.97 111.69,67.97 112.1,68.38 112.55,68.38 113.06,67.87 113.32,67.87 113.85,68.4 114.21,68.4 114.64,67.97 115.12,67.97 115.55,68.4 115.98,68.4 116.42,67.97 116.9,67.97 117.36,68.43 117.71,68.43 118.22,67.92 118.57,67.92 119.08,68.43 119.41,68.43 119.92,67.92 120.35,67.92 120.81,68.38 121.24,68.38 121.71,67.91 121.97,67.91 122.47,68.41 122.82,68.41 123.32,68.91 123.73,68.91 124.21,69.4 124.55,69.4 125.06,69.91 125.48,69.91 125.97,70.4 126.41,70.4 126.86,69.94 127.2,69.94 127.9,69.24 v1(127.9,68.93)
FPGA_TEMP3N: length 63.9
  L07_SIG3 w0.203: v1(106.25,65.43) 105.14,65.43 104.66,65.92 104.3,65.92 103.79,65.41 103.39,65.41 102.95,64.98 102.57,64.98 102.14,65.41 101.71,65.41 101.23,64.93 100.85,64.93 100.39,65.38 99.96,65.38 99.51,64.93 99.15,64.93 98.68,64.47 98.39,64.47 97.69,64.87 97.32,64.87 96.93,64.48 94.79,64.48 94.38,64.9 93.95,64.9 93.53,64.48 93.17,64.48 91.61,65.38 91.4,65.38 90.81,65.97 88.42,65.97 88.08,66.31 87.66,66.31 86.48,67.49 78.32,67.49 76.31,65.49 73.63,65.49 72.68,66.44 72.68,69 72.68,69 72.68,75.75 72.35,76.07 70.64,76.07 68.97,77.74 68.97,80.53 69.77,81.33 75.72,81.33 76.37,80.69 76.37,79.92 v1(76.65,79.64)
FPGA_TEMP3P: length 60.2
  L07_SIG3 w0.203: v1(75.76,79.64) 76.04,79.92 76.04,80.55 75.59,81 69.91,81 69.3,80.39 69.3,77.88 70.77,76.4 72.49,76.4 73.01,75.88 73.01,69.14 73.01,69.14 73.01,66.57 73.76,65.82 76.18,65.82 78.18,67.82 86.61,67.82 87.79,66.64 88.08,66.64 88.42,66.98 89.08,66.98 89.68,66.39 91.6,66.39 93.18,65.47 93.45,65.47 93.91,65.93 96.06,65.93 96.53,65.46 96.92,65.46 97.34,65.88 97.68,65.88 98.4,65.46 98.64,65.46 99.06,65.88 99.41,65.88 99.93,66.4 100.39,66.4 100.86,65.93 101.29,65.93 101.73,66.37 102.14,66.37 102.64,65.87 102.97,65.87 103.53,66.43 v1(104.52,66.43)
FPGA_VCC: length 234.6
  L03_SIG1 w0.203: v1(170.06,72.72) 169.74,73.05 168.41,73.05 167,71.63 158.6,71.63 158.3,71.94 155.25,71.94 154.71,71.4 145.35,71.4 144.81,71.94 142.42,71.94 141.94,71.45 141.54,71.45 141.08,71.91 140.7,71.91 140.24,71.45 139.83,71.45 139.35,71.94 138.97,71.94 138.46,71.43 138.12,71.43 137.59,71.96 137.24,71.96 136.74,71.45 136.38,71.45 135.9,70.97 135.59,70.97 135.06,70.44 134.82,70.44 134.54,70.32 134.12,69.9 133.79,69.9 133.28,69.4 132.9,69.4 132.47,68.96 132.09,68.96 131.53,68.4 131.17,68.4 130.69,67.92 130.28,67.92 129.75,67.39 129.45,67.39 128.99,66.93 128.56,66.93 128.05,66.42 127.71,66.42 127.23,65.94 126.85,65.94 126.37,65.46 125.99,65.46 125.48,64.95 125.13,64.95 124.62,64.44 124.26,64.44 123.73,63.91 123.37,63.91 122.89,63.43 122.51,63.43 122.03,62.94 121.65,62.94 121.14,63.45 119.36,63.45 119.06,63.15 114.33,63.15 112.58,61.39 112.17,61.39 111.71,60.93 v1(110.58,60.93)
  L03_SIG1 w0.254: v1(219.21,44.53) 218.22,43.54 214.56,43.54 213.57,44.53 195.56,44.53 193.66,42.62 193.66,36.83 192,35.18 180.67,35.18 v1(179.94,34.45)
  L07_SIG3 w0.203: v1(190.34,64.7) 189.31,64.7 188.91,65.1 181.13,65.1 174.4,71.83 170.36,71.83 170.06,72.14 v1(170.06,72.72)
  L07_SIG3 w0.254: v1(219.21,44.53) 219.78,45.1 227.53,45.1 228.99,46.56 v1(256.67,46.56)
  L12_SIG4 w0.254: v1(256.67,36.46) 258.71,38.5 258.71,44.53 v1(256.67,46.56)
  L16_SIG6 w0.254: v1(170.06,72.72) 170.38,73.05 173.17,73.05 179.43,66.78 179.43,59.31 178.34,58.22 178.34,48.45 178.85,47.94 178.85,45.06 178.34,44.55 178.34,36.05 v1(179.94,34.45)
  vias: v1(80.8,74.83) v1(82,74.83) v1(83.8,74.93) v1(93.86,84.43) v1(95.86,84.43) v1(97.59,84.43) v1(97.59,83.43) v1(97.59,38.43) v1(97.59,37.3) v1(99.32,87.52) v1(99.32,86.43) v1(99.32,83.43) v1(99.32,37.36) v1(101.06,87.52) v1(101.06,86.43) v1(101.06,83.43) v1(101.06,40.43) v1(101.06,39.43) v1(101.06,38.43) v1(101.06,37.43) v1(102.79,87.52) v1(102.79,86.43) v1(102.79,37.43) v1(102.87,83.43) v1(104.52,87.52) v1(104.52,86.43) v1(104.52,38.43) v1(104.52,37.43) v1(106.25,38.43) v1(106.25,37.43) v1(107.12,67.93) v1(107.12,66.93) v1(107.12,65.93) v1(107.12,64.93) v1(107.12,63.93) v1(107.12,62.93) v1(107.12,61.93) v1(107.12,60.93) v1(107.12,59.93) v1(107.12,58.93) v1(107.12,57.93) v1(107.12,56.93) v1(107.12,55.93) v1(107.12,54.93) v1(107.12,53.93) v1(107.99,87.43) v1(107.99,86.43) v1(107.99,38.43) v1(107.99,37.43) v1(108.85,66.93) v1(108.85,65.93) v1(108.85,64.93) v1(108.85,63.93) v1(108.85,62.93) v1(108.85,61.93) v1(108.85,60.93) v1(108.85,59.93) v1(108.85,58.93) v1(108.85,57.93) v1(108.85,56.93) v1(108.85,55.93) v1(108.85,54.93) v1(108.85,53.93) v1(109.72,86.43) v1(109.72,40.43) v1(109.72,39.43) v1(109.72,38.43) v1(109.72,37.43) v1(110.58,67.93) v1(110.58,66.93) v1(110.58,65.93) v1(110.58,64.93) v1(110.58,63.93) v1(110.58,62.93) v1(110.58,59.93) v1(110.58,58.93) v1(110.58,57.93) v1(110.58,56.93) v1(110.58,55.93) v1(111.45,38.43) v1(111.45,37.43) v1(112.32,69.93) v1(112.32,68.93) v1(112.32,67.93) v1(112.32,55.93) v1(112.32,54.93) v1(112.32,53.93) v1(114.05,69.93) v1(114.05,68.93) v1(114.05,67.93) v1(114.05,55.93) v1(114.05,54.93) v1(114.05,53.93) v1(115.78,69.93) v1(115.78,68.93) v1(115.78,67.93) v1(115.78,55.93) v1(115.78,54.93) v1(115.78,53.93) v1(117.51,69.93) v1(117.51,68.93) v1(117.51,67.93) v1(117.51,55.93) v1(117.51,54.93) v1(117.51,53.93) v1(119.24,69.93) v1(119.24,68.93) v1(119.24,67.93) v1(119.24,55.93) v1(119.24,54.93) v1(119.24,53.93) v1(119.98,86.43) v1(120.98,67.93) v1(120.98,66.93) v1(120.98,65.93) v1(120.98,64.93) v1(120.98,63.93) v1(120.98,62.93) v1(120.98,61.93) v1(120.98,60.93) v1(120.98,59.93) v1(120.98,58.93) v1(120.98,57.93) v1(120.98,56.93) v1(120.98,55.93) v1(122.71,67.93) v1(122.71,66.93) v1(122.71,65.93) v1(122.71,64.93) v1(122.71,63.93) v1(122.71,62.93) v1(122.71,61.93) v1(122.71,60.93) v1(122.71,59.93) v1(122.71,58.93) v1(122.71,57.93) v1(122.71,56.93) v1(122.71,55.93) v1(124.44,69.93) v1(124.44,68.93) v1(124.44,67.93) v1(124.44,66.93) v1(124.44,65.93) v1(124.44,64.93) v1(124.44,63.93) v1(124.44,62.93) v1(124.44,61.93) v1(124.44,60.93) v1(124.44,59.93) v1(124.44,58.93) v1(124.44,57.93) v1(124.44,56.93) v1(124.44,55.93) v1(127.04,84.43) v1(127.04,83.43) v1(135.7,87.43) v1(135.7,86.43) v1(137.43,87.43) v1(137.43,86.43) v1(149.62,70.93) v1(156.62,41.43) v1(156.62,40.43) v1(159.85,56.75) v1(159.9,70.82) v1(159.98,70.13) v1(160,56.21) v1(160.64,70.77) v1(160.64,70.08) v1(160.56,56.72) v1(164.5,57.43) v1(164.5,56.64) v1(165.44,78.36) v1(166.43,57.56) v1(166.89,56.92) v1(171.89,38.2) v1(171.97,82.4) v1(172.09,83.77) v1(172.07,40.31) v1(172.83,44.45) v1(172.85,38.18) v1(174.5,82.43) v1(174.58,44.53) v2(159,84.43) v2(159,82.43) v2(159,80.43) v2(159,78.43) v2(159,74.43) v2(159,72.43) v2(159,70.43) v2(159,68.43) v2(159,66.43) v2(159,64.43) v2(159,62.43) v2(159,60.43) v2(159,58.43) v2(159,56.43) v2(159,54.43) v2(159,52.43) v2(159,50.43) v2(159,48.43) v2(159.95,78.21) v2(159.98,74.5) v2(159.98,64.67) v2(160.08,59.57) v2(160.37,67.39) v2(160.37,63.83) v2(160.78,80.43) v2(160.78,78.43) v2(160.78,76.43) v2(160.78,74.43) v2(160.78,72.43) v2(160.78,66.43) v2(160.78,64.43) v2(160.78,62.43) v2(160.78,60.43) v2(160.78,58.43) v2(160.78,52.43) v2(160.78,50.43) v2(160.78,48.43) v2(160.83,46.43) v2(162.01,72.82) v2(164.46,80.43) v2(164.65,40.11) v2(165.34,73.76) v2(165.44,70.77) v2(169.29,82.43) v2(169.29,80.43) v2(169.29,78.43) v2(169.29,76.43) v2(169.29,74.43) v2(169.29,72.43) v2(169.29,50.43) v2(169.29,48.43) v2(169.29,46.43) v2(169.29,44.43) v2(169.28,42.43) v2(170.16,79.81) v2(170.92,63.25) v2(171.07,82.43) v2(171.07,80.43) v2(171.07,78.43) v2(171.07,76.43) v2(171.07,74.43) v2(171.07,72.43) v2(171.07,50.43) v2(171.07,48.43) v2(171.07,46.43) v2(171.07,44.43) v2(171.05,42.43) v2(171.79,62.13) v2(171.99,69.55) v2(172.07,55.25) v2(172.35,68.48) v2(172.45,63.17) v2(172.5,54.36) v2(172.63,61.24) v2(172.72,82.43) v2(172.72,78.43) v2(172.72,76.43) v2(172.72,74.43) v2(172.74,56.22) v2(172.72,50.43) v2(172.72,48.43) v2(174.07,76.53) v2(174.5,78.43) v2(174.5,74.43) v2(174.53,68.56) v2(174.48,59.77) v2(174.52,56.22) v2(174.5,54.43) v2(174.5,50.43) v2(174.5,48.43) v2(174.5,46.43) v3(167.44,46.21) v5(169.24,40.43) v5(169.24,38.43) v5(169.29,68.43) v5(169.29,66.43) v5(169.29,64.43) v5(169.29,62.43) v5(169.29,60.43) v5(169.29,58.43) v5(169.29,56.43) v5(169.29,54.43) v5(169.29,52.43) v5(170.19,55.43) v5(170.92,62.39) v5(171,84.48) v5(171.02,40.43) v5(171.02,38.43) v5(171.07,68.43) v5(171.07,66.43) v5(171.07,64.43) v5(171.07,60.43) v5(171.07,58.43) v5(171.07,56.43) v5(171.07,54.43) v5(171.07,52.43) v5(172.19,65.05) v5(172.19,59.72) v5(172.72,46.43) v5(173.44,69.42) v5(173.36,55.1)
FPGA_VCC_EN: length 117
  TOP w0.127: R5943.2 198.15,56.29 198.34,56.48 U47.20 ; v1(215.93,27) 215.54,27 215.28,27.26 TP16.1
  L07_SIG3 w0.127: v1(198.14,55.81) 195.43,53.1 195.43,48.53 197.39,46.58 197.39,42.27 200.49,39.17 211.92,39.17 212.27,38.81 212.27,35.49 215.93,31.83 v1(215.93,27)
  L12_SIG4 w0.127: v1(215.93,27) 216.34,27 225.66,36.32 233.9,36.32 245.8,24.42 245.8,20.09 246.54,19.36 250.83,19.36 251.62,20.14 251.62,22.23 251.35,22.49 251.35,24.63 252.14,25.42 252.14,31.05 251.77,31.42 250.91,31.42 248.94,33.39 248.94,33.83 248.55,34.23 v1(248.55,34.56)
  BOTTOM w0.127: R877.2 216.95,25.99 v1(215.93,27)
FPGA_VCC_PG: length 120.4
  TOP w0.127: v1(195.18,58.63) 195.46,58.63 196.28,59.44 U47.13
  TOP w0.254: TP20.1 v1(218.96,27.26)
  L07_SIG3 w0.127: v1(258.95,25.86) 258.95,25.75 258.55,25.35 258.55,24.79 259.6,23.75 260.03,23.75 260.28,23.5 260.28,22.94 260.05,22.71 259.52,22.71 258.38,23.85 257.08,23.85 256.27,24.66 251.6,24.66 251.35,24.42 251.35,24.4 251.34,24.39 251.34,22.31 250.71,21.67 250.71,20.14 250.43,19.87 246.92,19.87 246.27,20.52 246.27,23 244.08,25.18 242.09,25.18 240.98,26.29 236.86,26.29 236.56,25.99 236.56,19.87 234.32,17.63 223.91,17.63 220.5,21.03 220.5,26.7 219.95,27.26 v1(218.96,27.26) 217.74,28.48 217.74,30.89 213.14,35.49 213.14,40.16 212.5,40.8 201.4,40.8 199.73,42.47 199.73,47.25 198.86,48.11 198.86,54.18 198.65,54.4 198.65,57.6 197.77,58.47 195.33,58.47 v1(195.18,58.63)
FT232R_RXD: length 3.9
  BOTTOM w0.149: U10.4 16.79,70.42 17.64,69.57 U11.2
FT232R_TXD: length 5.9
  BOTTOM w0.149: U9.2 20.96,67.01 19.96,68.01 U11.30
FT232R_VCCIO: length 4
  TOP w0.381: v1(13.72,101.3) 14.14,101.72 D2.A ; D3.A 17.57,101.46 v1(17.41,101.3)
  BOTTOM w0.381: v1(15.5,70.88) 15.49,70.9 U10.5
  vias: v1(16.71,68.91) v1(18.04,66.75) v1(18.49,74.63) v1(22.42,66.37) v1(25.47,72.21) v1(26.55,73.23) v1(27.31,73.23) v1(28.2,73.23)
FX2_D_N: length 15
  TOP w0.102: U28.9 15.11,22.37 14.97,22.23 14.97,21.81 v4(15.23,21.56) ; J13.2 5.13,26.41 5.26,26.55 5.87,26.55 5.98,26.44 U27.2 6.64,26.19 6.86,26.19 v4(7.12,26.46)
  L03_SIG1 w0.079: v4(7.12,26.46) 7.19,26.46 7.26,26.38 7.26,26.37 7.34,26.29 8.3,26.29 8.73,25.86 9,25.86 9.53,25.33 10.26,25.33 10.28,25.31 10.31,25.31 12.63,22.99 14.28,22.99 14.99,22.27 14.99,21.79 v4(15.23,21.56)
FX2_D_P: length 14.8
  TOP w0.102: v4(14.49,21.56) 14.74,21.81 14.74,22.25 14.61,22.38 U28.8 ; J13.3 5.19,25.76 5.32,25.62 5.87,25.62 5.98,25.74 U27.1 6.63,25.97 6.87,25.97 v4(7.12,25.72)
  L03_SIG1 w0.079: v4(14.49,21.56) 14.76,21.83 14.76,22.18 14.18,22.76 12.53,22.76 10.19,25.1 9.68,25.1 9.68,25.1 9.44,25.1 8.91,25.63 8.64,25.63 8.2,26.06 7.36,26.06 7.12,25.83 v4(7.12,25.72)
FX2_FLAGA: length 20.9
  TOP w0.149: U28.29 v1(17.61,32.03)
  L03_SIG1 w0.081: v4(30.03,22.82) 30.43,23.22 30.43,23.78 30.19,24.02 29.87,24.02 29.63,24.26 29.63,24.58 29.39,24.82 29.07,24.82 28.83,25.06 28.83,25.38 28.59,25.62 28.27,25.62 28.03,25.86 28.03,28.58 25.31,31.3 18.34,31.3 v1(17.61,32.03)
FX2_FLAGB: length 15
  TOP w0.149: U28.30 v1(17.11,31.27)
  L05_SIG2 w0.081: v1(17.11,31.27) 18.08,31.27 21.63,27.72 24.4,27.72 24.9,27.22 27.03,27.22 28.03,26.22 28.03,25.82 28.43,25.42 v1(28.43,25.22)
FX2_FLAGC: length 27.4
  TOP w0.149: U28.31 v1(16.61,32.03)
  L03_SIG1 w0.081: v1(16.61,32.03) 17.08,32.5 18.03,32.5 18.83,31.7 26.04,31.7 28.84,28.91 28.84,25.86 29.07,25.62 29.39,25.62 29.63,25.38 29.63,25.06 29.87,24.82 30.19,24.82 30.43,24.58 30.43,24.26 30.67,24.02 30.99,24.02 31.23,23.78 31.23,22.66 30.99,22.42 30.67,22.42 30.43,22.18 30.43,21.86 30.19,21.62 29.87,21.62 29.63,21.38 29.63,21.06 29.39,20.82 28.83,20.82 v1(28.43,20.42)
FX2_PA0: length 21.7
  TOP w0.149: U28.33 v1(15.61,32.03)
  L05_SIG2 w0.081: v1(15.61,32.03) 16.1,32.52 21.96,32.52 23.36,31.12 26.63,31.12 28.83,28.92 28.83,25.87 29.07,25.62 29.43,25.62 29.63,25.42 29.63,24.82 v1(29.23,24.42)
FX2_PA1: length 15.5
  TOP w0.149: U28.34 v1(15.11,31.27)
  L05_SIG2 w0.081: v1(27.63,26.02) 27.2,26.45 25.5,26.45 25.47,26.48 24.07,26.48 23.3,27.26 21.6,27.26 19.99,28.86 18.69,28.86 17.43,30.12 16.25,30.12 v1(15.11,31.27)
FX2_PA2: length 17.9
  TOP w0.149: U28.35 v1(14.61,32.03)
  L05_SIG2 w0.081: v1(14.61,32.03) 14.61,31.15 16.18,29.57 16.98,29.57 18.73,27.82 19.43,27.82 19.93,27.32 20.94,27.32 22.28,25.98 24.28,25.98 24.53,25.73 26.22,25.73 26.73,25.22 v1(27.63,25.22)
FX2_PA3: length 24.4
  TOP w0.149: U28.36 v1(14.11,31.27)
  L05_SIG2 w0.081: v1(29.23,25.22) 28.84,24.83 28.84,24.23 28.63,24.02 24.73,24.02 23.43,25.32 19.93,25.32 19.43,25.82 18.63,25.82 17.23,27.23 15.53,27.23 12.2,30.56 12.2,31.45 12.4,31.65 13.73,31.65 v1(14.11,31.27)
FX2_PA4: length 20.7
  TOP w0.149: U28.37 v1(13.61,32.03)
  L05_SIG2 w0.081: v1(13.61,32.03) 14.1,32.52 14.81,32.52 15.13,32.2 15.13,31.92 15.41,31.64 21.49,31.64 22.51,30.62 26.03,30.62 28.03,28.62 28.03,26.62 28.43,26.22 v1(28.43,26.02)
FX2_PA5: length 26.8
  TOP w0.149: v1(12.61,32.03) 13.11,31.53 U28.38
  L05_SIG2 w0.081: v1(30.03,25.22) 30.03,25.43 29.63,25.83 29.63,28.56 26.57,31.62 24.18,31.62 20.8,35.01 14.62,35.01 12.61,33 v1(12.61,32.03)
FX2_PA6: length 20.8
  TOP w0.149: U28.39 v1(12.61,31.27)
  L05_SIG2 w0.081: v1(26.83,26.02) 27.23,25.62 27.8,25.62 28.03,25.4 28.03,25.02 27.85,24.84 25.63,24.84 25.05,25.42 24.33,25.42 24.13,25.62 21.33,25.62 20.63,26.32 19.83,26.32 19.33,26.82 18.63,26.82 17.13,28.32 16.83,28.32 15.32,29.84 14.04,29.84 v1(12.61,31.27)
FX2_PA7: length 31.2
  TOP w0.149: U28.40 12.11,31.16 v1(11.31,31.96)
  L05_SIG2 w0.081: v1(30.03,23.62) 30.03,23.82 30.43,24.22 30.43,29.22 27.32,32.32 24.39,32.32 21.3,35.42 13.96,35.42 11.31,32.77 v1(11.31,31.96)
FX2_PB0: length 11.8
  TOP w0.149: v1(20.2,24.82) U28.18
  L03_SIG1 w0.081: v4(29.23,23.62) 28.83,23.22 26.67,23.22 26.23,23.67 24.51,23.67 23.67,24.5 20.52,24.5 v1(20.2,24.82)
FX2_PB1: length 9.9
  TOP w0.149: U28.19 v1(19.06,25.32)
  L03_SIG1 w0.081: v4(26.83,22.02) 26.42,22.43 25.14,22.43 23.47,24.1 20.27,24.1 v1(19.06,25.32)
FX2_PB2: length 9.5
  TOP w0.149: U28.20 v1(20.2,25.82)
  L03_SIG1 w0.081: v1(20.2,25.82) 21.12,24.9 23.79,24.9 24.67,24.02 26.43,24.02 v4(26.83,23.62)
FX2_PB3: length 9.5
  TOP w0.149: U28.21 v1(19.06,26.32)
  L03_SIG1 w0.081: v4(26.83,24.42) 26.72,24.42 26.3,24.84 25.07,24.84 24.53,25.38 23.87,25.38 23.71,25.22 21.87,25.22 20.77,26.32 v1(19.06,26.32)
FX2_PB4: length 24
  TOP w0.149: U28.22 v1(20.2,26.82)
  L03_SIG1 w0.081: v4(27.63,18.82) 27.23,19.22 26.59,19.22 25.55,20.26 25.55,20.66 22.91,23.3 18.83,23.3 17.79,24.35 17.79,28.15 18.42,28.78 19.31,28.78 19.56,28.54 19.56,27.88 19.44,27.76 18.93,27.76 18.68,27.51 18.68,27.02 18.88,26.82 v1(20.2,26.82)
FX2_PB5: length 9.6
  TOP w0.149: U28.23 v1(19.06,27.32)
  L03_SIG1 w0.081: v4(26.83,25.22) 26.45,25.61 24.83,25.61 24.65,25.78 23.71,25.78 23.53,25.61 22.61,25.61 20.89,27.32 v1(19.06,27.32)
FX2_PB6: length 17.8
  TOP w0.149: U28.24 v1(20.2,27.82)
  L03_SIG1 w0.081: v4(27.63,22.02) 27.67,22.02 28.07,22.43 29.47,22.43 29.63,22.59 29.63,23.78 29.39,24.02 28.27,24.02 28.03,24.26 28.03,24.58 27.79,24.82 27.47,24.82 27.23,25.06 27.23,26.18 26.99,26.42 25.79,26.42 25.63,26.58 23.75,26.58 23.15,25.99 22.79,25.99 20.95,27.82 v1(20.2,27.82)
FX2_PB7: length 16.4
  TOP w0.149: U28.25 v1(19.06,28.32)
  L03_SIG1 w0.081: v4(27.63,20.42) 27.23,20.82 26.03,20.82 23.15,23.7 19.05,23.7 18.17,24.59 18.17,27.89 18.6,28.32 v1(19.06,28.32)
FX2_PD0: length 39
  TOP w0.149: U28.45 v1(9.66,28.82)
  L05_SIG2 w0.081: v1(9.66,28.82) 10.29,29.46 10.29,32.34 14.07,36.11 29.47,36.11 33.31,39.96 34.55,39.96 35.44,40.85 35.44,44.15 v1(34.93,44.66)
  BOTTOM w0.149: v1(34.93,44.66) 34.3,44.66 33.75,44.11 U29.16
FX2_PD1: length 37.4
  TOP w0.149: U28.46 v1(8.64,28.32)
  L05_SIG2 w0.081: v1(34.93,41.99) 34.27,41.99 32.91,40.63 32.91,40.1 31.31,38.5 29.87,38.5 28.67,37.3 26.35,37.3 26.11,37.54 22.99,37.54 22.67,37.22 18.83,37.22 18.51,37.54 14.73,37.54 9.15,31.96 9.15,28.83 v1(8.64,28.32)
  BOTTOM w0.149: U29.3 34.62,42.3 v1(34.93,41.99)
FX2_PD2: length 34.9
  TOP w0.149: U28.47 v1(9.66,27.82)
  L05_SIG2 w0.081: v1(31.38,41.23) 29.55,39.4 29.55,39.06 28.99,38.5 19.39,38.5 19.06,38.18 13.98,38.18 8.11,32.31 8.11,28.3 8.59,27.82 v1(9.66,27.82)
  BOTTOM w0.149: v1(31.38,41.23) 32.05,41.9 U29.9
FX2_PD3: length 38.6
  TOP w0.149: U28.48 v1(8.64,27.32)
  L05_SIG2 w0.081: v1(31.38,43.89) 30.71,43.22 30.11,43.22 29.23,42.34 29.23,40.58 28.51,39.86 14.88,39.86 7.25,32.24 7.25,28.72 v1(8.64,27.32)
  BOTTOM w0.149: U29.12 32.05,43.1 31.38,43.77 v1(31.38,43.89)
FX2_PD4: length 20.1
  TOP w0.149: U28.49 v1(9.66,26.82)
  L05_SIG2 w0.081: v1(9.66,26.82) 10.36,26.12 14.09,26.12 15.46,24.76 17.53,24.76 18.36,23.92 20.3,23.92 20.89,24.51 23.24,24.51 24.53,23.22 26.43,23.22 v1(26.83,22.82)
FX2_PD5: length 23.1
  TOP w0.149: U28.50 8.79,26.32 v1(8.64,26.47)
  L05_SIG2 w0.081: v1(27.63,23.62) 24.63,23.62 23.36,24.89 20.81,24.89 20.34,24.42 19.48,24.42 19.08,24.82 18.53,24.82 17.44,25.92 15.64,25.92 14.3,27.26 9.4,27.26 8.64,26.5 v1(8.64,26.47)
FX2_PD6: length 20.8
  TOP w0.149: U28.51 v1(9.66,25.82)
  L05_SIG2 w0.081: v1(27.63,22.82) 27.24,22.43 24.82,22.43 23.15,24.11 20.94,24.11 20.35,23.52 15.55,23.52 13.25,25.82 v1(9.66,25.82)
FX2_PD7: length 26.7
  TOP w0.149: U28.52 8.79,25.32 v1(8.62,25.15)
  L05_SIG2 w0.081: v1(30.03,24.42) 28.83,23.22 28.23,23.22 28.03,23.02 28.03,22.62 27.53,22.12 26.93,22.12 26.35,21.54 25.21,21.54 23,23.75 21.06,23.75 20.54,23.22 12.13,23.22 10.2,25.15 v1(8.62,25.15)
FX2_RESETN: length 19.7
  TOP w0.149: U28.42 11.11,30.74 v1(10.7,31.14)
  L03_SIG1 w0.081: v4(26.83,26.82) 26.43,27.22 24.99,27.22 24.75,27.46 23.96,27.46 v1(22.94,26.45) 19.69,29.7 18.83,29.7 18.67,29.54 13.47,29.54 11.87,31.14 v1(10.7,31.14)
FX2_SCL: length 19.4
  TOP w0.149: v1(17.15,20.4) 17.15,20.78 18.8,22.43 18.8,23.19 18.67,23.32 U28.15
  L05_SIG2 w0.081: v1(17.15,20.4) 17.58,20.82 19.08,20.82 21.42,23.17 22.61,23.17 24.96,20.82 27.79,20.82 28.82,21.86 28.82,22.42 v1(29.23,22.82)
FX2_SDA: length 5.5
  TOP w0.149: R331.1 R326.1 19.18,21.54 19.44,21.8 19.44,23.45 19.06,23.82 U28.16
FX2_SLRDN: length 20.8
  TOP w0.149: v1(10.55,22.67) U28.1
  L05_SIG2 w0.081: v1(27.63,19.62) 27.23,20.02 24.33,20.02 23.53,20.83 19.97,20.83 19.13,19.99 11.76,19.99 10.1,21.65 10.1,22.23 v1(10.55,22.67)
FX2_SLWRN: length 19.5
  TOP w0.149: U28.2 11.61,22.3 11.23,21.92 v1(10.55,21.92)
  L05_SIG2 w0.081: v1(26.83,21.22) 26.77,21.16 25.13,21.16 22.79,23.5 21.27,23.5 20.71,22.94 15.34,22.94 14.83,22.42 11.05,22.42 v1(10.55,21.92)
FX2_WAKEUP: length 5.7
  TOP w0.149: U28.44 v1(8.64,29.32)
  BOTTOM w0.149: 7.63,29.32 v1(8.64,29.32) 9.96,29.32 C345.1 R344.2
HPS_COLD_RESETN: length 388
  L03_SIG1 w0.081: v1(42.04,35.89) 40.8,35.89 39.15,37.54 39.15,38.03 36.71,40.46 36.71,46.79 31.36,52.14 31.36,53.66 30.84,54.18 30.84,56.24 30.13,56.95 28.43,56.95 v1(27.95,56.47)
  L16_SIG6 w0.081: v1(266.07,60.98) 266.07,62.82 270.77,67.52 270.77,89.87 261.3,99.34 256.47,99.34 254.52,97.39 247.56,97.39 245.58,99.36 245.38,99.36 242.58,102.16 240.85,102.16 239.53,103.48 219.52,103.48 216.64,100.6 211.21,100.6 209.82,99.22 205.86,99.22 204.52,100.55 202,100.55 201.33,99.88 195.18,99.88 193.17,97.87 189.49,97.87 188.48,98.88 188.48,99.39 188.14,99.72 188.14,100.69 185.58,103.25 185.58,105.21 184.16,106.63 145.46,106.63 145.23,106.87 134.46,106.87 133.01,105.42 133.01,104.6 132.5,104.08 131.64,104.08 131.42,103.86 131.42,103.35 131.14,103.07 127.33,103.07 126.86,102.61 126.55,102.61 126.34,102.83 126.34,103.22 125.95,103.61 125.54,103.61 124.4,104.75 124.4,105.31 124.12,105.59 123.71,105.59 122.44,106.86 107.24,106.86 105.67,105.29 105.67,104.87 105.39,104.59 104.82,104.59 104.6,104.81 103.18,104.81 102.46,104.09 97.67,104.09 95.79,105.97 75.58,105.97 75.12,105.51 74.66,105.51 74.27,105.12 74.27,104.58 73.84,104.16 71.47,104.16 71.04,103.73 69.92,103.73 69.73,103.92 68.24,103.92 67.52,104.64 67.52,104.89 66,106.4 58.71,106.4 56.65,104.35 56.14,104.35 55.76,103.96 53.98,103.96 53.47,103.46 53.47,102.19 53.25,101.96 50.76,101.96 49.37,100.58 47.16,100.58 44.52,97.94 43.65,97.94 40.79,95.08 40.17,95.08 37.07,91.97 36.64,91.97 36.01,91.35 36.01,89.42 34.35,87.76 34.35,87.08 33.06,85.79 32.56,85.79 32.23,85.46 32.23,85.19 30.24,83.2 29.47,83.2 27.75,81.48 27.75,78.8 26.81,77.86 26.81,76.37 26.1,75.66 26.1,72.89 26.34,72.65 26.34,67.9 26.55,67.69 26.55,63.71 27.6,62.66 27.6,56.82 v1(27.95,56.47) ; v1(42.04,35.89) 42.04,30.13 41.41,29.49 41.41,25.86 38.78,23.23 36.29,23.23 36.04,22.98 36.04,22.43 v1(35.63,22.02)
  BOTTOM w0.149: U24.2 266.07,62.57 v1(266.07,60.98)
HPS_I2C_EN: length 62.8
  L03_SIG1 w0.127: v1(23.12,47.45) 24.23,46.34 26.11,46.34 29.09,43.36 29.09,32.97 31.4,30.66 31.95,30.66 32.35,30.26 32.35,29.06 32.03,28.74 32.03,27.46 31.79,27.22 31.23,27.22 v4(30.83,26.82)
  L05_SIG2 w0.127: v1(2.67,64.28) 8.45,64.28 13.32,59.41 13.32,58.63 16.67,55.27 16.67,47.32 17.3,46.69 22.36,46.69 v1(23.12,47.45)
  BOTTOM w0.149: SW3.2 4.02,63.76 3.5,64.28 v1(2.67,64.28) ; U22.5 v1(23.12,47.45)
HPS_I2C_SCL: length 101.3
  L05_SIG2 w0.081: v1(43.44,79.07) 43.06,79.45 43.06,80.22 43.57,80.72 43.57,80.98 46.28,83.69 57.36,83.69 58.55,82.5 68.84,82.5 69.45,81.89 76.31,81.89 79.11,79.09 83.71,79.09 85.56,79.86 89.19,79.86 89.62,79.43 89.94,79.43 90.3,79.07 90.3,78.57 90.67,78.2 v1(90.67,77.43)
  L12_SIG4 w0.089: v1(43.44,79.07) 43.44,70.18 43.31,70.06 43.31,66.02 42.3,65 42.3,62.56 40.01,60.28 40.01,59.51 37.85,57.36 32.95,57.36 30.74,55.15 30.74,52.02 30.04,51.32 24.26,51.32 v1(21.53,48.59)
  BOTTOM w0.149: v1(21.53,48.59) U22.7
HPS_I2C_SDA: length 108.5
  L05_SIG2 w0.081: v1(44.46,79.07) 44.46,79.83 44.84,80.22 44.84,80.98 47.04,83.18 57.11,83.18 58.17,82.12 68.59,82.12 69.14,81.57 76.17,81.57 78.97,78.77 83.81,78.77 85.41,79.43 88.67,79.43 89.57,78.53 89.95,78.53 90.2,78.28 90.2,77.22 90.43,76.99 90.9,76.99 91.85,76.03 92.88,76.03 93.71,75.2 93.71,74.24 94.02,73.93 94.29,73.93 94.57,73.65 94.57,72.83 94.94,72.46 94.94,71.98 v1(95,71.93)
  L12_SIG4 w0.089: v1(44.46,79.07) 44.46,69.34 43.7,68.58 43.7,65.76 42.7,64.77 42.7,62.44 40.77,60.51 40.77,59.77 37.22,56.21 32.77,56.21 31.63,55.07 31.63,51.77 30.8,50.94 24.77,50.94 v1(21.53,47.7)
  BOTTOM w0.149: U22.6 22.18,47.7 v1(21.53,47.7)
HPS_JTAG_TCK: length 104.7
  L03_SIG1 w0.081: v1(50.05,90.57) 50.31,90.57 50.76,90.12 51.06,90.12 51.32,90.38 51.32,90.76 51.12,90.95 51.12,92.1 49.79,93.42 40.29,93.42 39.45,92.59 39.45,91.6 38.92,91.06 38.92,79.76 38.21,79.05 36.68,79.05 34.07,76.43 34.07,70.67 33.73,70.32 33.73,61.94 32.7,60.91 32.7,57.1 33.87,55.93 33.87,51.89 36.43,49.33 38.11,49.33 39.58,47.86 39.58,40.58 40.68,39.48 40.68,38.78 41.79,37.67 v1(42.17,37.67)
  L12_SIG4 w0.089: v1(32.43,19.62) 32.43,19.88 32.83,20.28 32.83,21.4 33.06,21.62 33.36,21.62 33.63,21.89 33.63,22.17 33.88,22.42 34.16,22.42 34.43,22.69 34.43,22.97 34.68,23.22 34.99,23.22 35.23,23.47 35.23,23.77 35.48,24.02 39.06,24.02 39.89,24.85 39.89,30.41 41.79,32.31 41.79,35.11 42.55,35.87 42.55,37.29 v1(42.17,37.67)
HPS_JTAG_TDI: length 96.1
  L03_SIG1 w0.081: v1(48.27,90.57) 48.27,90.93 47.3,91.9 41.41,91.9 40.98,91.47 40.98,87.22 41.09,87.11 41.71,87.11 41.82,87 41.82,86.84 41.71,86.72 41.09,86.72 40.98,86.61 40.98,86.45 41.09,86.34 41.71,86.34 41.82,86.23 41.82,86.07 41.71,85.95 41.09,85.95 40.98,85.84 40.98,85.68 41.09,85.57 41.71,85.57 41.82,85.45 41.82,85.29 41.71,85.18 41.09,85.18 40.98,85.07 40.98,84.91 41.09,84.79 41.71,84.79 41.82,84.68 41.82,84.52 41.71,84.41 41.09,84.41 40.98,84.3 40.98,82.15 42.27,80.85 42.27,68.53 41.16,67.42 41.16,66.07 40.22,65.13 40.22,62 40.65,61.57 40.65,55.58 42.35,53.88 42.35,40.9 42.94,40.3 42.94,38.55 v1(43.31,38.18)
  L16_SIG6 w0.081: v1(33.23,19.62) 33.64,20.04 33.64,26.2 33.87,26.42 34.96,26.42 35.22,26.68 35.22,26.96 35.49,27.23 37.95,27.23 39.2,28.48 39.2,32.46 40.52,33.78 40.72,33.78 40.85,33.91 40.85,34.01 40.77,34.09 40.52,34.09 40.39,34.22 40.39,36.55 42.02,38.18 v1(43.31,38.18)
HPS_JTAG_TDO: length 103
  L03_SIG1 w0.081: v1(43.06,36.78) 43.06,37.34 42.35,38.05 41.92,38.05 41.41,38.56 41.41,53.42 39.48,55.35 39.48,60.45 38.87,61.06 38.87,68.02 39.5,68.66 39.5,74.3 41.36,76.15 41.36,78.87 39.92,80.31 39.92,80.45 40.01,80.55 40.15,80.55 40.79,79.91 40.93,79.91 41.03,80.01 41.03,80.15 40.08,81.1 39.7,81.1 39.51,81.28 39.51,81.75 40.06,82.3 40.06,91.89 40.78,92.61 47.94,92.61 49.62,90.93 49.76,90.93 49.86,91.03 49.86,91.17 48.31,92.72 48.31,92.86 48.41,92.96 48.54,92.96 v1(50.93,90.57)
  L12_SIG4 w0.089: v1(34.83,19.62) 35.1,19.62 35.5,20.02 35.83,20.02 36.03,20.23 36.03,20.57 35.78,20.82 35.47,20.82 35.23,21.07 35.23,21.36 35.5,21.62 36.56,21.62 36.97,22.04 39.82,22.04 40.65,22.86 40.65,28.91 42.55,30.81 42.55,34.75 43.44,35.64 43.44,36.15 43.06,36.53 v1(43.06,36.78)
HPS_JTAG_TMS: length 100.5
  L03_SIG1 w0.081: v1(49.16,90.57) 47.44,92.28 41.15,92.28 40.49,91.62 40.49,81.79 41.74,80.55 41.74,75.42 39.99,73.66 39.99,71.26 40.1,71.15 41.47,71.15 41.58,71.04 41.58,70.88 41.47,70.76 40.1,70.76 39.99,70.65 39.99,70.49 40.1,70.38 41.47,70.38 41.58,70.26 41.58,70.1 41.47,69.99 40.1,69.99 39.99,69.88 39.99,69.72 40.1,69.6 41.47,69.6 41.58,69.49 41.58,69.33 41.47,69.22 40.1,69.22 39.99,69.11 39.99,68.38 39.25,67.64 39.25,61.34 39.99,60.61 39.99,55.58 41.87,53.7 41.87,39.07 43.14,37.8 43.7,37.8 43.95,37.54 v1(43.95,36.78)
  L16_SIG6 w0.081: v1(43.95,36.78) 43.52,36.36 41.95,36.36 41.35,35.75 41.35,33.48 40.11,32.25 40.11,26.68 37.45,24.01 35.45,24.01 35.24,23.8 35.24,23.46 34.99,23.21 34.64,23.21 34.44,23.01 34.44,21.07 34.68,20.83 35.22,20.83 v1(35.63,20.42)
HPS_OSC_CLK: length 88.3
  L05_SIG2 w0.081: v1(41.09,31.07) 39.51,32.64 39.51,50.36 48.83,59.67 57.6,59.67 64.16,66.22 71.79,66.22 72.02,65.99 72.52,65.99 72.78,66.25 75.57,66.25 75.83,65.99 76.23,65.99 77.61,67.37 87.9,67.37 88.23,67.04 88.96,67.04 89.44,66.56 90.01,66.56 92.22,67.82 92.78,67.82 93.05,67.56 93.46,67.56 94.39,68.1 96.5,69.31 96.94,69.31 97.54,69.91 97.6,69.91 98.46,70.77 v1(98.46,70.93)
HPS_RESETN: length 274.1
  L03_SIG1 w0.081: v1(37.23,18.82) v1(37.23,15.7)
  L14_SIG5 w0.081: v1(140.03,51.93) 140.95,51.93 141.42,51.46 141.76,51.46 142.32,50.9 143.69,50.9 144.23,51.44 144.23,51.64 144.5,51.91 144.65,51.91 145.17,52.43 155.53,52.43 156.81,51.16 161.27,51.16 165.18,47.25 165.55,47.25 169.02,43.77 170.88,43.77 172.02,42.63 172.02,42.01 172.65,41.38 178.14,41.38 180.58,38.94 180.58,38.04 183.06,35.55 183.06,30.78 188.33,25.5 189.6,25.5 v1(197.75,17.35)
  L16_SIG6 w0.081: v1(37.23,15.7) 39.44,13.49 44.48,13.49 45.96,12.01 45.96,10.57 48.24,8.28 48.24,7.6 49.91,5.93 54.17,5.93 55.31,7.07 55.31,8.49 56.03,9.22 57.92,9.22 59.72,7.42 94.93,7.42 96.4,8.89 127.7,8.89 131.73,12.93 139.02,12.93 140.26,14.18 142.5,14.18 143.64,15.32 151.9,15.32 159.18,22.6 180.73,22.6 183.9,19.43 183.9,18.49 184.61,17.78 197.31,17.78 v1(197.75,17.35)
  BOTTOM w0.149: v1(140.03,51.93) 140.47,51.49 140.47,50.65 140.27,50.45 139.78,50.45 139.23,49.9 138.92,49.9 138.42,49.4 138.13,49.4 137.66,48.94 137.21,48.94 136.7,48.43 136.41,48.43 135.91,47.92 135.49,47.92 135.04,47.47 134.64,47.47 134.14,46.97 133.81,46.97 133.52,46.67 133.52,41.59 133.26,41.33 R125.2
HPS_WARM_RESETN: length 388.5
  L07_SIG3 w0.089: v1(33.41,54.69) 33.31,54.59 33.31,48.54 37.7,44.15 37.7,39.19 32.47,33.96 32.47,32.74 34.42,30.79 34.42,27.46 34.19,27.22 33.87,27.22 33.63,26.98 33.63,24.82 v1(34.03,24.42)
  L16_SIG6 w0.081: v1(33.41,54.69) 32.77,54.69 32.52,54.94 31.25,54.94 31.02,55.17 29.88,55.17 27.95,57.1 27.95,62.82 26.93,63.83 26.93,67.5 27.26,67.83 27.26,72.5 26.94,72.83 26.94,74.26 27.12,74.45 27.12,77.64 28.58,79.1 28.58,80.87 32.61,84.9 34.1,84.9 34.88,85.68 34.88,87.53 36.34,88.99 36.34,90.16 37.4,91.22 37.4,91.73 40.43,94.76 40.95,94.76 43.7,97.51 44.72,97.51 47.35,100.15 49.88,100.15 50.88,101.15 53.45,101.15 56.27,103.96 56.85,103.96 58.81,105.92 65.24,105.92 67.47,103.69 69.63,103.69 69.84,103.48 71.13,103.48 71.57,103.92 74.46,103.92 75.29,104.75 75.29,104.94 75.97,105.62 95.57,105.62 97.45,103.75 102.59,103.75 102.81,103.97 106.64,103.97 107.37,104.7 107.37,105.31 108.62,106.56 122.18,106.56 123.51,105.23 123.51,105.02 123.84,104.69 124.1,104.69 125.44,103.35 125.85,103.35 126.06,103.13 126.06,102.77 126.46,102.37 126.96,102.37 127.37,102.78 131.44,102.78 132.39,103.73 132.63,103.73 133.42,104.52 133.42,105.23 134.75,106.56 145.03,106.56 145.31,106.28 183.73,106.28 184.77,105.23 184.77,103.41 187.76,100.41 187.76,99.56 188.11,99.22 188.11,98.74 189.87,96.98 192.92,96.98 195.21,99.27 201.07,99.27 202.09,100.28 204.45,100.28 205.86,98.87 210.02,98.87 210.58,99.44 216.97,99.44 220.76,103.23 235.21,103.23 236.79,101.65 242.75,101.65 245.28,99.13 245.46,99.13 247.31,97.28 247.31,97.15 247.64,96.82 247.87,96.82 248.63,96.06 253.52,96.06 256.56,99.09 261.2,99.09 270.39,89.89 270.39,68.91 265.44,63.96 265.44,59.9 264.68,59.13 264.68,53.36 v1(265.18,52.85)
  BOTTOM w0.149: R324.1 v1(265.18,52.85)
I2C_INA_SCL: length 9.8
  TOP w0.149: R6289.1 220.18,40.11 220.18,40.98 220.43,41.23 221.42,41.23 221.58,41.39 v1(221.58,41.79) 221.58,42.19 221.95,42.55 223.06,42.55 223.6,42.01 223.6,40.08 224.18,39.51 U126.5
I2C_INA_SDA: length 5.1
  TOP w0.149: R6290.1 221.57,40.22 221.58,40.23 v1(221.58,40.64) 222.4,39.83 222.89,39.83 223.86,38.86 U126.6
IIN-_1:
  vias: v1(228.54,73.77) v1(228.54,72.5) v1(228.54,71.23) v1(228.54,69.96) v1(229.81,73.77) v1(229.81,72.5) v1(229.81,71.23) v1(229.81,69.96) v1(231.08,73.77) v1(231.08,72.5) v1(231.08,71.23) v1(231.08,69.96) v1(231.15,63.58) v1(231.15,62.82) v1(231.78,63.58) v1(231.78,62.82) v1(232.35,73.77) v1(232.35,72.5) v1(232.35,71.23) v1(232.35,69.96) v1(232.42,63.58) v1(232.42,62.82) v1(233.18,67.01) v1(233.18,66.12) v1(233.18,65.23) v1(233.18,64.34) v1(233.18,63.58) v1(233.31,62.82) v1(233.81,73.1) v1(233.81,72.21) v1(233.81,71.33) v1(233.81,70.44) v1(233.81,69.67) v1(233.94,67.64) v1(233.94,67.01) v1(233.94,66.12) v1(233.94,65.23) v1(233.94,64.34) v1(233.94,63.58) v1(234.07,68.79) v1(234.07,62.82) v1(234.58,73.1) v1(234.58,72.21) v1(234.58,71.33) v1(234.58,70.44) v1(234.58,69.67) v1(234.7,68.79) v1(234.7,67.9) v1(234.7,67.01) v1(234.7,66.12) v1(234.7,65.23) v1(234.7,64.34) v1(234.7,63.58) v1(234.7,62.82) v1(234.83,74.88) v1(234.83,73.99) v1(235.59,74.88) v1(235.59,73.99) v1(235.59,73.1) v1(235.59,72.21) v1(235.59,71.33) v1(235.59,70.56) v1(235.59,69.67) v1(235.59,68.79) v1(235.59,67.9) v1(235.59,67.01) v1(235.59,66.12) v1(235.59,65.23) v1(235.59,64.34) v1(235.59,63.58) v1(235.59,62.82) v1(236.35,62.94) v1(236.48,69.55) v1(236.48,68.66) v1(236.48,67.77) v1(236.48,66.88) v1(236.48,66.12) v1(236.48,65.23) v1(236.48,64.34) v1(236.48,63.58) v1(236.63,71.4) v1(236.61,70.56) v1(236.74,74.88) v1(236.71,74.02) v1(236.71,73.1) v1(236.66,72.24) v1(237.12,68.66) v1(237.12,67.77) v1(237.12,66.88) v1(237.12,66.12) v1(237.12,65.23) v1(237.12,64.34) v1(237.12,63.58) v1(237.12,62.94) v1(237.4,71.55) v1(237.37,70.56) v1(237.37,69.67) v1(237.47,74.88) v1(237.47,74.02) v1(237.5,73.13) v1(237.5,72.21) v1(238.26,74.88) v1(238.28,74.02) v1(238.28,73.13) v1(238.28,72.24) v1(239.02,74.88) v1(239.02,73.99) v1(239.02,73.1) v1(239.02,72.21) v3(236.48,70.49)
IN1+_3P3V: length 37.9
  TOP w0.203: R6291.1 233.51,37.06 233.71,36.86 R6276.1
  L12_SIG4 w0.089: v1(227.5,21.06) 235.47,21.06 236.38,21.97 236.38,25.78 236.86,26.27 238.26,26.27 239.22,27.23 239.22,30.63 234.27,35.59 v1(232.72,35.59)
  BOTTOM w0.149: R6271.1 232.23,22.03 231.26,21.06 v1(227.5,21.06)
INTVCC_PVCC: length 0.7
  TOP w0.149: R5960.2 199.3,51.82 199.3,51.74 v1(199.52,51.51)
IO_1P8V: length 210.4
  TOP w0.381: v1(210.07,31.78) 209.94,31.65 v1(209,31.65) ; U6.B4 v1(208.01,28.99)
  L05_SIG2 w0.305: v1(263.61,37.32) 263.15,37.77 255.68,37.77 255.23,37.32 253.46,37.32 v1(252.61,36.46)
  L05_SIG2 w0.508: v1(220.5,16.67) 220.5,20.12 219.51,21.11 218.62,21.11 216.67,23.07 v1(216.67,24.62)
  L07_SIG3 w0.254: v1(210.07,31.78) 210.07,32.34 209.14,33.26 195.24,33.26 193.81,31.83 189.31,31.83 186.37,34.78 186.37,37.32 185.76,37.92 184.72,37.92 179,43.64 179,48.08 177.63,49.46 166.15,49.46 160.43,55.17 158.5,55.17 158.22,55.45 154.31,55.45 153.54,54.68 151.2,54.68 149.95,53.43 v1(149.62,53.43)
  L12_SIG4 w0.305: v1(263.61,37.32) 263.07,36.78 263.07,23.88 257.21,18.01 246.59,18.01 244.3,15.73 221.44,15.73 v1(220.5,16.67)
  BOTTOM w0.191: U16.P3 U16.N4 U16.M4
  BOTTOM w0.203: v1(34.17,101.91) 33.67,101.41 U16.P5
  BOTTOM w0.229: v1(27.72,100.41) 27.72,100.64 27.45,100.91 U16.C6 ; v1(33.28,102.69) 32.99,102.41 U16.P3
  BOTTOM w0.254: v1(149.62,53.43) 144.63,53.43 144,54.05 143.01,54.05 142.88,53.93 142.43,53.93 141.89,53.39 141.56,53.39 141.13,52.96 140.67,52.96 140.22,53.42 139.81,53.42 139.33,52.94 138.95,52.94 138.46,53.42 138.08,53.42 137.57,52.91 137.25,52.91 136.77,52.43 136.38,52.43 135.87,51.92 135.5,51.92 135.02,51.44 134.65,51.44 134.14,50.93 133.76,50.93 133.26,50.42 132.9,50.42 132.39,49.91 132.01,49.91 131.55,49.46 131.2,49.46 130.66,48.92 130.33,48.92 129.88,48.47 129.39,48.47 128.94,48.92 128.58,48.92 128.1,48.44 127.72,48.44 127.24,47.96 126.8,47.96 126.3,48.47 125.97,48.47 125.51,48.92 125.13,48.92 124.82,49.23 124.82,49.66 125,49.84 125,50.07 124.77,50.29 124.77,50.6 124.94,50.76 124.94,51.09 124.7,51.34 124.7,51.67 v1(124.44,51.93) ; R216.1 v1(49.16,87.07) ; R214.1 v1(48.27,87.07) ; R158.1 v1(22.82,80.66) ; R210.1 v1(43.57,80.09) ; R213.2 v1(47.38,87.07) ; U20.8 28.3,49.33 ; C1421.1 v1(107.12,70.93) ; U22.8 22.33,49.33
  BOTTOM w0.381: R236.2 31.06,92.98 v1(31.25,93.17) ; U14.2 47.25,93.01 v1(47.25,91.07) ; v1(27.5,49.48) 28.15,49.48 28.3,49.33 ; v1(21.53,49.48) 22.18,49.48 22.33,49.33 ; U9.5 26.93,66.37 v1(28.39,66.37) ; R232.2 v1(25.66,107.84) ; R190.2 v1(47.89,108.54) ; v1(33.28,102.69) v1(34.17,102.69)
  vias: v1(2.67,74.06) v1(10.74,90.25) v1(10.74,89.23) v1(16.77,75.9) v1(17.41,75.9) v1(18.04,75.88) v1(18.55,98.01) v1(20.64,48.59) v1(20.64,47.7) v1(20.84,104.73) v1(20.84,103.74) v1(20.84,102.85) v1(20.84,101.96) v1(23.63,92.6) v1(24.61,80.66) v1(26.61,48.59) v1(26.61,47.7) v1(31.12,74.95) v1(33.28,107.84) v1(37.79,105.06) v1(37.79,104.22) v1(39.76,106.89) v1(39.76,104.22) v1(41.41,90.19) v1(42.3,90.19) v1(43.19,90.19) v1(44.08,90.19) v1(44.97,90.19) v1(45.85,90.19) v1(49.28,79.05) v1(50.55,79.05) v1(51.82,90.57) v1(52.71,90.57) v1(64.65,43.77) v1(64.65,40.72) v1(64.65,38.43) v1(64.65,37.42) v1(65.21,36.6) v1(65.41,39.7) v1(65.41,38.31) v1(65.41,37.42) v1(66.67,41.54) v1(66.67,40.74) v1(66.67,37.54) v1(66.67,36.74) v1(71.47,41.54) v1(71.53,40.8) v1(71.47,37.54) v1(71.47,36.74) v1(72.12,40.69) v1(72.27,41.48) v1(74.25,41.33) v1(74.76,41) v1(83.8,50.43) v1(84.8,50.43) v1(85.8,50.43) v1(107.12,69.93) v1(107.12,68.93) v1(124.44,52.93) v1(135.7,39.43) v1(139.16,39.43) v1(139.16,37.43) v1(139.16,36.35) v1(139.16,35.38) v1(203.33,25.86) v1(206.95,106.12) v1(206.95,101.68) v1(208.54,105.74) v1(208.54,104.98) v1(208.8,100.47) v1(216.75,25.33) v2(48.52,31.45) v2(54.24,19.76) v2(54.24,19.13) v2(54.87,19.76) v2(54.87,19.13) v2(55.51,19.76) v2(55.51,19.13) v3(62.31,37.95)
IO_1P8V_AGND: length 0.8
  BOTTOM w0.203: R6074.1 64.92,38.97 ST20.1
IO_1P8V_EN: length 389.1
  TOP w0.127: v1(37.47,65.1) 37.52,65.1 38.77,63.86 39.96,63.86 43.91,59.91 47.75,59.91 48.98,58.68 58.81,58.68 60.48,57 60.48,55.18 60.99,54.68 60.99,49.28 61.25,49.02 61.25,33.86 61.86,33.25 71.47,33.25 74.61,36.39 74.61,38.12 R6076.2
  L12_SIG4 w0.127: v1(246.41,30.69) 245.65,31.45 245.65,35.59 247.14,37.07 247.14,50.13 247.81,50.81 247.81,57.25 245.68,59.39 245.68,60.56 243.77,62.46 243.77,63.84 243.34,64.27 243.34,76.98 240.33,79.99 240.33,83.07 240.13,83.26 240.12,83.26 238.46,84.93 238.46,86.62 237.4,87.68 235.69,87.68 235.08,88.29 235.08,89.84 234.33,90.59 232.66,90.59 225.97,97.28 209.53,97.28 207.76,99.06 206.56,99.06 205.01,100.61 202.04,100.61 201.25,99.82 196.7,99.82 194.14,102.39 190.92,102.39 190.11,103.2 186.72,103.2 185.68,104.24 176.36,104.24 175.83,103.71 157.18,103.71 156.78,104.11 150.46,104.11 147.71,106.86 134.86,106.86 132.21,104.21 132.21,103.53 131.55,102.86 127.35,102.86 127.01,102.52 125.53,102.52 124.59,103.47 114.33,103.47 113.76,104.04 112.33,104.04 111.92,103.63 102.85,103.63 101.84,102.62 100.85,102.62 100.41,103.05 97.26,103.05 96.83,103.48 95.13,103.48 94.32,104.3 93.4,104.3 92.79,104.9 92.34,104.9 91.83,104.4 88.22,104.4 87.87,104.75 87.87,105.36 86.13,107.1 84.26,107.1 83.13,105.96 75.48,105.96 75.06,105.54 74.71,105.54 74.28,105.11 74.28,104.68 73.63,104.03 68.35,104.03 67.43,103.11 65.61,103.11 64.25,104.47 59.44,104.47 58.17,103.2 58.17,101.04 57.67,100.54 57.67,100.03 55.13,97.49 52.46,97.49 48.65,93.68 45.98,93.68 43.63,91.33 43.63,89.93 42.93,89.23 42.55,89.23 40.27,86.95 40.27,83.64 39.5,82.88 39.12,82.88 38.74,82.5 38.74,81.87 37.98,81.1 36.84,81.1 33.41,77.68 33.41,73.23 30.49,70.31 30.49,67.9 30.8,67.58 35.38,67.58 35.69,67.9 36.35,67.9 36.71,67.54 36.71,65.86 v1(37.47,65.1)
  BOTTOM w0.127: R367.2 v1(246.41,30.69)
