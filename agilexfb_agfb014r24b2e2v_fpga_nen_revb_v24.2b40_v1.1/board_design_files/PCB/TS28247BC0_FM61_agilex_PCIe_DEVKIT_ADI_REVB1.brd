# Allegro board TS28247BC0_FM61_agilex_PCIe_DEVKIT_ADI_REVB1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR4_DIMM_CH2_TDQS_N15: length 58.4
  L12_SIG4 w0.085: v1(118.38,42.43) 118.38,42.14 118.28,42.04 118.08,42.04 117.89,41.85 117.71,41.42 117.71,40.94 116.82,40.05 116.4,40.05 116.02,40.43 115.49,40.43 115.11,40.05 114.67,40.05 114.3,40.42 113.76,40.42 113.39,40.05 112.92,40.05 112.53,40.45 112.01,40.45 111.75,40.19 111.75,40.01 111.62,39.88 111.29,39.88 111.16,40.01 111.16,40.21 110.89,40.48 110.42,40.48 109.99,40.05 109.48,40.05 109.08,40.45 108.55,40.45 108.15,40.05 107.83,40.05 107.44,40.44 106.81,40.44 106.42,40.05 100.9,40.05 100.51,40.44 99.88,40.44 99.5,40.05 99.14,40.05 98.79,40.41 97.4,40.41 97.04,40.05 93.7,40.05 91.4,37.76 91.4,37.34 90.86,36.8 90.68,36.8 90.35,37.13 89.98,37.13 89.6,36.75 89.6,36.39 89.93,36.05 89.93,35.88 88.49,34.43 88.3,34.43 87.69,35.04 86.73,35.04 86.08,34.39 86.08,34.06 86.48,33.65 86.82,33.65 87.08,33.91 87.3,33.91 87.51,33.7 87.51,33.45 86.91,32.85 86.91,32.06 87.24,30.39 87.24,29.29 87.14,29.18 86.21,29.18 85.78,28.76 85.54,28.76 85.3,29 85.3,29.65 85.44,29.79 86.3,29.79 86.53,30.02 86.53,30.66 86.3,30.9 85.8,30.9 85.7,31 85.7,31.51 86.32,32.14 86.32,32.97 85.89,33.39 85.39,33.39 85.14,33.15 85.14,32.67 v1(84.89,32.42)
DDR4_DIMM_CH2_TDQS_N16: length 73.2
  L16_SIG6 w0.079: v1(75.54,32.42) 75.84,32.12 75.84,31.83 76.08,31.6 76.45,31.6 77.67,32.82 83.63,32.82 84.6,31.85 84.6,29.23 84.84,28.99 85.62,28.99 85.85,29.23 85.85,31.62 87.05,32.82 91.23,32.82 92.16,31.89 92.16,31.56 91.64,31.04 86.88,31.04 86.53,30.69 86.53,30.25 86.88,29.9 92.77,29.9 94.03,31.15 94.03,31.7 93.64,32.08 93.64,32.4 95.07,33.82 98.02,33.82 99.02,34.82 99.43,34.82 100.98,36.37 101.19,36.37 102.67,37.85 103.41,37.85 105.38,39.82 106.81,39.82 107.79,40.8 113.78,40.8 114.53,41.55 arc(114.54,41.57) 114.55,41.58 114.63,41.68 arc(114.75,41.78) 114.9,41.81 114.96,41.81 arc(115.08,41.79) 115.18,41.7 115.33,41.51 arc(115.51,41.37) 115.74,41.31 115.83,41.31 arc(116.05,41.37) 116.23,41.51 116.38,41.7 arc(116.48,41.78) 116.61,41.81 116.69,41.81 arc(116.91,41.87) 117.09,42.01 117.24,42.2 arc(117.34,42.28) 117.47,42.31 117.55,42.31 arc(117.78,42.37) 117.96,42.51 118.11,42.7 arc(118.21,42.78) 118.34,42.81 118.42,42.81 arc(118.6,42.85) 118.75,42.95 118.88,43.08 118.98,43.32 118.98,43.58 118.86,43.86 118.86,44.03 118.98,44.31 118.98,44.57 118.86,44.85 118.68,45.04 118.48,45.04 118.38,45.14 v1(118.38,45.43)
DDR4_DIMM_CH2_TDQS_N17: length 42.2
  L12_SIG4 w0.085: v1(130.5,45.43) 130.5,45.13 130.6,45.02 130.81,45.02 131,44.84 131.11,44.57 131.11,44.31 130.99,44.01 130.99,43.87 131.06,43.69 131.14,43.61 131.29,43.55 131.45,43.55 131.72,43.44 131.88,43.28 131.97,43.05 131.97,42.77 131.86,42.5 131.86,42.33 131.97,42.05 131.97,41.81 131.86,41.53 131.86,41.35 132.15,40.65 133.76,39.03 134.16,39.03 134.58,38.61 134.58,38.21 134.39,38.02 134.39,37.88 134.58,37.69 134.58,36.9 134.86,36.62 135.03,36.62 135.45,37.04 135.98,37.04 136.43,36.59 136.8,36.59 136.9,36.7 136.9,37.11 137.22,37.43 137.74,37.43 138,37.17 138,36.66 138.13,36.53 138.55,36.53 138.78,36.3 138.78,35.72 138.55,35.49 136.58,35.49 136.48,35.39 136.48,35 136.64,34.84 139.15,34.84 139.76,35.45 140.25,35.45 140.87,34.84 141.14,34.84 141.28,34.98 141.28,35.75 141.5,35.97 142.14,35.97 142.36,35.75 142.36,35.03 142.49,34.9 142.85,34.9 142.98,35.03 142.98,35.43 143.2,35.66 144.61,35.66 144.84,35.43 144.84,34.95 144.45,34.57 144.45,34.42 144.91,33.96 145.37,33.96 145.47,34.06 145.47,34.71 145.8,35.04 146.35,35.04 146.65,34.74 146.65,33.92 147.51,33.06 148.36,33.06 148.62,32.8 148.75,32.8 148.88,32.94 149.02,32.94 149.12,32.84 149.12,32.7 148.99,32.57 148.99,32.43 149.52,31.9 149.7,31.9 149.8,32 149.8,32.16 v1(149.54,32.42)
DDR4_DIMM_CH3_A0: length 88.6
  L07_SIG3 w0.089: v1(121.37,24.79) 121.03,24.79 120.17,25.65 120.05,25.65 119.93,25.53 119.93,25.4 120.92,24.41 120.92,24.29 120.81,24.17 120.68,24.17 120.34,24.51 120.09,24.51 119.96,24.38 119.96,24.11 119.87,24.02 118.39,24.02 118.3,24.11 118.3,24.28 118.39,24.36 119.21,24.36 119.36,24.51 119.36,24.99 119.17,25.19 118.8,25.19 118.7,25.29 118.7,25.56 118.6,25.66 118.45,25.66 118.35,25.56 118.35,24.83 118.26,24.74 118.1,24.74 118.01,24.83 118.01,25.11 117.92,25.2 116.91,25.2 116.83,25.29 116.83,25.52 116.91,25.61 117.28,25.61 117.37,25.7 117.37,25.9 117.28,25.98 116.37,25.98 116.28,26.07 116.28,26.26 116.37,26.35 116.63,26.35 116.75,26.47 116.75,26.88 116.66,26.97 116.23,26.97 115.92,27.28 115.92,27.57 116.15,27.8 116.15,28.05 115.92,28.28 115.92,28.82 115.84,28.91 115.67,28.91 115.58,28.82 115.58,27.57 115.48,27.47 115.22,27.47 115.01,27.68 115.01,28.04 115.22,28.26 115.22,28.72 114.98,28.96 114.46,28.96 114.25,28.75 114.25,27.62 114.16,27.53 114,27.53 113.91,27.62 113.91,28.85 113.82,28.94 113.65,28.94 113.56,28.85 113.56,28.28 113.47,28.19 113.31,28.19 113.22,28.28 113.22,28.84 113.13,28.93 112.98,28.93 112.87,28.81 112.87,28.33 112.78,28.25 112.61,28.25 112.52,28.33 112.52,28.78 112.42,28.88 112.02,28.88 111.81,28.67 109.54,28.67 109.44,28.77 109.44,28.92 109.53,29.01 111.66,29.01 111.75,29.1 111.75,29.26 111.66,29.35 109.17,29.35 109.08,29.44 109.08,29.61 109.17,29.7 110.74,29.7 110.83,29.79 110.83,29.95 110.74,30.04 108.57,30.04 108.39,29.86 108.39,29.67 108,29.28 105.53,29.28 105.44,29.37 105.44,29.53 105.53,29.62 107.76,29.62 107.85,29.71 107.85,29.88 107.76,29.96 102.45,29.96 102.36,30.05 102.36,30.22 102.45,30.31 108.25,30.31 108.34,30.4 108.34,30.56 108.25,30.65 106.53,30.65 106.44,30.74 106.44,30.9 106.53,30.99 107.67,30.99 107.76,31.08 107.76,31.23 107.66,31.34 106.32,31.34 105.77,30.78 102.39,30.78 102.3,30.87 102.3,31.04 102.39,31.13 103.83,31.13 103.92,31.21 103.92,31.38 103.83,31.47 102.59,31.47 102.37,31.69 102.37,32.02 102.74,32.4 102.74,32.81 101.9,33.65 101.9,40.61 101.72,41.04 101.57,41.19 101.39,41.63 101.13,41.89 100.95,41.89 100.67,42.17 100.67,42.48 100.73,42.63 100.94,42.84 101.3,42.84 101.92,43.47 v1(101.92,43.93)
DDR4_DIMM_CH3_A1: length 89
  L07_SIG3 w0.089: v1(132.49,24.8) 132.32,24.97 132.32,26.06 132.02,26.36 131.61,26.36 131.52,26.44 131.52,26.61 131.61,26.7 132.04,26.7 132.13,26.79 132.13,26.95 132.04,27.04 131.49,27.04 131.27,27.26 131.27,27.8 131.17,27.91 130.96,27.91 130.86,27.81 130.86,27.35 130.76,27.25 130.62,27.25 130.52,27.35 130.52,28.05 130.42,28.15 130.28,28.15 130.18,28.05 130.18,27.61 130.08,27.5 129.93,27.5 129.83,27.61 129.83,28.05 129.73,28.15 129.59,28.15 129.49,28.05 129.49,27.9 129.39,27.8 129.25,27.8 129.15,27.9 129.15,28.05 129.05,28.15 126.62,28.15 126.5,28.03 126.5,27.19 126.41,27.1 126.18,27.1 126.09,27.19 126.09,28.03 126,28.12 125.78,28.12 125.69,28.03 125.69,27.15 125.6,27.06 125.36,27.06 125.27,27.15 125.27,30.49 124.45,31.32 123.5,31.32 122.68,30.51 122.68,27.63 122.59,27.54 122.43,27.54 122.34,27.63 122.34,29.92 122.25,30.01 122.09,30.01 122,29.92 122,28.77 121.91,28.68 121.74,28.68 121.65,28.77 121.65,30.05 121.57,30.14 121.4,30.14 121.31,30.05 121.31,28.82 121.22,28.74 121.06,28.74 120.97,28.82 120.97,30.57 120.75,30.79 120.42,30.79 120.19,30.55 120.19,30.26 120.56,29.89 120.56,27.66 120.47,27.57 120.3,27.57 120.21,27.66 120.21,29.73 120.12,29.82 119.96,29.82 119.87,29.73 119.87,27.65 119.78,27.56 119.62,27.56 119.53,27.65 119.53,29.74 119.44,29.83 119.27,29.83 119.18,29.74 119.18,28.92 119.1,28.83 118.93,28.83 118.84,28.92 118.84,30.15 118.2,30.79 117.89,30.79 117.46,30.36 116.93,30.36 116.5,30.79 116.19,30.79 115.76,30.36 114.38,30.36 113.95,30.79 113.64,30.79 113.42,30.57 113.26,30.57 112.47,31.37 112.47,31.71 111.74,32.44 110.12,32.44 109.23,33.32 105.64,33.32 105.55,33.41 105.55,33.58 105.64,33.67 106.12,33.67 106.21,33.76 106.21,33.92 106.12,34.01 104.49,34.01 104.4,34.1 104.4,34.28 104.49,34.37 105.85,34.37 105.94,34.46 105.94,34.63 105.85,34.72 105.43,34.72 105.34,34.8 105.34,34.98 105.43,35.07 105.79,35.07 105.88,35.16 105.88,35.33 105.79,35.42 105.11,35.42 104.97,35.28 104.97,34.86 104.87,34.76 104.72,34.76 104.6,34.89 104.36,34.89 104.21,34.74 104.03,34.74 103.93,34.84 103.93,35.73 104.02,35.82 104.36,35.82 104.45,35.91 104.45,36.1 104.36,36.19 104.05,36.19 103.9,36.34 103.9,37.45 104.2,37.75 104.2,38.08 103.9,38.38 103.9,38.67 104.16,38.94 104.16,39.23 103.9,39.49 103.9,41.21 104.08,41.4 104.08,41.54 104.32,41.78 104.32,42.07 104.08,42.31 104.08,42.53 104.33,42.78 104.33,43.06 103.89,43.5 103.46,43.5 103.26,43.7 103.26,44.06 103.48,44.28 103.48,44.57 103.24,44.81 102.46,44.81 102.34,44.93 v1(101.92,44.93)
DDR4_DIMM_CH3_A2: length 87.9
  L14_SIG5 w0.081: v1(101.06,44.43) 102.11,44.43 102.33,44.21 102.33,41.78 101.54,40.99 101.54,32.76 101.47,32.69 101.47,32.32 101.7,32.08 101.7,31.33 101.46,31.09 101.46,24.5 101.37,24.41 101.37,20.47 101.47,20.37 101.61,20.37 101.71,20.47 101.71,23.1 101.81,23.2 101.94,23.2 102.04,23.1 102.04,20.49 102.14,20.39 102.28,20.39 102.38,20.49 102.38,22.4 102.48,22.5 102.61,22.5 102.71,22.4 102.71,20.4 102.81,20.29 102.95,20.29 103.05,20.4 103.05,21.71 103.15,21.82 103.28,21.82 103.38,21.71 103.38,20.44 103.49,20.34 103.62,20.34 103.72,20.44 103.72,21.03 103.82,21.14 103.95,21.14 104.05,21.03 104.05,18.38 105.68,16.75 108.74,16.75 109.14,16.35 112.05,16.35 113.24,15.17 121.47,15.17 122.05,15.75 127.06,15.75 127.84,16.53 128.03,16.53 128.13,16.43 128.13,15.87 128.23,15.77 128.36,15.77 128.46,15.87 128.46,16.59 128.56,16.69 128.7,16.69 128.8,16.59 128.8,15.86 128.9,15.76 129.03,15.76 129.13,15.86 129.13,16.51 129.24,16.61 129.37,16.61 129.47,16.51 129.47,15.88 129.57,15.78 129.7,15.78 129.8,15.88 129.8,16.39 129.91,16.49 130.04,16.49 130.14,16.39 130.14,15.88 130.24,15.78 130.38,15.78 130.48,15.88 130.48,16.52 130.58,16.63 130.71,16.63 130.82,16.52 130.82,15.9 130.92,15.79 131.05,15.79 131.15,15.9 131.15,17.04 131.25,17.15 131.38,17.15 131.49,17.04 131.49,15.9 131.59,15.8 131.72,15.8 131.82,15.9 131.82,17.31 131.92,17.41 132.06,17.41 132.16,17.31 132.16,16.51 132.26,16.41 132.39,16.41 132.49,16.51 v1(132.49,18.8)
DDR4_DIMM_CH3_A3: length 89.2
  L07_SIG3 w0.089: v1(101.06,45.43) 101.06,45.77 101.72,46.44 102.14,46.44 102.61,45.97 102.99,45.97 103.47,46.45 103.86,46.45 104.22,46.81 104.87,46.81 105.12,46.56 105.12,46.21 104.93,46.03 104.93,44.72 105.23,44.42 105.43,44.42 105.71,44.14 105.76,44 105.76,43.84 105.65,43.58 105.65,43.27 105.76,43 105.76,42.85 105.62,42.5 105.62,42.36 105.76,42.01 105.76,41.85 105.71,41.72 105.5,41.51 105.38,41.51 105.25,41.38 105.25,41.03 105.5,40.79 105.5,40.52 105.3,40.32 105.3,40.02 105.5,39.82 105.5,39.45 105.3,39.25 105.3,38.77 105.39,38.68 105.72,38.68 105.82,38.58 105.82,38.37 105.72,38.26 105.34,38.26 105.25,38.18 105.25,37.94 105.34,37.85 105.81,37.85 105.9,37.76 105.9,37.55 105.81,37.46 105.35,37.46 105.27,37.37 105.27,37.02 105.35,36.93 106.54,36.93 106.66,37.06 106.66,37.57 106.76,37.67 106.9,37.67 107.01,37.57 107.01,36.74 106.86,36.59 105.98,36.59 105.89,36.5 105.89,36.3 105.98,36.21 107.29,36.21 107.72,35.79 107.86,35.79 107.99,35.92 107.99,36.06 107.61,36.45 107.61,36.59 107.71,36.69 107.85,36.69 108.4,36.14 108.4,35.23 109.78,33.85 109.92,33.85 110.02,33.95 110.02,34.42 109.9,34.54 109.57,34.54 108.8,35.31 108.8,35.95 108.9,36.05 109.14,36.05 109.25,35.95 109.25,35.35 109.65,34.95 110.16,34.95 110.4,34.71 110.4,33.24 110.49,33.15 110.66,33.15 110.75,33.24 110.75,34.21 110.85,34.31 110.99,34.31 111.09,34.21 111.09,33.82 111.19,33.72 111.33,33.72 111.51,33.89 111.63,33.89 112.22,33.29 112.22,32.93 112.66,32.49 113.27,32.49 113.56,32.2 113.73,32.2 113.82,32.29 113.82,32.81 113.91,32.9 114.07,32.9 114.16,32.81 114.16,32.25 114.26,32.15 114.4,32.15 114.5,32.25 114.5,32.44 114.6,32.54 114.74,32.54 114.85,32.44 114.85,32.25 114.95,32.15 115.09,32.15 115.19,32.25 115.19,32.4 115.29,32.5 115.43,32.5 115.53,32.4 115.53,32.25 115.63,32.15 115.77,32.15 115.87,32.25 115.87,32.82 115.97,32.92 116.12,32.92 116.22,32.82 116.22,32.25 116.32,32.15 116.46,32.15 116.56,32.25 116.56,32.49 116.66,32.59 116.8,32.59 116.9,32.49 116.9,32.25 117,32.15 117.15,32.15 117.25,32.25 117.25,32.39 117.35,32.49 117.49,32.49 117.59,32.39 117.59,32.25 117.69,32.15 117.83,32.15 117.93,32.25 117.93,32.81 118.03,32.91 118.17,32.91 118.27,32.81 118.27,32.25 118.37,32.15 118.52,32.15 118.62,32.25 118.62,32.5 118.72,32.6 118.86,32.6 118.96,32.5 118.96,32.25 119.06,32.15 119.2,32.15 119.3,32.25 119.3,32.37 119.4,32.47 119.55,32.47 119.65,32.37 119.65,32.25 119.75,32.15 119.89,32.15 119.99,32.25 119.99,32.8 120.09,32.9 120.23,32.9 120.33,32.8 120.33,32.25 120.43,32.15 120.57,32.15 120.67,32.25 120.67,32.81 120.78,32.91 120.92,32.91 121.02,32.81 121.02,32.25 121.12,32.15 121.26,32.15 121.36,32.25 121.36,32.4 121.46,32.5 121.77,32.5 121.89,32.38 121.89,32.2 122.16,31.93 122.59,31.93 122.78,32.13 122.78,32.79 122.88,32.89 123.03,32.89 123.13,32.79 123.13,32.25 123.23,32.15 123.37,32.15 123.47,32.25 123.47,32.79 123.57,32.89 123.71,32.89 123.81,32.79 123.81,32.38 123.95,32.24 124.53,32.24 125.96,30.81 125.96,28.95 126.06,28.85 126.2,28.85 126.3,28.95 126.3,30.23 126.4,30.33 126.54,30.33 126.64,30.23 126.64,28.97 126.74,28.87 126.89,28.87 126.99,28.97 126.99,29.55 127.09,29.65 127.23,29.65 127.33,29.55 127.33,28.98 127.47,28.84 131.76,28.84 131.92,28.68 131.92,28.25 132.16,28.01 132.48,28.01 132.62,27.87 132.62,27.55 133.18,27 133.62,27 133.78,26.84 133.78,26.1 133.89,25.99 135.11,25.99 135.2,25.9 135.2,25.64 135.11,25.55 134.21,25.55 134.12,25.47 134.12,25.3 134.21,25.21 134.59,25.21 134.68,25.12 134.68,24.96 134.59,24.87 133.69,24.87 133.62,24.8 v1(133.34,24.8)
DDR4_DIMM_CH3_A4: length 87.8
  L07_SIG3 w0.089: v1(100.19,43.93) 100.07,44.05 99.14,44.05 98.88,44.31 98.4,44.31 98.25,44.25 97.91,43.91 97.65,43.8 97.44,43.8 96.94,43.31 96.57,43.31 96.34,43.07 96.34,42.58 96.13,42.07 96.13,41.76 96.24,41.5 96.24,41.07 93.75,38.58 93.75,37.61 91.97,35.83 91.97,32.86 91.24,32.13 91.24,31.55 91.77,31.03 91.77,27.35 91.24,26.82 91.24,24.53 93.23,22.54 96.4,22.54 97.03,21.91 103.1,21.91 103.29,21.72 108.09,21.72 108.54,22.17 108.85,22.17 109.15,21.87 111.43,21.87 112.13,21.17 119.53,21.17 119.93,20.78 119.93,20.01 120.28,19.66 120.81,19.66 122.06,18.41 122.48,18.41 123.24,19.18 126.19,19.18 127.87,20.86 131.86,20.86 132.17,21.17 140.65,21.17 140.75,21.07 140.75,20.46 140.65,20.36 137.15,20.36 135.21,18.42 134.57,18.42 v1(134.19,18.8)
DDR4_DIMM_CH3_A5: length 87.8
  L07_SIG3 w0.089: v1(135.04,18.8) 135.46,19.21 135.46,20.17 135.24,20.39 132.16,20.39 132.03,20.51 128.32,20.51 127.77,19.96 127.77,19.53 127.44,19.2 127.01,19.2 126.57,18.76 124.45,18.76 124.35,18.66 124.35,18.51 124.45,18.41 126.48,18.41 126.58,18.31 126.58,18.17 126.48,18.07 121.88,18.07 120.72,19.23 120.13,19.23 118.94,20.42 118.57,20.42 118.47,20.32 118.47,19.84 118.37,19.74 116.94,19.74 116.84,19.84 116.84,19.98 116.94,20.08 118.02,20.08 118.12,20.18 118.12,20.32 118.02,20.42 115.63,20.42 115.53,20.32 115.53,19.82 115.43,19.72 115.29,19.72 115.19,19.82 115.19,20.32 115.09,20.42 113.77,20.42 113.69,20.34 113.69,19.83 113.59,19.73 113.45,19.73 113.35,19.83 113.35,20.32 113.25,20.42 112.05,20.42 111.11,21.36 103.17,21.36 102.96,21.57 96.89,21.57 96.26,22.2 92.78,22.2 90.44,24.54 90.44,26.69 91.38,27.63 91.38,30.85 90.44,31.79 90.44,32.62 91.63,33.8 91.63,35.97 93.41,37.75 93.41,38.72 95.43,40.74 95.43,42.68 95.74,43 95.96,43 96.51,43.55 96.88,43.55 97.38,44.05 97.68,44.05 97.8,44.1 98.13,44.44 98.41,44.55 98.77,44.55 99.03,44.8 99.72,44.8 99.85,44.93 v1(100.19,44.93)
DDR4_DIMM_CH3_A6: length 87.8
  L07_SIG3 w0.089: v1(135.04,24.8) 134.76,24.51 133.89,24.51 133.79,24.4 133.1,24.4 132.94,24.57 132.94,25.08 133.04,25.18 133.27,25.18 133.36,25.27 133.36,25.43 133.27,25.52 132.74,25.52 132.67,25.6 132.67,25.79 132.74,25.86 133.31,25.86 133.41,25.96 133.41,26.11 133.31,26.21 133.04,26.21 132.94,26.31 132.94,26.67 131.53,28.07 131.53,28.32 131.35,28.5 125.85,28.5 125.62,28.73 125.62,30.66 124.48,31.8 123.06,31.8 122.78,31.52 122.78,31.12 122.68,31.02 122.54,31.02 122.44,31.12 122.44,31.44 122.34,31.54 122.19,31.54 122.09,31.44 122.09,30.46 121.99,30.36 121.85,30.36 121.75,30.46 121.75,31.7 121.65,31.8 121.51,31.8 121.41,31.7 121.41,30.97 121.31,30.87 121.17,30.87 121.07,30.97 121.07,31.7 120.97,31.8 120.28,31.8 120.18,31.7 120.18,31.06 120.08,30.96 119.93,30.96 119.83,31.06 119.83,31.7 119.73,31.8 119.59,31.8 119.49,31.7 119.49,30.33 119.39,30.23 119.25,30.23 119.15,30.33 119.15,31.7 119.05,31.8 118.91,31.8 118.81,31.7 118.81,31.06 118.7,30.96 118.56,30.96 118.46,31.06 118.46,31.7 118.36,31.8 117.43,31.8 117.33,31.7 117.33,30.83 117.23,30.73 117.09,30.73 116.99,30.83 116.99,31.7 116.89,31.8 116.02,31.8 115.92,31.7 115.92,31.05 115.82,30.94 115.68,30.94 115.58,31.05 115.58,31.7 115.48,31.8 115.34,31.8 115.24,31.7 115.24,30.81 115.14,30.71 114.99,30.71 114.89,30.81 114.89,31.7 114.79,31.8 114.65,31.8 114.55,31.7 114.55,31.05 114.45,30.94 114.31,30.94 114.21,31.05 114.21,31.7 114.11,31.8 113.49,31.8 113.39,31.7 113.39,31.32 113.29,31.22 113.15,31.22 113.05,31.32 113.05,31.98 112.9,32.13 112.54,32.13 111.89,32.78 110.26,32.78 109.32,33.72 106.65,33.72 106.56,33.81 106.56,33.98 106.65,34.07 108.71,34.07 108.79,34.15 108.79,34.32 108.71,34.41 106.39,34.41 106.31,34.5 106.31,34.66 106.39,34.75 107.74,34.75 107.83,34.84 107.83,35 107.74,35.09 106.72,35.09 106.63,35.18 106.63,35.35 106.72,35.44 107.21,35.44 107.3,35.53 107.3,35.69 107.18,35.82 104.91,35.82 104.82,35.9 104.82,36.13 104.91,36.22 105.44,36.22 105.53,36.31 105.53,36.48 105.44,36.57 104.41,36.57 104.32,36.66 104.32,36.9 104.41,36.99 104.82,36.99 104.91,37.09 104.91,37.58 104.68,37.81 104.68,38.05 104.91,38.28 104.91,38.57 104.68,38.8 104.68,39.06 104.91,39.29 104.91,39.91 104.81,40.01 104.36,40.01 104.26,40.11 104.26,40.25 104.36,40.35 104.81,40.35 104.91,40.45 104.91,40.59 104.81,40.69 104.36,40.69 104.26,40.79 104.26,40.94 104.36,41.04 104.81,41.04 104.91,41.14 104.91,43.63 104.61,43.93 104.33,43.93 104.07,44.18 104.07,45.25 103.9,45.43 103.43,45.43 103.05,45.05 102.63,45.05 102.17,45.52 101.68,45.52 101.09,44.93 100.83,44.93 100.45,44.55 99.85,44.55 99.73,44.43 v1(99.32,44.43)
DDR4_DIMM_CH3_A7: length 88.9
  L07_SIG3 w0.089: v1(99.32,45.43) 98.22,45.43 97.78,44.99 97.33,44.99 96.89,45.43 96.56,45.43 96.06,44.93 95.68,44.93 95.18,44.43 94.83,44.43 94.56,44.16 94.56,43.33 94.34,43.11 94.34,42.74 94.5,42.58 94.5,42.27 94.32,42.09 94.32,41.77 94.5,41.58 94.5,40.79 91.65,37.93 91.65,36.96 90.78,36.1 90.78,34.58 88.77,32.57 88.77,24.61 88.96,24.41 89.28,24.41 92.18,21.51 95.97,21.51 96.61,20.88 102.67,20.88 103.13,20.43 107.97,20.43 108.82,19.58 110.07,19.58 110.25,19.4 110.67,19.4 110.85,19.22 112.2,19.22 113.02,18.41 118.04,18.41 118.14,18.31 118.14,18.04 118.24,17.94 118.38,17.94 118.48,18.04 118.48,18.31 118.58,18.41 118.72,18.41 118.83,18.31 118.83,18.04 118.93,17.94 119.07,17.94 119.17,18.04 119.17,18.31 119.27,18.41 121.06,18.41 121.74,17.73 126.77,17.73 127.76,18.72 127.76,18.89 128.1,19.23 128.58,19.23 128.7,19.36 128.7,19.97 128.91,20.17 131.83,20.17 132.21,19.78 132.21,19.33 132.32,19.23 132.54,19.23 132.64,19.33 132.64,19.75 132.85,19.95 134.98,19.95 135.08,19.85 135.08,19.6 134.98,19.49 133.9,19.49 133.76,19.35 133.76,19.03 133.61,18.88 133,18.88 132.9,18.78 132.9,18.59 133,18.49 133.6,18.49 134.01,18.08 135.35,18.08 136.31,19.04 136.5,19.04 v1(136.74,18.8)
DDR4_DIMM_CH3_A8: length 88.3
  L07_SIG3 w0.089: v1(98.46,43.93) 98.81,43.93 98.93,43.81 99.76,43.81 100.02,43.54 100.48,43.54 100.58,43.64 100.58,43.89 100.74,44.05 100.96,44.05 101.23,43.79 101.41,43.79 101.54,43.92 101.54,44.28 101.76,44.5 102.15,44.5 102.54,44.11 102.54,43.79 102.33,43.57 102.33,43.09 102.55,42.87 102.75,42.87 102.9,43.02 103.13,43.02 103.26,42.88 103.26,42.66 103.49,42.44 103.49,42.29 103.31,42.12 103.05,42.12 102.96,42.03 102.96,41.8 103.06,41.7 103.33,41.7 103.54,41.49 103.54,41.3 103.44,41.2 103.11,41.2 103.01,41.1 103.01,40.95 103.11,40.85 103.44,40.85 103.54,40.75 103.54,40.61 103.44,40.51 103.19,40.51 103.09,40.41 103.09,40.22 103.19,40.12 103.44,40.12 103.54,40.02 103.54,34.47 103.66,34.35 103.94,34.35 104.03,34.26 104.03,34.1 103.94,34.01 103.47,34.01 103.39,33.92 103.39,33.76 103.47,33.67 105.06,33.67 105.15,33.58 105.15,33.41 105.06,33.33 104.13,33.33 104.04,33.24 104.04,33.07 104.13,32.98 104.8,32.98 104.9,32.88 104.9,32.34 105,32.24 105.14,32.24 105.24,32.34 105.24,32.88 105.34,32.98 105.89,32.98 106.08,32.8 106.42,32.8 106.61,32.98 106.95,32.98 107.14,32.8 107.48,32.8 107.67,32.98 108.01,32.98 108.2,32.8 108.54,32.8 108.72,32.98 108.99,32.98 109.33,32.64 109.33,32.47 109.06,32.2 109.06,32.07 109.24,31.89 109.36,31.89 109.69,32.22 109.82,32.22 109.93,32.1 109.93,31.98 109.7,31.75 109.7,31.62 109.82,31.5 109.94,31.5 110.53,32.09 111.58,32.09 111.66,32 111.66,31.84 111.58,31.75 110.88,31.75 110.79,31.66 110.79,31.39 110.88,31.3 111.59,31.3 112.01,30.89 112.46,30.89 113.33,30.02 116.88,30.02 117.18,29.72 117.37,29.72 117.46,29.81 117.46,29.92 117.55,30.01 117.72,30.01 117.8,29.92 117.8,29.56 117.65,29.4 117.65,29.15 117.8,29 117.8,27.33 117.89,27.24 118.06,27.24 118.15,27.33 118.15,29.99 118.24,30.08 118.4,30.08 118.49,29.99 118.49,28.28 118.76,28.01 118.76,27.83 118.49,27.56 118.49,26.84 118.62,26.71 118.93,26.71 119.03,26.81 119.03,27.01 119.21,27.19 120.88,27.19 120.99,27.29 120.99,27.93 121.09,28.03 121.59,28.03 121.74,28.18 121.88,28.18 121.98,28.08 121.98,27.93 121.84,27.8 121.84,27.31 121.98,27.17 122.57,27.17 122.93,26.82 123.07,26.82 123.17,26.92 123.17,27.63 123.27,27.73 123.41,27.73 123.51,27.63 123.51,26.82 123.61,26.72 123.76,26.72 123.86,26.82 123.86,27.51 123.96,27.61 124.1,27.61 124.2,27.51 124.2,26.82 124.3,26.72 124.44,26.72 124.54,26.82 124.54,27.71 124.64,27.81 124.79,27.81 124.89,27.71 124.89,26.82 124.99,26.72 126.53,26.72 126.87,27.06 126.87,27.57 127.09,27.79 127.41,27.79 127.63,27.57 127.85,27.57 128.07,27.79 128.4,27.79 128.62,27.57 128.62,27.06 128.96,26.72 129.23,26.72 129.64,27.13 130.24,27.13 130.58,26.79 130.95,26.79 131.17,26.57 131.17,26.1 131.29,25.98 131.73,25.98 131.98,25.74 131.98,24.73 132.72,23.99 133.86,23.99 134.04,24.17 134.44,24.17 134.64,23.96 134.8,23.96 134.91,24.07 134.91,24.18 135,24.27 135.15,24.27 135.24,24.18 135.24,23.85 135.33,23.76 135.49,23.76 135.58,23.85 135.58,24.26 135.67,24.35 135.84,24.35 135.93,24.26 135.93,23.86 136.01,23.77 136.18,23.77 136.59,24.18 137.28,24.18 137.39,24.28 137.39,24.42 137.28,24.53 136.16,24.53 v1(135.89,24.8)
DDR4_DIMM_CH3_A9: length 88
  L07_SIG3 w0.089: v1(98.46,44.93) 98.58,45.05 99.59,45.05 99.74,45.2 99.74,47.18 100,47.43 100.41,47.43 100.81,47.03 101.37,47.03 101.77,47.43 102.07,47.43 102.54,46.96 102.96,46.96 103.44,47.43 103.81,47.43 104.19,47.05 104.82,47.05 105.19,47.41 105.54,47.41 105.83,47.12 105.83,44.33 105.95,44.21 106.01,44.07 106.01,43.81 105.87,43.48 105.87,43.35 105.99,43.06 105.99,42.79 105.87,42.5 105.87,42.36 106.02,42.01 106.02,41.85 105.86,41.47 105.86,39.08 106.03,38.91 106.43,38.91 106.64,38.7 106.64,38.14 106.74,38.05 107.06,38.05 107.56,37.54 107.56,37.22 107.74,37.05 108,37.05 108.63,36.42 109.3,36.42 111.03,34.69 111.31,34.69 112.57,33.44 112.57,33.07 112.79,32.85 113.1,32.85 113.51,33.26 114.5,33.26 114.91,32.85 115.22,32.85 115.64,33.26 116.62,33.26 117.04,32.85 117.35,32.85 117.76,33.26 118.69,33.26 119.1,32.85 119.42,32.85 119.83,33.26 121.23,33.26 121.64,32.85 121.96,32.85 122.37,33.26 124.16,33.26 128.24,29.18 132.74,29.18 132.97,28.95 132.97,27.91 133.06,27.83 133.7,27.83 133.79,27.91 133.79,28.51 133.87,28.6 134.04,28.6 134.13,28.51 134.13,26.89 134.22,26.8 134.38,26.8 134.47,26.89 134.47,28.51 134.56,28.6 134.72,28.6 134.81,28.51 134.81,26.89 134.9,26.8 135.07,26.8 135.16,26.89 135.16,27.68 135.25,27.76 135.41,27.76 135.5,27.68 135.5,27.11 135.65,26.97 135.89,26.97 135.99,26.87 135.99,26.71 135.89,26.61 135.61,26.61 135.51,26.51 135.51,26.24 135.61,26.14 135.89,26.14 135.99,26.04 135.99,25.41 136.53,24.87 136.74,24.87 136.84,24.97 136.84,25.12 136.36,25.6 136.36,27.53 136.45,27.61 136.62,27.61 136.71,27.53 136.71,26.95 136.8,26.87 136.96,26.87 137.05,26.95 137.05,27.38 137.14,27.47 137.33,27.47 137.42,27.38 137.42,26.83 137.18,26.59 137.18,26.15 137.39,25.94 137.71,25.94 137.8,25.85 137.8,25.14 137.89,25.05 138.06,25.05 138.15,25.14 138.15,26.59 138.23,26.68 138.4,26.68 138.49,26.59 138.49,26.24 138.58,26.15 138.74,26.15 138.83,26.24 138.83,26.65 139.08,26.9 139.39,26.9 139.57,27.08 139.7,27.08 139.88,26.9 139.88,26.77 139.69,26.58 139.69,26.09 139.59,25.99 139.09,25.99 138.99,25.89 138.99,25.75 139.09,25.65 139.59,25.65 139.69,25.55 139.69,24.26 139.6,24.18 139.33,24.18 139.24,24.26 139.24,25.21 139.16,25.3 138.95,25.3 138.86,25.21 138.86,24.48 138.78,24.39 138,24.39 v1(137.59,24.8)
DDR4_DIMM_CH3_A10: length 86.7
  L07_SIG3 w0.089: v1(119.74,18.8) 119.21,19.33 118.82,19.33 118.72,19.23 118.72,18.92 118.62,18.82 118.48,18.82 118.38,18.92 118.38,19.23 118.28,19.33 118.14,19.33 118.03,19.23 118.03,18.92 117.93,18.82 117.79,18.82 117.69,18.92 117.69,19.23 117.59,19.33 116.44,19.33 116.34,19.23 116.34,18.88 116.24,18.78 116.1,18.78 116,18.88 116,19.23 115.9,19.33 114.77,19.33 114.67,19.23 114.67,18.87 114.57,18.77 114.43,18.77 114.33,18.87 114.33,19.23 114.23,19.33 112.65,19.33 112.31,19.67 111.72,19.67 111.57,19.83 111.57,20.36 111.47,20.47 111.33,20.47 111.23,20.36 111.23,19.71 111.13,19.61 110.99,19.61 110.89,19.71 110.89,20.88 110.78,20.98 110.64,20.98 110.54,20.88 110.54,20.29 110.44,20.19 110.3,20.19 110.2,20.29 110.2,20.92 110.1,21.02 109.96,21.02 109.86,20.92 109.86,20.08 109.76,19.98 109.57,19.98 109.47,20.08 109.47,20.92 109.37,21.02 109.18,21.02 109.07,20.9 109.07,20.29 108.97,20.19 108.73,20.19 108.04,20.87 103.17,20.87 102.82,21.22 96.75,21.22 96.12,21.85 92.4,21.85 89.6,24.65 89.6,26.81 89.7,26.91 90.11,26.91 90.21,27.01 90.21,27.16 90.11,27.26 89.3,27.26 89.2,27.36 89.2,27.5 89.3,27.6 90.81,27.6 90.91,27.7 90.91,27.84 90.81,27.94 89.3,27.94 89.2,28.04 89.2,28.18 89.3,28.29 90.81,28.29 90.91,28.39 90.91,28.53 90.81,28.63 89.3,28.63 89.2,28.73 89.2,28.87 89.3,28.97 90.81,28.97 90.91,29.07 90.91,29.21 90.81,29.31 89.3,29.31 89.2,29.41 89.2,29.56 89.3,29.66 90.81,29.66 90.91,29.76 90.91,29.9 90.81,30 89.34,30 89.24,30.1 89.24,30.24 89.34,30.34 90.81,30.34 90.91,30.44 90.91,30.59 90.81,30.69 89.34,30.69 89.24,30.79 89.24,30.93 89.34,31.03 90.36,31.03 90.46,31.13 90.46,31.27 90.36,31.37 89.7,31.37 89.56,31.51 89.56,32.54 91.28,34.27 91.28,36.12 91.99,36.82 91.99,37.79 92.39,38.19 92.58,38.19 92.71,38.06 92.71,37.9 92.81,37.8 92.95,37.8 93.05,37.9 93.05,38.85 95,40.8 95,41.39 94.62,41.77 94.62,42.08 94.76,42.23 94.76,42.63 94.62,42.77 94.62,43.08 94.97,43.43 95.18,43.43 95.67,43.92 96.04,43.92 96.55,44.43 v1(97.59,44.43)
DDR4_DIMM_CH3_A11: length 87.6
  L07_SIG3 w0.089: v1(97.59,45.43) 97.59,45.76 97.05,46.31 96.41,46.31 96.03,45.93 95.63,45.93 95.13,45.43 94.73,45.43 94.24,44.94 94.03,44.94 93.7,44.62 93.7,40.47 91.3,38.07 91.3,37.11 90.44,36.24 90.44,34.73 87.88,32.17 87.88,24.59 88.41,24.06 89.01,24.06 91.91,21.17 95.83,21.17 96.46,20.54 102.53,20.54 103.13,19.94 107.94,19.94 108.68,19.2 109.88,19.2 110.09,18.99 110.48,18.99 111.06,18.41 112.52,18.41 113.54,17.39 127.39,17.39 129.58,19.58 131.11,19.58 132.23,18.46 132.23,17.93 132.47,17.69 136.48,17.69 137.15,18.36 137.15,19.23 137.34,19.42 138.61,19.42 139.02,19.83 139.17,19.83 139.28,19.71 139.28,19.56 138.73,19.01 137.81,19.01 v1(137.59,18.8)
DDR4_DIMM_CH3_A12: length 82.5
  L05_SIG2 w0.081: v1(95,42.93) 95.28,42.64 95.28,42.19 95.4,42.07 95.4,41.79 95.16,41.55 95.16,38.45 95.43,38.18 95.43,34.5 96.4,33.53 96.4,30.76 97.22,29.95 97.22,26.18 98.08,25.32 98.08,18.64 98.32,18.39 98.77,18.21 100.28,16.69 107.21,16.69 109.16,18.65 109.16,20.03 109.68,20.55 109.68,22.72 110.33,23.37 112.65,23.37 114.21,24.93 114.21,25.07 114.11,25.17 113.29,25.17 113.19,25.28 113.19,25.41 113.29,25.51 114.21,25.51 114.31,25.61 114.31,25.74 114.21,25.84 113.24,25.84 113.13,25.95 113.13,26.08 113.24,26.18 114.22,26.18 114.32,26.28 114.32,26.41 114.22,26.52 113.32,26.52 113.22,26.62 113.22,26.75 113.32,26.85 119.84,26.85 120.11,26.57 120.11,26.25 120.35,26.01 121.11,26.01 121.59,25.53 124.58,25.53 126.79,23.32 136.97,23.32 v1(138.44,24.79)
DDR4_DIMM_CH3_A13: length 79.6
  L05_SIG2 w0.081: v1(94.13,41.43) 93.59,40.89 93.31,40.89 92.79,40.37 92.79,33.86 93.78,32.87 93.78,27.7 94.93,26.55 95.08,26.55 95.18,26.45 95.18,26.31 95.08,26.21 94.77,26.21 94.68,26.11 94.68,25.98 94.77,25.88 95.08,25.88 95.18,25.78 95.18,25.64 95.08,25.54 94.77,25.54 94.68,25.44 94.68,23.75 94.77,23.66 94.94,23.66 95.04,23.75 95.04,24.3 95.14,24.4 95.28,24.4 95.38,24.3 95.38,23.75 95.48,23.66 96.32,23.66 96.42,23.56 96.42,23.42 96.32,23.32 94.77,23.32 94.68,23.22 94.68,23.08 94.77,22.99 96.32,22.99 96.42,22.89 96.42,22.75 96.32,22.65 94.77,22.65 94.68,22.55 94.68,22.41 94.77,22.32 96.32,22.32 96.42,22.22 96.42,22.08 96.32,21.98 94.77,21.98 94.68,21.88 94.68,21.74 94.77,21.64 96.32,21.64 96.42,21.55 96.42,21.41 96.32,21.31 94.77,21.31 94.68,21.21 94.68,21.07 94.77,20.97 96.32,20.97 96.42,20.88 96.42,20.74 96.32,20.64 94.77,20.64 94.68,20.54 94.68,20.4 94.77,20.3 96.82,20.3 96.92,20.21 96.92,20.07 96.82,19.97 95.55,19.97 95.45,19.87 95.45,19.73 95.55,19.63 95.9,19.63 96.01,19.53 96.01,19.4 95.9,19.3 95.71,19.3 95.57,19.15 95.57,18.53 96.01,18.09 97.27,17.57 98.15,17.2 99.76,15.59 108.61,15.59 111.64,18.62 111.64,18.95 111.88,19.19 112.39,19.19 112.51,19.07 112.51,17.41 112.61,17.3 112.88,17.3 112.98,17.41 112.98,19.31 113.08,19.41 113.25,19.41 113.35,19.31 113.35,17.42 113.45,17.31 113.61,17.31 113.72,17.42 113.72,17.88 114.24,18.4 114.24,20.44 114.14,20.54 113.89,20.54 113.79,20.44 v1(113.79,18.8)
DDR4_DIMM_CH3_A14: length 81.1
  L05_SIG2 w0.081: v1(94.13,42.43) 94.13,42.74 93.46,43.4 92.9,43.4 92.55,43.06 92.19,43.06 91.55,42.42 91.3,42.42 91.1,42.22 91.1,41.12 90.77,40.79 90.77,33.69 91.27,33.19 91.27,23.99 91.37,23.89 91.56,23.89 91.66,23.79 91.66,23.66 91.56,23.56 90.97,23.56 90.87,23.46 90.87,23.32 90.97,23.22 91.56,23.22 91.66,23.12 91.66,22.99 91.56,22.89 91.37,22.89 91.27,22.79 91.27,15.96 94.43,12.8 108.31,12.8 111.65,16.14 111.98,16.14 112.08,16.04 112.08,15.49 112.18,15.39 112.32,15.39 112.41,15.49 112.41,16.04 112.51,16.14 112.65,16.14 112.75,16.04 112.75,15.49 112.85,15.39 112.99,15.39 113.08,15.49 113.08,16.04 113.18,16.14 113.32,16.14 113.42,16.04 113.42,15.49 113.52,15.39 113.66,15.39 113.75,15.49 113.75,16.04 113.86,16.14 114,16.14 114.1,16.04 114.1,15.53 114.2,15.43 114.37,15.43 114.47,15.53 114.47,16.25 114.57,16.35 114.7,16.35 114.8,16.25 114.8,15.55 114.91,15.45 115.04,15.45 115.14,15.55 115.14,16.87 115.24,16.97 115.37,16.97 115.47,16.87 115.47,15.56 115.58,15.45 115.72,15.45 115.82,15.56 115.82,17.57 115.93,17.67 116.06,17.67 116.16,17.57 116.16,15.6 116.26,15.5 116.42,15.5 116.52,15.6 116.52,17.51 116.62,17.62 116.76,17.62 116.86,17.51 116.86,15.75 116.96,15.65 117.09,15.65 117.19,15.75 v1(117.19,18.8)
DDR4_DIMM_CH3_A15: length 79.7
  L05_SIG2 w0.081: v1(115.49,24.79) 115.49,25.5 115.59,25.61 115.87,25.61 115.97,25.5 115.97,24.63 116.07,24.53 116.27,24.53 116.37,24.63 116.37,25.13 116.47,25.23 116.69,25.23 116.79,25.13 116.79,23.83 116.67,23.7 115.93,23.7 115.74,23.51 115.74,22.49 115.05,21.8 115.05,17.92 114.04,16.92 111.11,16.92 108.27,14.08 107.95,14.08 107.87,14.16 107.87,14.74 107.77,14.84 107.63,14.84 107.53,14.74 107.53,13.6 107.43,13.5 107.29,13.5 107.2,13.6 107.2,14.78 107.1,14.88 106.96,14.88 106.86,14.78 106.86,13.57 106.76,13.47 106.62,13.47 106.52,13.57 106.52,14.78 106.43,14.88 106.29,14.88 106.19,14.78 106.19,13.57 106.09,13.47 105.95,13.47 105.85,13.57 105.85,14.78 105.76,14.88 105.62,14.88 105.52,14.78 105.52,13.57 105.42,13.47 105.28,13.47 105.18,13.57 105.18,14.78 105.09,14.88 104.95,14.88 104.85,14.78 104.85,13.57 104.75,13.47 104.61,13.47 104.51,13.57 104.51,14.78 104.41,14.88 104.28,14.88 104.18,14.78 104.18,13.57 104.08,13.47 94.98,13.47 93.66,14.79 93.66,17.91 92.97,18.6 92.97,30.51 92.65,30.82 92.65,31.96 92.96,32.26 92.96,32.7 91.61,34.05 91.61,40.46 92.02,40.88 92.02,41.58 92.37,41.93 v1(93.26,41.93)
DDR4_DIMM_CH3_A16: length 79.9
  L05_SIG2 w0.081: v1(118.89,24.8) 119.14,24.54 119.14,23.65 119.04,23.54 118.91,23.54 118.81,23.65 118.81,24.06 118.71,24.16 118.58,24.16 118.47,24.06 118.47,22.61 117.47,21.6 117.47,19.29 117.36,19.18 117.21,19.18 117.11,19.29 117.11,21.73 117.01,21.83 116.85,21.83 116.75,21.73 116.75,19.05 114.17,16.47 111.31,16.47 107.98,13.14 94.73,13.14 92.12,15.75 92.12,15.91 92.22,16 93.18,16 93.28,16.1 93.28,16.24 93.18,16.34 91.86,16.34 91.76,16.44 91.76,16.58 91.86,16.67 93.16,16.67 93.26,16.77 93.26,16.91 93.16,17.01 91.9,17.01 91.8,17.11 91.8,17.25 91.9,17.35 93.15,17.35 93.24,17.44 93.24,17.58 93.15,17.68 91.87,17.68 91.77,17.78 91.77,17.92 91.87,18.02 92.6,18.02 92.69,18.11 92.69,18.25 92.6,18.35 92.22,18.35 92.12,18.45 92.12,32.95 91.25,33.82 91.25,40.65 91.64,41.04 91.64,41.51 91.91,41.78 91.91,42.48 92.23,42.8 93.13,42.8 v1(93.26,42.93)
DDR4_DIMM_CH3_A17: length 79.2
  L05_SIG2 w0.081: v1(92.4,42.43) 93.46,42.43 93.7,42.19 93.7,41.82 92,40.13 92,34.17 93.29,32.88 93.29,32.03 93,31.74 93,31.11 93.34,30.77 93.34,27.25 93.82,26.77 93.82,24.46 94.21,24.06 94.21,23.75 94.11,23.65 93.44,23.65 93.34,23.55 93.34,23.41 93.44,23.32 94.11,23.32 94.21,23.22 94.21,23.08 94.11,22.98 93.44,22.98 93.34,22.88 93.34,22.74 93.44,22.64 94.11,22.64 94.21,22.55 94.21,19.7 94.82,19.1 94.82,18.68 94.08,17.95 94.08,14.97 95.23,13.82 97.63,13.82 97.74,13.94 97.74,14.37 97.84,14.47 97.98,14.47 98.08,14.37 98.08,13.94 98.18,13.84 98.32,13.84 98.42,13.94 98.42,16.03 98.51,16.13 98.65,16.13 98.75,16.03 98.75,13.94 98.85,13.84 98.99,13.84 99.09,13.94 99.09,15.38 99.18,15.48 99.32,15.48 99.42,15.38 99.42,13.94 99.52,13.84 99.66,13.84 99.76,13.94 99.76,15.13 99.85,15.23 99.99,15.23 100.09,15.13 100.09,13.94 100.19,13.84 100.33,13.84 100.43,13.94 100.43,15.13 100.53,15.23 100.66,15.23 100.76,15.13 100.76,13.94 100.86,13.84 101,13.84 101.1,13.94 101.1,15.13 101.2,15.23 101.33,15.23 101.43,15.13 101.43,13.94 101.53,13.84 101.67,13.84 101.77,13.94 101.77,15.14 101.87,15.23 102.01,15.23 102.1,15.14 102.1,13.97 102.2,13.87 102.34,13.87 102.44,13.97 102.44,15.11 102.54,15.2 102.68,15.2 102.77,15.11 102.77,13.98 102.87,13.89 103.01,13.89 103.11,13.98 103.11,15.12 103.21,15.21 103.35,15.21 103.44,15.12 103.44,14 103.54,13.91 103.68,13.91 103.78,14 103.78,15.08 103.93,15.23 108.89,15.23 110.99,17.33 111.63,17.33 112.09,17.79 v1(112.09,18.8)
DDR4_DIMM_CH3_ACT_N: length 86.3
  L07_SIG3 w0.089: v1(101.06,42.43) 101.48,42 101.67,41.54 102.25,40.96 102.25,39.11 102.35,39.01 102.73,39.01 102.83,38.91 102.83,38.77 102.73,38.67 102.35,38.67 102.25,38.57 102.25,38.43 102.35,38.32 102.73,38.32 102.83,38.22 102.83,38.08 102.73,37.98 102.35,37.98 102.25,37.88 102.25,33.89 103.12,33.02 103.12,32.33 103.42,32.02 103.82,32.02 104.72,31.13 105.62,31.13 106.18,31.68 106.42,31.68 106.83,32.09 107.15,32.09 107.56,31.68 107.84,31.68 108.71,30.81 109.53,30.81 109.78,30.56 110.75,30.56 111.34,29.97 112.2,29.97 112.87,29.3 116.49,29.3 117.07,28.72 117.07,27.07 118.13,26.01 130.14,26.01 131.17,24.98 131.17,22.47 131.26,22.38 131.43,22.38 131.52,22.47 131.52,23.3 131.6,23.39 131.77,23.39 131.86,23.3 131.86,22.38 131.95,22.29 132.11,22.29 132.2,22.38 132.2,23.2 132.29,23.29 132.46,23.29 132.54,23.2 132.54,22.44 132.63,22.35 132.8,22.35 132.89,22.44 132.89,23.18 132.98,23.27 133.14,23.27 133.23,23.18 133.23,22.44 133.32,22.35 133.48,22.35 133.57,22.44 133.57,23.08 133.66,23.17 133.83,23.17 133.92,23.08 133.92,22.5 134.03,22.39 134.59,22.39 134.74,22.54 134.74,22.96 134.85,23.07 136.26,23.07 136.35,22.98 136.35,22.82 136.26,22.73 135.23,22.73 135.14,22.64 135.14,22.45 135.23,22.36 137.06,22.36 137.16,22.46 137.16,22.94 137.26,23.04 138.79,23.04 138.89,22.94 138.89,22.8 138.79,22.7 137.71,22.7 137.61,22.6 137.61,22.46 137.71,22.36 139.53,22.36 139.67,22.5 139.67,23 139.76,23.09 139.92,23.09 140.01,23 140.01,22.54 140.1,22.45 140.27,22.45 140.35,22.54 140.35,23.92 140.44,24.01 140.61,24.01 140.7,23.92 140.7,22.59 140.79,22.5 140.95,22.5 141.04,22.59 141.04,24.31 141.13,24.4 141.35,24.4 141.44,24.31 141.44,22.67 141.69,22.41 142.88,22.41 142.97,22.5 142.97,22.67 142.88,22.76 142.39,22.76 142.3,22.85 142.3,23.01 142.39,23.1 142.88,23.1 142.97,23.19 142.97,23.34 142.86,23.44 142.33,23.44 142.22,23.55 142.22,24.56 141.99,24.79 v1(140.99,24.79)
DDR4_DIMM_CH3_ALERT_N: length 82.5
  L07_SIG3 w0.089: v1(139.29,18.8) 138.99,18.49 137.93,18.49 136.78,17.35 132.33,17.35 131.89,17.79 131.89,18.31 131.02,19.18 129.72,19.18 127.58,17.04 112.57,17.04 112.47,17.14 112.47,17.74 112.37,17.84 112.23,17.84 112.13,17.74 112.13,17.14 112.03,17.04 111.63,17.04 110.26,18.41 103.42,18.41 103.13,18.7 103.13,19.09 102.03,20.2 96.32,20.2 95.69,20.83 91.67,20.83 88.79,23.71 87.94,23.71 87.05,24.6 87.05,25.41 87.15,25.52 87.15,26.62 87.06,26.71 87.06,32.67 87.51,33.11 88.34,33.11 90.09,34.87 90.09,36.38 90.96,37.25 90.96,38.22 92.84,40.1 92.84,43.98 v1(92.4,44.43)
DDR4_DIMM_CH3_BA0: length 79.5
  L05_SIG2 w0.081: v1(91.53,42.93) 91.53,42.93 90.52,42.93 90.2,42.62 90.2,33.33 90.44,33.09 90.44,16.25 94.11,12.58 94.11,12.37 94.49,11.99 108.08,11.99 111.11,15.02 117,15.02 117.62,15.63 117.62,17.38 118.06,17.83 118.06,21.71 118.17,21.81 118.41,21.81 118.51,21.71 118.51,21.32 118.61,21.22 118.77,21.22 118.88,21.32 118.88,23.03 118.98,23.14 119.2,23.14 119.31,23.03 119.31,20.37 119.44,20.24 120.64,20.24 120.75,20.34 120.75,20.49 120.64,20.59 120.14,20.59 120.04,20.69 120.04,20.9 120.14,21 120.87,21 120.98,21.11 120.98,21.82 120.87,21.92 119.84,21.92 119.74,22.02 v1(119.74,24.8)
DDR4_DIMM_CH3_BA1: length 76.8
  L05_SIG2 w0.081: v1(120.5,18.8) 120.32,18.8 119.73,18.2 119.73,16.43 119.63,16.33 119.35,16.33 119.25,16.43 119.25,19.29 119.15,19.39 118.93,19.39 118.82,19.29 118.82,15.67 118.72,15.57 118.56,15.57 118.46,15.67 118.46,17.22 118.35,17.32 118.16,17.32 118.06,17.22 118.06,15.35 117.32,14.6 111.39,14.6 107.79,11 98.34,11 97.7,11.64 95.63,11.64 95,11 93.52,11 93.06,11.47 93.06,13.04 89.54,16.56 89.54,19.02 90.03,19.51 90.03,24.05 89.54,24.54 89.54,41.47 89.39,41.62 89.39,43.52 v1(89.8,43.93)
DDR4_DIMM_CH3_BG0: length 78.6
  L07_SIG3 w0.089: v1(89.8,44.93) 90.94,44.93 91.38,45.37 91.79,45.37 92.22,44.94 92.68,44.94 93.18,45.43 93.48,45.43 93.94,45.9 94.3,45.9 94.89,46.49 95.29,46.49 95.8,47 96.15,47 96.58,47.43 96.85,47.43 97.36,47.93 97.78,47.93 98.26,48.41 98.66,48.41 99.13,47.93 99.57,47.93 100.03,48.4 100.37,48.4 100.85,47.92 101.18,47.92 101.66,48.39 102.12,48.39 102.58,47.93 102.98,47.93 103.48,48.43 103.87,48.43 104.3,48 104.76,48 105.15,48.38 105.65,48.38 106.09,47.94 106.39,47.94 106.64,47.69 106.64,39.74 107.6,38.78 107.6,38.2 107.84,37.97 108.08,37.97 108.38,37.66 108.38,37.19 108.48,37.09 108.62,37.09 108.72,37.19 108.72,37.4 108.82,37.51 108.96,37.51 109.07,37.4 109.07,37.22 111.16,35.13 111.36,35.13 112.86,33.63 124.27,33.63 128.38,29.52 133.07,29.52 133.61,28.98 135.07,28.98 135.49,28.56 135.49,28.24 135.74,27.98 137.34,27.98 138.29,27.04 138.64,27.04 138.95,27.35 139.11,27.35 139.21,27.45 139.21,27.8 139.31,27.9 139.46,27.9 139.56,27.8 139.56,27.54 139.66,27.44 139.8,27.44 139.9,27.54 139.9,27.77 140,27.87 140.14,27.87 140.24,27.77 140.24,27.16 140.36,27.04 141.47,27.04 141.57,26.94 141.57,26.77 141.48,26.68 140.63,26.68 140.54,26.6 140.54,26.43 140.63,26.34 142.13,26.34 142.22,26.25 142.22,26.07 142.13,25.98 141.64,25.98 141.44,25.78 141.09,25.78 140.89,25.98 140.43,25.98 140.14,25.7 v1(140.14,24.8)
DDR4_DIMM_CH3_BG1: length 85.5
  L14_SIG5 w0.081: v1(101.92,41.93) 100.88,41.93 100.64,41.68 100.64,32.66 101.34,31.96 101.34,31.54 100.98,31.18 100.98,26.94 100.6,26.56 100.6,16.64 100.7,16.54 100.83,16.54 100.93,16.64 100.93,18.23 101.04,18.33 101.17,18.33 101.27,18.23 101.27,16.62 101.38,16.52 101.51,16.52 101.61,16.62 101.61,17.9 101.71,18 101.84,18 101.94,17.9 101.94,16.65 102.05,16.55 102.18,16.55 102.28,16.65 102.28,17.84 102.38,17.94 102.51,17.94 102.62,17.84 102.62,16.63 102.72,16.53 102.85,16.53 102.95,16.63 102.95,18.08 103.05,18.18 103.18,18.18 103.29,18.08 103.29,16.64 103.39,16.54 103.52,16.54 103.62,16.64 103.62,17.87 103.72,17.97 103.85,17.97 103.96,17.87 103.96,16.64 104.06,16.54 104.19,16.54 104.29,16.64 104.29,17.25 104.39,17.35 104.53,17.35 104.63,17.25 104.63,16.57 104.78,16.42 108.6,16.42 109,16.02 111.91,16.02 113.1,14.83 121.61,14.83 122.19,15.41 131.91,15.41 134.15,17.66 139.93,17.66 140.45,18.17 140.45,18.49 v1(140.14,18.8)
DDR4_DIMM_CH3_C2: length 84.6
  L05_SIG2 w0.081: v1(111.24,18.8) 109.77,17.33 109.63,17.33 109.37,17.59 109.23,17.59 109.13,17.49 109.13,17.35 109.4,17.09 109.4,16.95 109.3,16.85 109.16,16.85 108.89,17.12 108.75,17.12 108.66,17.02 108.66,16.88 108.92,16.61 108.92,16.48 108.43,15.98 99.98,15.98 98.47,17.49 96.61,18.26 96.36,18.62 96.36,18.95 97.3,19.88 97.3,20.63 97.2,20.73 96.91,20.73 96.82,20.83 96.82,20.97 96.91,21.07 97.2,21.07 97.3,21.16 97.3,21.33 97.2,21.43 96.97,21.43 96.87,21.53 96.87,21.67 96.97,21.76 97.2,21.76 97.3,21.86 97.3,22 97.2,22.1 96.97,22.1 96.87,22.2 96.87,22.34 96.97,22.43 97.2,22.43 97.3,22.53 97.3,22.67 97.2,22.77 96.97,22.77 96.87,22.87 96.87,23.01 96.97,23.1 97.2,23.1 97.3,23.2 97.3,23.74 96.36,24.67 96.36,25.9 96.26,26 96.04,26 95.94,25.9 95.94,24.72 95.83,24.62 95.63,24.62 95.53,24.72 95.53,26.99 95.63,27.09 95.95,27.09 96.04,27.19 96.04,27.33 95.95,27.43 94.59,27.43 94.49,27.53 94.49,27.66 94.59,27.76 95.92,27.76 96.02,27.86 96.02,28 95.92,28.1 94.24,28.1 94.14,28.2 94.14,28.33 94.24,28.43 95.91,28.43 96.01,28.53 96.01,28.67 95.91,28.77 95.52,28.77 95.42,28.87 95.42,29.01 95.52,29.1 95.91,29.1 96.01,29.2 96.01,29.34 95.91,29.44 94.71,29.44 94.57,29.3 94.57,28.93 94.47,28.82 94.24,28.82 94.14,28.93 94.14,30.32 94.35,30.52 95.23,30.52 95.33,30.63 95.33,30.76 95.23,30.86 94.24,30.86 94.14,30.96 94.14,31.09 94.24,31.2 95.05,31.2 95.15,31.3 95.15,31.43 95.05,31.53 94.28,31.53 94.18,31.63 94.18,31.76 94.28,31.87 95.11,31.87 95.48,32.23 95.48,33.05 95.26,33.27 93.89,33.27 93.79,33.37 93.79,33.5 93.89,33.6 94.93,33.6 95.03,33.7 95.03,33.84 94.93,33.94 93.34,33.94 93.23,34.04 93.23,34.17 93.34,34.27 94.26,34.27 94.36,34.37 94.36,34.51 94.26,34.61 93.3,34.61 93.2,34.71 93.2,34.84 93.3,34.94 93.66,34.94 93.76,35.04 93.76,35.18 93.66,35.28 93.23,35.28 93.13,35.38 93.13,35.51 93.23,35.61 93.71,35.61 93.81,35.71 93.81,35.85 93.71,35.95 93.23,35.95 93.13,36.05 93.13,36.19 93.23,36.28 93.65,36.28 93.75,36.38 93.75,36.52 93.65,36.62 93.23,36.62 93.13,36.72 93.13,36.86 93.23,36.95 93.68,36.95 93.78,37.05 93.78,37.19 93.68,37.29 93.23,37.29 93.13,37.39 93.13,37.53 93.23,37.62 93.72,37.62 93.82,37.72 93.82,37.86 93.72,37.96 93.23,37.96 93.13,38.06 93.13,38.2 93.23,38.3 93.64,38.3 93.74,38.39 93.74,38.53 93.64,38.63 93.23,38.63 93.13,38.73 93.13,38.87 93.23,38.97 94.19,38.97 94.29,39.06 94.29,39.2 94.19,39.3 93.23,39.3 93.13,39.4 93.13,39.54 93.23,39.64 94.24,39.64 94.34,39.73 94.34,39.87 94.24,39.97 93.23,39.97 93.13,40.07 93.13,40.21 93.23,40.31 93.93,40.31 94.03,40.41 94.03,40.75 94.5,41.22 94.5,41.58 94.39,41.69 94.39,42.16 94.5,42.27 94.5,42.58 94.39,42.69 94.39,43.17 94.51,43.28 94.51,43.44 v1(95,43.93)
DDR4_DIMM_CH3_CK_N0: length 84.7
  L07_SIG3 w0.085: v1(129.94,24.8) 130.24,24.8 130.34,24.69 130.34,22.55 130.18,22.39 129.76,22.39 129.67,22.47 129.67,24.15 129.31,24.51 129.07,24.51 128.97,24.61 128.97,25.15 128.72,25.39 127.89,25.39 127.63,25.13 127.63,23.54 128.05,23.12 128.52,23.12 128.61,23.03 128.61,22.47 128.52,22.38 127.61,22.38 127.28,22.72 126.85,23.75 126.85,25.1 126.63,25.32 126.01,25.32 125.79,25.1 125.79,23.45 126.39,21.98 126.39,21.58 125.97,21.15 125.65,21.15 125.44,21.36 125.44,22.55 125.19,23.16 125.19,25.14 124.96,25.36 124.05,25.36 123.83,25.14 123.83,23.95 123.74,23.86 123.09,23.86 123,23.95 123,25.08 122.67,25.41 122.02,25.41 121.76,25.14 121.76,24.25 121.89,24.11 121.89,23.56 121.73,23.4 121.4,23.4 121.29,23.51 121.01,23.51 120.89,23.4 115.47,23.4 114.26,24.61 114.26,25.33 113.31,26.28 112.21,26.28 111.47,27.03 106.69,27.03 106.5,26.84 105.74,26.84 105.52,27.05 105.21,27.05 105.07,27.19 105.07,27.5 104.7,27.87 103.78,27.87 103.43,27.52 103.43,27.14 103.29,27 102.97,27 102.84,27.14 102.84,27.52 102.52,27.83 102.1,27.83 101.79,27.52 101.79,27.12 101.66,27 101.32,27 101.19,27.12 101.19,27.6 100.92,27.87 100.41,27.87 100.14,27.6 100.14,27.15 100.01,27.03 99.68,27.03 99.55,27.15 99.55,27.49 99.23,27.81 98.81,27.81 98.5,27.49 98.5,27.16 98.37,27.03 98.03,27.03 97.91,27.16 97.91,27.58 97.64,27.84 96.13,27.84 95.61,28.36 95.61,30.59 95.43,30.77 95.43,31.64 95.81,32.02 95.81,33.3 97.22,34.7 97.22,35.63 97.42,35.83 97.83,35.83 98.92,36.92 98.92,38.17 99.96,39.2 99.96,41.53 99.87,41.73 99.66,41.94 99.41,42.04 99.24,42.04 99.12,42.1 99.01,42.21 98.94,42.36 98.78,42.52 98.56,42.52 98.46,42.63 v1(98.46,42.93)
DDR4_DIMM_CH3_CK_N1: length 81.2
  L07_SIG3 w0.081: 129.18,16.36 101.82,16.36 99.81,18.37 94.54,18.37 94.12,17.94 88.47,17.94 86.17,20.25 86.17,20.7 86.41,20.95 88.15,20.95 88.59,21.39 88.59,22.19 88.21,22.57 86.85,22.57 86.12,23.31 86.12,24.18 86.45,24.5 86.45,25.15 86.03,25.56 86.03,25.86 86.44,26.85 86.44,29.1 85.93,29.61 85.93,31.1 86.43,32.3 86.43,33.03 87.32,33.92 88.29,33.92 89.5,35.12 89.5,37.73 91.78,40.01 91.78,41.29 92,41.51 92,44.46 v1(91.53,44.93)
  L07_SIG3 w0.089: v1(129.94,18.8) 130.24,18.49 130.24,17.43 129.98,17.17 129.77,17.17 129.53,17.41 129.3,17.41 129.16,17.27 129.16,17.05 129.38,16.83 129.38,16.56 129.18,16.36
DDR4_DIMM_CH3_CK_P0: length 84.7
  L07_SIG3 w0.085: v1(98.46,41.93) 98.46,42.21 98.54,42.3 98.69,42.3 98.75,42.24 98.81,42.08 98.99,41.9 99.2,41.82 99.37,41.82 99.53,41.75 99.68,41.6 99.73,41.48 99.73,39.3 98.7,38.27 98.7,37.01 97.74,36.06 97.32,36.06 96.99,35.72 96.99,34.8 95.59,33.4 95.59,32.12 95.2,31.73 95.2,30.67 95.38,30.49 95.38,28.26 96.03,27.61 97.55,27.61 97.68,27.48 97.68,27.06 97.94,26.8 98.47,26.8 98.73,27.06 98.73,27.4 98.91,27.58 99.14,27.58 99.32,27.4 99.32,27.06 99.58,26.8 100.11,26.8 100.37,27.06 100.37,27.5 100.51,27.64 100.82,27.64 100.96,27.5 100.96,27.03 101.22,26.77 101.75,26.77 102.01,27.03 102.01,27.42 102.2,27.6 102.42,27.6 102.61,27.42 102.61,27.04 102.88,26.77 103.39,26.77 103.66,27.04 103.66,27.42 103.88,27.64 104.61,27.64 104.84,27.41 104.84,27.09 105.12,26.82 105.43,26.82 105.64,26.61 106.59,26.61 106.78,26.8 111.37,26.8 112.12,26.05 113.21,26.05 114.03,25.24 114.03,24.52 115.38,23.17 121.82,23.17 122.12,23.47 122.12,24.21 121.99,24.34 121.99,25.05 122.12,25.18 122.58,25.18 122.77,24.99 122.77,23.86 122.99,23.63 123.84,23.63 124.06,23.86 124.06,25.05 124.15,25.13 124.87,25.13 124.96,25.05 124.96,23.12 125.21,22.5 125.21,21.27 125.56,20.92 126.06,20.92 126.62,21.49 126.62,22.03 126.02,23.49 126.02,25 126.11,25.09 126.53,25.09 126.62,25 126.62,23.7 127.08,22.59 127.52,22.15 128.62,22.15 128.84,22.38 128.84,23.12 128.62,23.35 128.15,23.35 127.86,23.63 127.86,25.04 127.99,25.16 128.62,25.16 128.74,25.05 128.74,24.52 128.97,24.28 129.22,24.28 129.44,24.06 129.44,22.38 129.67,22.16 130.27,22.16 130.57,22.46 130.57,24.57 v1(130.79,24.8)
DDR4_DIMM_CH3_CK_P1: length 80.9
  L07_SIG3 w0.081: v1(130.79,18.8) 130.57,18.57 130.57,17.29 129.34,16.07 101.65,16.07 99.68,18.04 94.67,18.04 94.25,17.62 88.34,17.62 85.84,20.11 85.84,20.84 86.28,21.27 88.02,21.27 88.26,21.52 88.26,22.06 88.07,22.25 86.72,22.25 85.8,23.17 85.8,24.31 86.12,24.64 86.12,25.01 85.71,25.43 85.71,25.93 86.12,26.91 86.12,28.97 85.61,29.48 85.61,31.16 86.11,32.37 86.11,33.17 87.18,34.24 88.16,34.24 89.17,35.26 89.17,37.86 91.46,40.15 91.46,41.23 90.87,41.81 90.87,42.07 91.09,42.28 91.09,42.62 90.87,42.84 90.87,43 91.09,43.22 91.09,43.83 91.19,43.93 v1(91.53,43.93)
DDR4_DIMM_CH3_CKE0: length 83.8
  L07_SIG3 w0.089: v1(142.69,24.8) J4.60 143.39,23.4 143.39,23.09 143.6,22.89 145.55,22.89 145.64,22.8 145.64,22.63 145.55,22.54 143.55,22.54 143.46,22.45 143.46,22.29 143.55,22.2 146.37,22.2 146.46,22.11 146.46,21.95 146.37,21.86 131.89,21.86 131.57,21.54 127.54,21.54 125.89,19.9 123.11,19.9 122.67,20.34 122.67,22.07 122.32,22.42 115.04,22.42 114.16,23.3 113.68,23.3 113.32,23.66 113.32,25 113.11,25.2 112.08,25.2 111.29,26 97.52,26 96.86,26.66 96.61,26.66 96.26,27.01 95.79,27.01 94.51,28.29 94.51,31.89 94.72,32.09 94.72,32.57 94.99,32.84 94.99,33.67 95.68,34.36 95.68,35.58 95.9,35.8 96.23,35.8 97.14,36.72 97.56,36.72 97.99,37.14 97.99,38.47 98.93,39.41 98.93,41.03 v1(99.32,41.43)
DDR4_DIMM_CH3_CKE1: length 84.5
  L07_SIG3 w0.089: v1(143.54,18.8) 143.54,21.21 143.24,21.51 132.03,21.51 131.71,21.2 127.71,21.2 126.04,19.54 122.99,19.54 121.87,20.65 121.87,21.75 121.61,22.02 112.92,22.02 111.77,23.17 111.3,23.17 110.96,22.83 109.78,22.83 109.43,23.17 109.12,23.17 108.81,22.86 108.25,22.86 107.82,22.42 103.56,22.42 103.39,22.6 97.32,22.6 96.69,23.23 93.64,23.23 92.94,23.93 92.94,26.64 93.35,27.05 93.35,30.79 93,31.14 93,31.96 93.18,32.15 93.18,32.86 93.96,33.64 93.96,34.09 94.65,34.79 94.65,36.05 95.79,37.18 95.79,38.6 96.26,39.07 96.26,39.54 96.67,39.94 96.96,39.94 97.11,40.1 97.11,40.63 96.88,40.86 96.88,41.32 97.07,41.78 97.35,42.05 97.75,42.05 97.92,42.22 97.97,42.35 97.97,42.49 97.87,42.74 97.87,43.17 98.24,43.54 98.68,43.54 99.17,43.05 99.51,43.05 99.76,43.3 100.38,43.3 100.57,43.11 100.57,42.84 100.52,42.72 100.22,42.43 v1(99.32,42.43)
DDR4_DIMM_CH3_CS_N0: length 85.4
  L07_SIG3 w0.089: v1(117.19,24.8) 117.53,24.46 117.8,24.46 117.89,24.37 117.89,24.18 117.8,24.09 116.92,24.09 116.61,24.4 116.61,24.99 116.51,25.1 116.34,25.1 116.23,24.99 116.23,24.57 116.13,24.47 115.99,24.47 115.89,24.57 115.89,26.36 116,26.47 116,26.71 115.6,27.11 115.41,27.11 115.12,26.81 114.96,26.81 114.75,27.03 113.97,27.03 113.11,27.89 112.78,27.89 112.57,27.67 112.25,27.67 111.62,28.29 109.3,28.29 109.07,28.53 109.07,28.87 108.92,29.02 108.36,29.02 108.23,28.89 108.23,28.32 108.13,28.22 105.7,28.22 105.6,28.32 105.6,28.46 105.7,28.56 107.79,28.56 107.89,28.66 107.89,28.81 107.79,28.91 102.91,28.91 102.83,28.99 102.83,29.16 102.91,29.25 105,29.25 105.09,29.34 105.09,29.51 105,29.6 102.57,29.6 102.47,29.5 102.47,29.01 102.37,28.91 99.91,28.91 99.81,29.01 99.81,29.16 99.91,29.26 102,29.26 102.1,29.36 102.1,29.5 102,29.6 99.94,29.6 99.85,29.69 99.85,29.85 99.94,29.94 101.92,29.94 102.01,30.03 102.01,30.21 101.92,30.3 99.95,30.3 99.86,30.39 99.86,30.55 99.95,30.64 101.86,30.64 101.95,30.73 101.95,30.9 101.86,30.98 99.79,30.98 99.7,31.07 99.7,31.24 99.79,31.33 100.02,31.33 100.17,31.48 100.17,31.84 100.27,31.94 100.44,31.94 100.55,31.84 100.55,31.49 100.71,31.33 101.94,31.33 102.03,31.42 102.03,31.58 101.94,31.67 101.56,31.67 101.47,31.76 101.47,32.33 101.35,32.46 101.12,32.46 100.87,32.2 100.7,32.2 100.59,32.31 100.59,32.71 100.68,32.8 101.89,32.8 101.99,32.9 101.99,33.04 101.89,33.14 99.99,33.14 99.84,32.99 99.84,32.64 99.74,32.54 99.54,32.54 99.44,32.64 99.44,33.03 99.33,33.14 99.03,33.14 98.93,33.24 98.93,33.38 99.03,33.48 101.44,33.48 101.54,33.58 101.54,33.73 101.44,33.83 99.48,33.83 99.38,33.93 99.38,34.07 99.48,34.17 100.58,34.17 100.68,34.27 100.68,34.41 100.58,34.51 99.62,34.51 99.52,34.61 99.52,34.76 99.62,34.86 101.45,34.86 101.55,34.96 101.55,35.1 101.45,35.2 99.67,35.2 99.57,35.3 99.57,35.44 99.67,35.54 101.44,35.54 101.55,35.65 101.55,35.81 101.45,35.91 101.1,35.91 101,36.01 101,36.15 101.1,36.25 101.45,36.25 101.55,36.35 101.55,36.49 101.45,36.6 101.1,36.6 101,36.7 101,36.84 101.1,36.94 101.37,36.94 101.47,37.04 101.47,37.55 101.23,37.79 101.23,38.07 101.47,38.3 101.47,38.55 101.19,38.83 101.19,39.03 101.47,39.31 101.47,39.58 101.22,39.83 101.22,40.06 101.47,40.31 101.47,40.61 101.2,40.88 101.2,41.28 v1(101.06,41.43)
