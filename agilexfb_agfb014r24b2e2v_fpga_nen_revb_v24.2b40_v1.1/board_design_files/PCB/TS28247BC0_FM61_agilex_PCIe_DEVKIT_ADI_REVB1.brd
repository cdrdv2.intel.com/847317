# Allegro board TS28247BC0_FM61_agilex_PCIe_DEVKIT_ADI_REVB1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
ENET_LED1: length 49.6
  L05_SIG2 w0.081: v1(32.39,87.47) 32.39,87.79 33.22,88.62 34.32,88.62 35.79,87.16 35.79,81.65 35.38,81.24 v1(35.38,80.6)
  L12_SIG4 w0.089: v1(32.39,87.47) 31.76,88.1 31.76,89.35 29.47,91.65 29.47,92.41 24.77,97.11 18.17,97.11 11.82,90.76 9.1,90.76 v1(5.31,86.97)
  BOTTOM w0.149: R138.2 v1(35.38,80.6) ; v1(32.39,87.47) 31.65,87.47 U7.17
ENET_LED2: length 40.6
  L12_SIG4 w0.089: v1(5.82,90.78) 6.18,91.14 11.56,91.14 17.91,97.49 25.09,97.49 29.98,92.6 30.68,92.6 31.5,91.77 31.5,90.63 32.39,89.74 v1(32.39,88.45) 32.88,88.45 34.93,90.5 v1(34.93,91.58)
  BOTTOM w0.149: v1(32.39,88.45) U7.15 ; v1(34.93,91.58) R136.2
ENET_MDC: length 79.5
  TOP w0.149: v1(24.61,82.37) R156.2
  L05_SIG2 w0.081: v1(91.53,79.93) 91.28,80.18 91.28,80.64 90.87,81.05 90.51,81.05 90.01,81.55 89.63,81.55 89.39,81.79 86.59,81.79 83.38,80.46 79.69,80.46 76.71,83.44 70.57,83.44 63.87,90.14 55.05,90.14 54.24,90.96 48.65,90.96 48.09,91.52 41.31,91.52 39.28,89.49 32.16,89.49 31.1,88.42 30.59,88.42 29.62,87.45 28.3,87.45 26.4,85.55 26.4,84.08 25,82.68 24.92,82.68 v1(24.61,82.37)
  BOTTOM w0.149: v1(24.61,82.37) 24.98,82.37 25.42,82.81 U7.36
ENET_MDIO: length 98.7
  L05_SIG2 w0.081: v1(23.88,82.76) 23.52,83.12 23.52,83.87 24.92,85.28 24.92,86.79 27.01,88.88 27.97,88.88 29.58,90.48 38.96,90.48 40.74,92.26 59.19,92.26 60.18,91.27 64.27,91.27 71.25,84.28 76.84,84.28 80.15,80.97 82.9,80.97 87.28,82.78 89.77,82.78 90.51,82.04 90.88,82.04 91.4,81.53 91.77,81.53 92.35,80.95 92.46,80.95 92.86,80.55 92.86,79.49 93.89,78.46 93.89,77.71 93.76,77.58 93.76,77.27 93.99,77.04 96,77.04 97.05,76 97.66,76 98.22,75.44 98.62,75.44 99.1,74.96 99.44,74.96 99.78,74.62 99.78,71.34 v1(100.19,70.93)
  BOTTOM w0.149: U7.37 24.7,83.57 v1(23.88,82.76) 23.88,82.36 24.59,81.65 R157.2
ENET_RSET: length 1.5
  TOP w0.149: R135.1 v1(24.01,89.23)
  BOTTOM w0.149: U7.48 24.23,89.45 v1(24.01,89.23)
ENET_RSTN: length 84.8
  L12_SIG4 w0.089: v1(31.63,21.22) 31.63,21.49 32.03,21.89 32.03,23.77 32.28,24.02 32.56,24.02 32.83,24.29 32.83,24.57 33.08,24.82 33.39,24.82 33.63,25.07 33.63,28.71 33.78,28.86 36.51,28.86 36.75,29.1 36.75,30.47 36.96,30.69 37.6,30.69 39.89,32.97 v1(39.89,37.92)
  L16_SIG6 w0.081: v1(22.74,81.61) 22.39,81.26 22.39,80.46 21.75,79.82 21.75,77.17 20.72,76.14 20.72,73.42 20.3,73 20.3,65.15 20.63,64.82 20.63,61.55 21.52,60.65 21.52,54.26 23.4,52.38 26.38,52.38 28.63,50.13 31.57,50.13 39.89,41.82 v1(39.89,37.92)
  BOTTOM w0.149: v1(22.74,81.61) 22.74,85.17 24.02,86.45 U7.42
ENET_RX_CLK: length 88.9
  TOP w0.149: R127.2 25.82,80.5 25.82,80.31 26.3,79.83 26.49,79.83 v1(26.5,79.83)
  L05_SIG2 w0.081: v1(92.4,72.43) 91.99,72.84 91.99,73 91.47,73.52 91.47,73.78 91.27,73.98 91.27,74.68 91.12,74.83 90.32,74.83 90.03,74.55 89.64,74.55 89.49,74.7 89.08,74.7 88.24,75.55 86.3,75.55 86.08,75.34 83.65,75.34 83.52,75.21 79.05,75.21 78.61,75.66 77.56,75.66 76.13,77.09 75.9,77.09 75.06,77.93 74.92,77.93 74.51,77.52 74.25,77.52 74.15,77.63 74.15,77.88 74.05,77.99 73.44,77.99 73.31,77.86 73.31,77.63 73.21,77.52 72.95,77.52 72.85,77.63 72.85,77.86 72.72,77.99 72.25,77.99 72.15,77.88 72.15,77.65 72.04,77.55 71.86,77.55 71.76,77.65 71.76,77.86 71.64,77.98 65.56,77.98 65.31,77.73 64.5,77.73 63.81,78.41 53.63,78.41 52.95,77.72 47.05,77.72 46.03,76.71 41.51,76.71 41.26,76.46 39.97,76.46 38.04,74.53 35.96,74.53 34.62,75.87 34.62,76.55 34.52,76.66 34.26,76.66 34.16,76.55 34.16,75.67 34.06,75.56 33.88,75.56 33.78,75.67 33.78,76.53 33.67,76.65 33.51,76.65 33.39,76.53 33.39,75.64 33.28,75.53 33.12,75.53 33.01,75.64 33.01,76.53 32.89,76.65 32.73,76.65 32.62,76.53 32.62,75.65 32.51,75.53 32.35,75.53 32.23,75.65 32.23,76.53 32.12,76.65 31.96,76.65 31.85,76.53 31.85,76.21 31.73,76.1 31.57,76.1 31.46,76.21 31.46,76.53 31.35,76.65 31.19,76.65 31.08,76.53 31.08,76.21 30.96,76.1 30.67,76.1 30.25,75.68 28.44,75.68 26.8,77.32 26.8,77.84 26.69,77.96 25.64,77.96 25.37,78.22 25.37,78.37 25.57,78.57 25.79,78.57 25.99,78.37 26.64,78.37 26.8,78.53 26.8,79.52 v1(26.5,79.83)
ENET_RX_DV: length 81.9
  L05_SIG2 w0.081: v1(89.8,74.93) 89.39,74.93 88.02,76.31 85.46,76.31 84.81,75.66 83.49,75.66 83.37,75.54 79.2,75.54 78.76,75.98 77.72,75.98 76.29,77.41 76.04,77.41 74.65,78.81 65.61,78.81 65.47,78.95 65.47,79.25 65.37,79.35 65.19,79.35 65.09,79.25 65.09,78.17 64.97,78.06 64.62,78.06 64.52,78.16 64.52,78.64 64.37,78.79 57.6,78.79 57.49,78.91 57.49,79.26 57.38,79.38 57.22,79.38 57.1,79.26 57.1,78.91 56.99,78.79 56.83,78.79 56.72,78.91 56.72,79.26 56.6,79.38 56.44,79.38 56.33,79.26 56.33,78.91 56.22,78.79 56.06,78.79 55.94,78.91 55.94,79.26 55.83,79.38 55.67,79.38 55.56,79.26 55.56,78.91 55.44,78.79 55.29,78.79 55.17,78.91 55.17,79.26 55.06,79.38 54.9,79.38 54.79,79.26 54.79,78.91 54.67,78.79 54.51,78.79 54.4,78.91 54.4,79.26 54.28,79.39 54.12,79.39 54.01,79.28 54.01,78.91 53.9,78.79 53.39,78.79 52.7,78.11 46.92,78.11 45.85,77.04 42.45,77.04 40.63,78.86 39.21,78.86 39.1,78.74 39.1,78.25 38.98,78.13 38.82,78.13 38.71,78.25 38.71,78.74 38.6,78.86 38.44,78.86 38.32,78.74 38.32,78.37 38.21,78.26 38.05,78.26 37.94,78.37 37.94,78.74 37.82,78.86 36.57,78.86 34.75,77.04 31.12,77.04 30.17,76.09 28.65,76.09 27.32,77.43 27.32,79.55 26.65,80.22 25.88,80.22 v1(25.5,79.85)
  BOTTOM w0.149: v1(25.5,79.85) R129.2
ENET_RXD0: length 90.2
  TOP w0.149: R130.2 v1(29.95,79.85)
  L05_SIG2 w0.081: v1(95,69.93) 95,70.39 94.62,70.76 94.62,71.62 94.5,71.75 94.5,72.58 94.28,72.8 94.23,72.8 93.98,73.06 93.49,73.54 93.12,73.54 92.89,73.77 92.89,74.08 93.07,74.26 93.07,74.54 92.58,75.04 92.13,75.04 90.75,76.42 89.75,76.42 89.38,76.79 89.38,77.16 87.98,78.56 85.4,78.56 84.56,78.21 83.66,77.31 80.22,77.31 80.12,77.41 79.41,77.41 75.97,80.85 68.23,80.85 67.98,81.1 54.9,81.1 54.79,81.22 54.79,81.91 54.68,82.02 54.52,82.02 54.4,81.91 54.4,81.22 54.29,81.1 54.13,81.1 54.02,81.22 54.02,81.91 53.9,82.02 53.74,82.02 53.63,81.91 53.63,81.22 53.52,81.1 53.28,81.1 52.74,81.64 52.16,81.64 51.69,82.12 48.59,82.12 47.58,81.1 47.58,80.92 45.02,78.36 43.11,78.36 41.27,80.2 40.73,80.2 40.62,80.31 40.62,81.16 40.51,81.28 40.35,81.28 40.23,81.16 40.23,80.31 40.12,80.2 39.96,80.2 39.85,80.31 39.85,81.07 39.73,81.18 39.57,81.18 39.46,81.07 39.46,80.31 39.35,80.2 39.19,80.2 39.08,80.31 39.08,81.83 38.96,81.94 38.8,81.94 38.69,81.83 38.69,80.31 38.58,80.2 38.42,80.2 38.3,80.31 38.3,81.32 38.19,81.43 38.03,81.43 37.92,81.32 37.92,80.31 37.8,80.2 36.04,80.2 34.21,78.36 31.68,78.36 30.2,79.85 v1(29.95,79.85)
ENET_RXD1: length 79.3
  L05_SIG2 w0.081: v1(89.8,76.93) 89.8,77.36 88.14,79.02 85.37,79.02 83.97,78.44 78.84,78.44 76.04,81.24 68.83,81.24 68.33,81.74 57.77,81.74 56.82,82.69 55.85,82.69 55.71,82.55 55.71,81.55 55.6,81.44 55.44,81.44 55.33,81.55 55.33,82.58 55.23,82.69 47.82,82.69 46.11,80.98 46.11,80.6 45.02,79.51 45.02,79 44.71,78.69 43.29,78.69 42.61,79.37 42.61,80.03 41.1,81.54 41.1,81.7 42.33,82.94 42.33,83.1 42.22,83.21 42.06,83.21 40.61,81.76 40.45,81.76 40.34,81.87 40.34,82.03 41.53,83.23 41.53,83.39 41.42,83.51 41.26,83.51 40.42,82.66 37.32,82.66 36.41,81.75 36.41,81.06 34.04,78.69 31.93,78.69 v1(30.74,79.88)
  BOTTOM w0.149: v1(30.74,79.88) 30.7,79.88 29.95,80.63 R131.2
ENET_RXD2: length 79.1
  L05_SIG2 w0.081: v1(24.33,79.07) 24.33,79.22 26.15,81.05 26.63,81.05 26.85,80.82 26.85,80.5 28.66,78.69 29.9,78.69 30.77,77.83 30.77,77.8 31.2,77.37 34.62,77.37 36.44,79.19 40.79,79.19 42.6,77.38 45.68,77.38 46.81,78.5 51.83,78.5 53.04,79.71 67.52,79.71 68.1,79.13 75.03,79.13 77.86,76.31 78.92,76.31 79.36,75.87 83.22,75.87 83.33,75.99 84.68,75.99 85.33,76.63 88.17,76.63 89.48,75.33 90.05,75.33 90.34,75.04 91.2,75.04 91.55,74.69 91.55,74.15 91.68,74.01 91.68,73.61 92.31,72.98 92.39,72.98 93,72.36 93,72.19 v1(93.26,71.93)
  BOTTOM w0.149: R132.2 v1(24.33,79.07)
ENET_RXD3: length 85.2
  L05_SIG2 w0.081: v1(90.67,74.43) 90.54,74.3 88.7,74.3 88.41,74.59 85.51,74.59 85.33,74.78 84.39,74.78 84.04,74.43 79.66,74.43 79.22,74.87 78.89,74.87 78.42,75.33 77.43,75.33 76,76.76 75.77,76.76 75.33,77.2 63.81,77.2 62.97,78.03 53.9,78.03 53.25,77.39 47.21,77.39 46.21,76.38 44.15,76.38 43.88,76.11 40.14,76.11 38.23,74.2 35.77,74.2 34.76,75.2 32.02,75.2 31.45,75.77 30.83,75.77 30.37,75.31 28.3,75.31 26.25,77.36 24.83,77.36 23.73,78.46 23.73,79.1 26.07,81.44 29.87,81.44 30.18,81.74 31.76,81.74 32.61,80.88 v1(32.61,79.96)
  BOTTOM w0.149: R133.2 v1(32.61,79.96)
ENET_TX_EN: length 88.7
  L05_SIG2 w0.081: v1(30.92,82.37) 30.25,82.37 29.84,81.96 26.51,81.96 26.34,81.79 25.94,81.79 25.2,81.05 24.44,81.05 24.21,80.83 24.21,80.14 23.38,79.31 23.38,78.31 24.66,77.03 25.93,77.03 27.16,75.8 27.16,75.21 27.41,74.96 30.53,74.96 30.99,75.42 31.32,75.42 31.87,74.87 34.6,74.87 35.6,73.87 38.41,73.87 40.32,75.78 44.39,75.78 44.68,75.49 45.99,75.49 47.41,76.91 53.48,76.91 54.19,77.62 62.9,77.62 63.65,76.87 71.09,76.87 71.35,76.61 71.35,76.13 71.48,76 71.69,76 71.81,76.13 71.81,76.61 71.94,76.74 72.34,76.74 72.47,76.61 72.47,76.02 72.59,75.9 72.8,75.9 72.93,76.02 72.93,76.61 73.11,76.79 73.63,76.79 73.81,76.61 73.81,76.05 73.93,75.92 74.14,75.92 74.27,76.05 74.27,76.7 74.37,76.81 74.66,76.81 74.81,76.66 74.81,76.13 74.93,76 75.14,76 75.27,76.13 75.27,76.51 75.37,76.61 75.46,76.61 75.63,76.44 75.84,76.44 77.3,74.98 78.24,74.98 78.68,74.54 79.09,74.54 79.6,74.04 84.35,74.04 84.59,74.27 88.27,74.27 88.66,73.88 89.75,73.88 v1(89.8,73.93)
  BOTTOM w0.149: v1(30.92,82.37) U7.25
ENET_TXD0: length 95.5
  L05_SIG2 w0.081: v1(33.54,87.45) 34.64,86.35 34.64,85.47 34.06,84.89 34.06,83.12 33.95,83.01 33.41,83.01 33.3,82.9 33.3,82.74 33.41,82.62 33.95,82.62 34.06,82.51 34.06,82.35 33.95,82.24 33.41,82.24 33.3,82.12 33.3,81.96 33.41,81.85 33.95,81.85 34.06,81.74 34.06,80.61 32.96,79.51 32.5,79.51 32.15,79.86 32.15,80.88 31.91,81.12 30.14,81.12 29.21,80.19 29.21,79.36 29.55,79.02 30.03,79.02 31.35,77.7 34.49,77.7 36.3,79.52 41,79.52 42.82,77.7 45.5,77.7 47.12,79.33 48.13,79.33 48.42,79.61 52.08,79.61 52.64,80.16 74.79,80.16 75.14,79.81 75.14,79.48 75.82,78.81 76.61,78.81 76.83,78.59 76.83,77.79 77.99,76.63 79.13,76.63 79.56,76.2 83.07,76.2 83.37,76.51 84.74,76.51 85.66,77.43 87.91,77.43 89.36,75.98 89.36,75.84 89.65,75.56 90.05,75.56 90.45,75.95 90.88,75.95 92.01,74.82 92.01,74.15 92.29,73.87 92.48,73.87 93.02,73.34 93.38,73.34 93.63,73.08 93.63,71.76 93.26,71.39 v1(93.26,70.93)
  BOTTOM w0.149: v1(33.54,87.45) 33.15,87.45 32.15,86.45 U7.19
ENET_TXD1: length 89.3
  L05_SIG2 w0.081: v1(89.8,75.93) 89.8,76.02 87.87,77.95 86.5,77.95 86.22,78.23 85.63,78.23 85.4,78 85.4,77.68 84.64,76.91 83.23,76.91 82.85,76.53 79.77,76.53 77.17,79.13 76.6,79.13 76.13,79.6 76.13,79.8 75.41,80.52 68.08,80.52 67.99,80.61 53.2,80.61 52.66,81.15 49.08,81.15 47.67,79.74 46.9,79.74 45.19,78.03 42.96,78.03 41.15,79.84 36.16,79.84 34.35,78.03 31.53,78.03 30.21,79.35 29.73,79.35 29.54,79.54 29.54,80.02 29.8,80.28 31.13,80.28 32.39,79.02 33.48,79.02 34.89,80.43 34.89,81.1 34.55,81.44 34.55,84.51 34.99,84.96 34.99,87.09 33.97,88.12 33.43,88.12 33.08,87.76 33.08,86.97 33.34,86.71 33.34,86.19 32.96,85.8 v1(30.87,85.8)
  BOTTOM w0.149: v1(30.87,85.8) 31.02,85.95 U7.20
ENET_TXD2: length 99.9
  L05_SIG2 w0.081: v1(32.77,86.44) 32.24,86.44 31.88,86.8 31.88,88.62 32.27,89 34.97,89 37.92,86.06 38.23,86.06 38.34,86.17 38.34,88.12 38.46,88.23 38.62,88.23 38.73,88.12 38.73,86.17 38.84,86.06 39,86.06 39.11,86.17 39.11,88.12 39.23,88.23 39.39,88.23 39.5,88.12 39.5,86.17 39.61,86.06 39.77,86.06 39.89,86.17 39.89,88.12 40,88.23 40.16,88.23 40.27,88.12 40.27,86.17 40.39,86.06 40.55,86.06 40.66,86.17 40.66,88.74 40.77,88.85 40.93,88.85 41.05,88.74 41.05,86.17 41.16,86.06 52.2,86.06 53.09,86.95 65.16,86.95 69.83,82.27 76.39,82.27 79.24,79.42 83.57,79.42 85.71,80.3 89.96,80.3 90.2,80.06 90.2,79.58 90.6,79.18 90.6,78.82 91.1,78.32 91.66,78.32 92.01,77.98 92.01,77.18 92.27,76.91 92.67,76.91 93.51,76.07 94.15,76.07 94.54,75.67 94.54,74.73 94.8,74.48 95.19,74.48 95.41,74.25 95.41,71.17 95.64,70.94 95.97,70.94 96.35,70.56 96.35,70.31 v1(96.73,69.93)
  BOTTOM w0.149: U7.21 32.17,85.45 32.39,85.68 32.39,86.06 v1(32.77,86.44)
ENET_TXD3: length 90
  L05_SIG2 w0.081: v1(90.67,73.43) 90.54,73.31 89.6,73.31 89.09,72.79 86.2,72.79 85.92,72.52 84.49,72.52 83.65,73.36 79.36,73.36 78.82,73.89 78.34,73.89 77.91,74.32 76.94,74.32 76.11,75.16 69.81,75.16 68.74,76.22 63.33,76.22 62.64,76.92 54.6,76.92 53.82,76.14 47.58,76.14 46.28,74.84 40.45,74.84 38.81,73.21 35.34,73.21 34.52,74.02 31.69,74.02 31.35,73.68 29.43,73.68 28.81,74.3 26.73,74.3 25.49,75.54 24.98,75.54 22.64,77.88 22.64,79.66 23.42,80.44 23.42,81 24.15,81.73 24.93,81.73 25.5,82.31 25.5,82.68 26.37,83.54 31.02,83.54 v1(32.77,85.3)
  BOTTOM w0.149: U7.22 32.43,84.95 v1(32.77,85.3)
ENET_VDD1.2V:
  vias: v1(16.01,80.22) v1(16.52,79.83) v1(23.76,90.38) v1(24.77,90.38) v1(39.31,82.17) v1(39.95,81.54) v1(49.28,95.27) v2(50.55,91.77) v2(51.7,92.92) v2(51.7,91.77)
ENET_XI: length 16.8
  BOTTOM w0.149: U7.46 24.03,88.45 23.44,89.04 23.44,90.06 22.87,90.63 22.87,93.17 23.5,93.8 31.69,93.8 R161.2
EXT_JTAG_TCK: length 312.8
  L07_SIG3 w0.089: v1(32.14,54.56) 32.06,54.49 32.06,53.56 31.96,53.46 31.71,53.46 31.6,53.36 31.6,53.22 31.71,53.12 31.96,53.12 32.06,53.01 32.06,52.87 31.96,52.77 31.71,52.77 31.6,52.67 31.6,52.53 31.71,52.43 31.96,52.43 32.06,52.33 32.06,52.19 31.96,52.09 31.71,52.09 31.6,51.99 31.6,51.84 31.71,51.74 31.96,51.74 32.06,51.64 32.06,51.53 31.96,51.42 31.65,51.42 31.55,51.32 31.55,51.18 31.65,51.08 31.96,51.08 32.06,50.98 32.06,50.84 31.96,50.74 31.65,50.74 31.55,50.64 31.55,50.5 31.65,50.4 31.96,50.4 32.06,50.3 32.06,47.73 32.21,47.58 32.21,47.44 31.78,47.01 31.78,46.8 31.98,46.59 32.12,46.59 32.57,47.04 32.75,47.04 33.3,46.49 33.3,46.33 32.76,45.79 32.76,45.63 32.88,45.51 33.04,45.51 33.58,46.05 33.74,46.05 34.55,45.24 34.55,44.15 v1(34.93,43.77) 35.59,43.77 35.8,43.56 35.8,39.22 30.8,34.23 30.8,31.44 30.69,31.33 30.53,31.33 30.42,31.44 30.42,33.32 30.31,33.43 30.13,33.43 30.03,33.33 v1(30.03,28.42)
  L16_SIG6 w0.081: v1(222.53,106.98) 221.24,108.28 217.04,108.28 214.86,106.1 212.59,106.1 209.66,109.02 196.18,109.02 194.8,110.41 97.44,110.41 96.57,109.54 73.27,109.54 72.35,110.47 68.49,110.47 67.49,109.47 46.79,109.47 41.97,104.65 41.97,103.92 37.87,99.82 37.11,99.82 32.44,95.15 32.44,91.39 31.19,90.14 30.54,90.14 29.85,89.45 29.85,89.03 28.41,87.59 27.11,87.59 25.68,86.16 25.38,86.16 23.24,84.03 23.24,80.35 22.32,79.43 22.32,77.12 21.73,76.53 21.73,74.12 21.1,73.49 21.1,62.99 21.89,62.21 21.89,54.6 22.84,53.65 28.12,53.65 28.4,53.93 29.98,53.93 30.13,53.77 31.88,53.77 32.14,54.03 v1(32.14,54.56)
  BOTTOM w0.149: v1(222.53,106.98) 221.6,106.05 221.6,100.94 J14.1 ; U29.1 34.39,43.1 34.93,43.64 v1(34.93,43.77) 35.44,44.27 35.44,44.85 R831.1
EXT_JTAG_TDI: length 313.2
  L07_SIG3 w0.089: v1(29.22,55.07) 27.9,53.75 27.9,43.71 31.01,40.6 31.11,40.6 v1(31.38,40.34) 31.38,38.31 27.77,34.7 27.77,33.57 27.67,33.47 27.34,33.47 27.24,33.37 27.24,33.23 27.34,33.13 27.67,33.13 27.77,33.03 27.77,32.88 27.67,32.78 27.34,32.78 27.24,32.68 27.24,32.54 27.34,32.44 27.67,32.44 27.77,32.34 27.77,32.2 27.67,32.1 27.34,32.1 27.24,32 27.24,31.85 27.34,31.75 27.67,31.75 27.77,31.65 27.77,31.51 27.67,31.41 27.34,31.41 27.24,31.31 27.24,31.17 27.34,31.07 27.67,31.07 27.77,30.97 27.77,29.47 27.23,28.93 27.23,26.65 27.4,26.49 28.09,26.49 v1(28.43,26.82)
  L16_SIG6 w0.081: v1(232.69,106.98) 231.22,105.51 221.48,105.51 220.05,106.94 218.3,106.94 216.73,105.37 216.73,104.86 216.32,104.45 215.63,104.45 214.99,103.81 211.43,103.81 211.08,104.16 210.6,104.16 210.35,103.91 205.61,103.91 205.12,104.4 202.28,104.4 201.56,105.12 196.03,105.12 195.13,104.21 191.77,104.21 187.47,108.51 132.28,108.51 131.75,107.97 131.75,107.17 129.27,104.69 127.99,104.69 126.97,105.72 126.97,106 126.46,106.51 126.17,106.51 125.43,107.25 125.43,107.9 124.82,108.51 104.45,108.51 101.37,105.43 98.28,105.43 95.76,107.95 78.64,107.95 77.9,107.21 73.92,107.21 72.75,106.04 71.43,105.5 71.13,105.5 70.62,105.29 69.64,105.29 67.25,107.68 56.68,107.68 55.38,106.38 53.98,106.38 52.97,105.36 50.94,105.36 48.9,103.33 47.78,103.33 45.74,101.28 45.74,100.89 44.1,99.25 41.89,99.25 40.76,98.13 40.39,98.13 39.71,97.45 39.71,97.01 39.23,96.54 38.06,96.54 34.54,93.02 34.54,90.44 32.81,88.7 32.81,88.28 32.46,87.94 32.24,87.94 31.35,87.05 31.35,86.84 31.09,86.58 30.44,86.58 29.71,85.86 29.14,85.86 26.66,83.37 26.66,82.13 25.55,81.02 25.55,80.52 25.09,80.06 25.09,77.49 24.67,77.06 24.67,72.82 23.32,71.47 23.32,68.18 23.73,67.77 23.73,65.56 23.4,65.23 23.4,60.74 23.72,60.42 23.72,58.15 24.45,57.43 25.53,57.43 26.94,56.01 28.28,56.01 v1(29.22,55.07)
  BOTTOM w0.149: U29.8 32.24,41.2 v1(31.38,40.34) ; J14.9 232.14,100.56 232.14,106.43 v1(232.69,106.98)
EXT_JTAG_TDO: length 311.2
  L07_SIG3 w0.089: v1(31.25,54.56) 31.25,51.51 31.05,51.32 31.05,46.94 31.83,46.15 31.83,43.77 31.38,43.31 v1(31.38,43) 31.99,43 32.47,42.52 33.76,42.52 34.69,41.59 35.1,41.59 35.31,41.37 35.31,39.22 29.63,33.54 29.63,28.02 v1(29.23,27.62)
  L16_SIG6 w0.081: v1(31.25,54.56) 30.87,54.18 30.18,54.18 30.03,54.33 28.86,54.33 28.12,55.07 27.31,55.07 26.83,54.59 23.78,54.59 23.51,54.85 23.51,56.98 22.61,57.88 22.61,64.83 21.92,65.52 21.92,68.39 22.61,69.08 22.61,72.9 23.67,73.96 23.67,74.94 23.38,75.24 23.38,76.25 23.12,76.51 23.12,79.02 24.18,80.09 24.18,80.9 25.08,81.79 25.08,82.67 25.67,83.27 25.67,84.24 26.46,85.02 27.07,85.02 27.35,85.31 27.35,85.85 27.8,86.3 28.32,86.3 29.13,87.12 29.71,87.12 30.32,87.73 30.32,87.9 30.65,88.23 31.18,88.23 31.68,88.74 31.68,89.49 33.16,90.97 33.16,93.88 37.37,98.09 38.42,98.09 38.74,98.41 38.74,98.63 40.22,100.1 43.19,100.1 43.98,100.89 43.98,103.11 46.49,105.62 47,105.62 48.27,106.89 51.32,106.89 52.97,108.54 67.31,108.54 69.87,105.98 70.6,105.98 71,106.15 71.21,106.15 72.23,106.57 74.46,108.8 95.96,108.8 98.66,106.1 100.92,106.1 104.02,109.2 125.46,109.2 126.58,108.08 126.58,107.31 127.38,106.51 127.5,106.43 128.21,106.13 128.98,106.13 129.69,106.43 130.58,107.32 130.58,108.05 131.74,109.2 188.11,109.2 191.57,105.74 195.4,105.74 195.79,106.12 206.03,106.12 206.46,105.69 207.68,105.69 208.2,106.21 209.93,106.21 210.96,105.18 212.46,105.18 212.64,105.36 215.05,105.36 217.3,107.61 220.52,107.61 221.96,106.16 226.79,106.16 v1(227.61,106.98)
  BOTTOM w0.149: U29.11 31.68,42.7 v1(31.38,43) ; v1(227.61,106.98) 226.98,106.36 226.98,100.69 J14.3
EXT_JTAG_TMS: length 315.7
  L07_SIG3 w0.089: v1(27.63,28.42) 28.03,28.02 28.56,28.02 28.84,28.3 28.84,28.91 29.24,29.31 29.24,33.66 29.84,34.25 29.84,34.41 29.5,34.75 29.5,34.91 29.62,35.02 29.78,35.02 30.11,34.69 30.27,34.69 30.38,34.8 30.38,34.96 29.92,35.42 29.92,35.58 30.03,35.7 30.19,35.7 30.66,35.23 30.82,35.23 30.93,35.35 30.93,35.51 30.47,35.97 30.47,36.13 30.58,36.24 30.74,36.24 31.2,35.78 31.36,35.78 34.93,39.35 v1(34.93,41.1) 33.37,41.1 31.9,42.57 31.25,42.57 30.91,42.91 30.91,46.21 30.33,46.79 30.05,46.79 29.52,47.32 29.52,50.53 30.82,51.82 30.82,54.1 v1(30.36,54.56)
  L16_SIG6 w0.081: v1(30.36,54.56) 30.23,54.69 29.02,54.69 28.16,55.54 26.94,55.54 25.6,56.88 24.15,56.88 22.99,58.03 22.99,65.69 22.82,65.86 22.82,67.11 22.99,67.29 22.99,72.44 24.11,73.56 24.11,75.18 23.73,75.56 23.73,77.12 24.75,78.13 24.75,80.19 25.14,80.59 25.14,81.14 26.32,82.31 26.32,84.27 26.73,84.69 27.29,84.69 27.73,85.13 27.73,85.66 28.01,85.94 28.59,85.94 28.93,86.28 29.58,86.28 30.74,87.44 31.08,87.44 32.01,88.38 32.01,89.18 33.62,90.8 33.62,93.7 37.06,97.13 37.69,97.13 38.19,97.63 38.99,97.63 39.79,98.44 39.79,98.86 40.57,99.63 43.96,99.63 45.33,101 45.33,101.41 47.78,103.86 48.76,103.86 50.77,105.87 52.4,105.87 54.6,108.07 67.32,108.07 69.78,105.61 70.55,105.61 71.06,105.82 71.31,105.82 72.4,106.27 74.5,108.37 95.83,108.37 98.44,105.76 101.21,105.76 104.3,108.84 125.28,108.84 126.22,107.9 126.22,107.21 127.47,105.95 127.47,105.71 127.72,105.46 129.58,105.46 130.93,106.82 130.93,107.9 131.88,108.84 187.74,108.84 191.99,104.6 194.92,104.6 195.85,105.53 205.8,105.53 206.5,104.84 207.68,104.84 208.2,105.36 209.56,105.36 210.1,104.82 212.42,104.82 212.62,104.61 213.34,104.61 213.56,104.39 214.58,104.39 217.47,107.28 220.17,107.28 221.61,105.84 229.01,105.84 v1(230.15,106.98)
  BOTTOM w0.149: v1(34.93,41.1) 34.93,41.23 34.26,41.9 U29.4 ; J14.5 229.6,100.76 229.6,106.43 v1(230.15,106.98)
FAN_CTRL: length 27.5
  L07_SIG3 w0.089: v1(251.75,23.46) 252.86,22.34 252.86,21.29 253.63,20.53 255.61,20.53 256.17,19.97 261.2,19.97 264.42,23.19 264.42,29.42 267.09,32.08 J15.4
FAULT: length 83.1
  TOP w0.149: R6090.1 196.99,54.88 196.97,54.89 R5938.1 v1(196.41,55.81) 196.42,55.81 197.08,56.47 197.14,56.47 197.54,56.87 U47.18
  L07_SIG3 w0.089: v1(190.55,72.98) 190.55,70.03 193.12,67.45 193.12,64.67 195.16,62.64 195.16,61.34 194.55,60.73 v1(189.87,60.73)
  L16_SIG6 w0.081: v1(189.22,48.72) 186.64,51.3 186.64,54.44 186.29,54.8 186.29,55.83 186.68,56.22 186.68,59.14 188.27,60.73 v1(189.87,60.73) 189.87,60.53 189.67,60.33 189.34,60.33 188.7,59.68 188.46,59.68 188.25,59.47 188.25,58.8 188.58,58.47 192.13,58.47 195.28,55.32 195.93,55.32 v1(196.41,55.81) ; v1(190.57,85.04) 190.15,85.46 190.15,85.98 189.36,86.77 188.07,86.77 187.33,87.51 184.77,87.51 183.54,86.28 183.54,77.27 184.72,76.1 190.18,76.1 191.27,75.01 191.27,73.7 v1(190.55,72.98)
  BOTTOM w0.149: R6112.1 190.44,60.16 v1(189.87,60.73)
FPGA_3V3_LED0: length 375.2
  L07_SIG3 w0.089: v1(34.03,28.42) 33.63,28.02 33.07,28.02 32.83,28.27 32.83,28.82 32.32,29.34 32.32,30.46 31.58,31.19 31.58,33.99 36.81,39.22 36.81,44.02 32.77,48.06 32.77,55.07 v1(33.41,55.7)
  L16_SIG6 w0.081: v1(263.53,40.08) 263.53,44 262.77,44.76 262.77,67.52 264.04,68.79 264.04,81.51 262.82,82.73 262.82,88.27 260.76,90.33 254.95,90.33 254.72,90.55 243.56,90.55 238.91,95.2 235.8,95.2 235.1,95.91 219.65,95.91 218.45,97.11 217.35,97.11 216.58,96.34 213.87,96.34 213.38,95.85 201.73,95.85 200.72,96.86 196.74,96.86 194.46,94.58 187.97,94.58 187.02,95.53 186.62,95.53 186.06,96.09 186.06,96.6 184.79,97.87 184.79,99.24 184.56,99.47 181.03,99.47 176.94,103.56 151.09,103.56 150.76,103.89 149.16,103.89 148.85,103.59 145.38,103.59 144.31,104.66 143.22,104.66 143.11,104.77 139.9,104.77 139.3,104.17 138.67,104.17 138.46,104.37 137.22,104.37 137.1,104.26 134.48,104.26 133.47,103.25 133.47,102.88 132.39,101.79 127.98,101.79 127.62,101.44 125.71,101.44 124.55,102.6 122.25,102.6 121.41,103.43 120.49,103.43 119.53,104.4 112.43,104.4 111.54,103.51 108.63,103.51 107.72,102.6 103.62,102.6 103.25,102.23 101.44,102.23 101.04,101.83 97.55,101.83 95.89,103.48 95.51,103.48 95.34,103.31 91.48,103.31 90.83,102.67 90.08,102.67 89.58,103.17 84.37,103.17 83.84,102.64 76.8,102.64 76.52,102.35 71.16,102.35 70.87,102.07 63.57,102.07 61.46,99.95 57.97,99.95 56.28,98.26 51.18,98.26 50.56,97.64 48.68,97.64 45.93,94.9 44.05,94.9 38.72,89.57 38.72,88.58 36.64,86.51 36.64,84.65 35.82,83.82 35.82,83.33 35.43,82.94 34.46,82.94 32.53,81.01 32.53,80.49 32.17,80.14 32.17,79.11 31.25,78.18 31.25,76.2 30.37,75.32 30.37,74.15 29.54,73.32 29.54,70.95 29.81,70.67 29.81,62.23 29.98,62.06 29.98,57.38 31.55,55.81 33.31,55.81 v1(33.41,55.7)
  BOTTOM w0.149: v1(263.53,40.08) 263.53,38.31 263.34,38.12 Q5.1
FPGA_3V3_LED1: length 374.5
  L07_SIG3 w0.089: v1(34.83,27.62) 35.23,28.02 35.23,28.74 35.03,28.93 35.03,29.59 36.05,30.61 37.62,30.61 39.25,32.24 39.25,35.47 37.43,37.29 37.43,38.45 38.09,39.11 38.09,44.21 33.66,48.65 33.66,53.54 33.85,53.74 33.85,54.8 34.3,55.25 v1(34.3,55.7)
  L16_SIG6 w0.081: v1(264.72,42.18) 264.72,43.44 263.15,45.01 263.15,67.26 264.42,68.53 264.42,81.69 263.25,82.86 263.25,88.34 260.97,90.63 255.25,90.63 254.34,91.54 243.75,91.54 237.93,97.36 216.92,97.36 216.54,96.98 208.6,96.98 208.06,96.44 207.32,96.44 206.93,96.83 201.41,96.83 200.4,97.83 197.08,97.83 194.83,95.58 188.22,95.58 187.21,96.6 186.82,96.6 186.44,96.98 186.44,97.97 186.06,98.35 186.06,99.01 184.94,100.13 181.41,100.13 177.58,103.97 151.16,103.97 150.71,104.42 145.1,104.42 143.98,105.54 142.57,105.54 142.15,105.12 139.89,105.12 139.4,104.63 138.56,104.63 138.35,104.84 137.05,104.84 136.9,104.69 136.59,104.69 136.02,105.26 135.15,105.26 133.15,103.26 133.15,102.93 132.24,102.03 127.86,102.03 127.51,101.67 125.81,101.67 124.13,103.35 122.07,103.35 120.73,104.69 112.19,104.69 111.41,103.91 108.48,103.91 107.51,102.95 103.4,102.95 102.91,102.46 101.34,102.46 100.97,102.09 97.82,102.09 96.1,103.81 94.66,103.81 94.43,103.58 84.1,103.58 83.96,103.72 77.26,103.72 76.22,102.68 72.34,102.68 72.24,102.58 71.06,102.58 70.78,102.3 64.6,102.3 62.62,104.28 59.4,104.28 58.3,103.18 58.3,102.31 57.92,101.93 57.67,101.93 57.16,101.42 57.16,100.28 55.59,98.72 51.72,98.72 51.55,98.54 48.87,98.54 45.74,95.41 44.05,95.41 38.23,89.6 38.23,88.8 36.2,86.77 36.2,85.04 32.18,81.02 32.18,80.55 31.62,79.98 31.62,79.29 30.91,78.59 30.91,76.73 29.13,74.95 29.13,72.59 28.44,71.9 28.44,67.05 28.81,66.68 28.81,64.24 29.47,63.58 29.47,62.05 29.6,61.93 29.6,57.38 31.47,55.5 32.82,55.5 33,55.32 33.92,55.32 v1(34.3,55.7)
FPGA_3V3_LED2: length 382.4
  L07_SIG3 w0.089: v1(34.3,54.69) 34.3,53.7 33.96,53.36 33.96,48.83 38.44,44.35 38.44,38.86 37.83,38.26 37.83,37.39 39.63,35.59 39.63,31.98 37.45,29.8 36.23,29.8 35.92,29.49 35.92,29.09 35.63,28.79 v1(35.63,28.42)
  L16_SIG6 w0.081: v1(263.53,45.67) 263.53,67.01 264.8,68.28 264.8,92.05 263.35,93.51 260.98,93.51 260.98,93.52 254.19,93.52 252.55,95.16 247.26,95.16 244.42,98 238.06,98 237.73,97.67 219.72,97.67 218.84,98.54 217.54,98.54 216.3,97.3 208.72,97.3 208.57,97.46 206.51,97.46 206.21,97.17 201.68,97.17 200.47,98.38 196.22,98.38 194.32,96.47 188.09,96.47 187.33,97.23 187.33,97.61 186.44,98.5 186.44,99.9 185.71,100.64 183.24,100.64 179.28,104.6 176.47,104.6 176.17,104.9 175.53,104.9 175.26,104.63 167.02,104.63 166.7,104.94 166.1,104.94 165.72,104.57 157.81,104.57 157.4,104.98 156.86,104.98 156.5,104.61 151.78,104.61 151.41,104.99 145.04,104.99 144.24,105.79 142.39,105.79 142.09,105.49 136.45,105.49 135.93,106.02 135.58,106.02 132.82,103.26 132.82,103.01 132.1,102.29 127.74,102.29 127.36,101.91 125.9,101.91 124.21,103.6 122.96,103.6 121.94,104.62 121.24,104.62 120.38,105.49 111.41,105.49 110.14,104.22 108.32,104.22 107.37,103.27 103.15,103.27 102.9,103.01 101.62,103.01 101.3,102.69 100.48,102.69 100.24,102.94 97.3,102.94 96.19,104.05 85.53,104.05 85.45,103.97 84.2,103.97 83.95,104.22 76.43,104.22 75.67,103.46 71.76,103.46 71.12,102.82 70.96,102.82 70.82,102.67 65.38,102.67 63.3,104.75 59.09,104.75 57.03,102.69 57.03,101.81 55.76,100.54 55.76,100.03 55.16,99.43 49.91,99.43 49.44,98.95 48.21,98.95 45.2,95.95 44.12,95.95 37.67,89.51 37.67,88.91 35.81,87.05 35.81,85.26 34.22,83.68 34.22,83.52 31.81,81.11 31.49,81.11 31.23,80.84 31.23,79.59 30.55,78.91 30.55,76.95 28.64,75.05 28.64,72.95 27.96,72.26 27.96,66.12 28.33,65.75 28.33,64.09 29.09,63.32 29.09,61.8 29.22,61.67 29.22,57.33 31.33,55.22 32.62,55.22 32.77,55.07 33.92,55.07 v1(34.3,54.69)
  BOTTOM w0.149: Q8.1 259.28,42.18 258.96,42.5 258.96,45.04 259.6,45.67 v1(263.53,45.67)
FPGA_3V3_LED3: length 349
  L03_SIG1 w0.081: v1(30.36,55.58) 29.85,55.07 29.85,54.31 30.74,53.42 30.74,52.02 36.18,46.59 36.18,40.67 38.79,38.05 38.79,37.29 40.57,35.51 43.36,35.51 43.77,35.92 v1(46.49,35.92)
  L07_SIG3 w0.089: v1(263.91,48.08) 265.28,46.71 267.81,46.71 272.05,42.47 272.05,24.78 265.37,18.1 246.54,18.1 244.52,16.07 216.66,16.07 v1(216.29,15.7) ; v1(30.36,55.58) 31.88,55.58 32.52,54.94 32.52,47.78 36.3,44 36.3,39.17 31.2,34.07 31.2,31.24 30.49,30.53 30.49,28.77 v1(30.83,28.42)
  L14_SIG5 w0.081: v1(46.49,35.92) 48.01,34.4 48.01,31.22 51.54,27.69 51.54,23.47 51.82,23.19 51.82,20.27 55.03,17.06 55.86,17.06 63.88,9.04 127.75,9.04 129.69,10.99 133.89,10.99 138.4,15.5 153.4,15.5 155.81,17.91 156.45,17.91 159.62,21.08 187.26,21.08 188.48,19.86 191.46,19.86 196.63,14.69 211.27,14.69 212.2,13.77 214.36,13.77 v1(216.29,15.7)
  BOTTOM w0.149: v1(263.91,48.08) 264.29,48.08 265.12,48.91 Q9.1
FPGA_BYPASSN: length 47.4
  L03_SIG1 w0.081: v1(2.8,48.9) 3.31,48.39 3.31,46.05 2.88,45.62 2.59,45.62 2.35,45.38 2.35,44.85 2.61,44.59 3.56,44.59 12.85,35.3 16.43,35.3 19.63,32.1 27.15,32.1 29.63,29.62 29.63,27.46 29.87,27.22 30.19,27.22 30.43,26.98 30.43,26.66 30.67,26.42 30.99,26.42 31.23,26.18 31.23,25.86 31.49,25.61 32.81,25.61 v4(33.23,26.02)
  BOTTOM w0.149: SW4.4 v1(2.8,48.9) R351.1
FPGA_CONF_DONE: length 344.3
  L07_SIG3 w0.089: v1(32.43,22.82) 32.43,23.06 32.99,23.62 34.27,23.62 34.67,23.22 34.99,23.22 35.23,22.98 35.23,22.66 35.47,22.42 39.4,22.42 39.83,22.86 39.83,23.11 46.9,30.18 50.48,30.18 56.14,35.84 56.14,36.78 57.61,38.26 59.39,38.26 62.87,41.73 62.87,43.77 65.54,46.43 65.54,52.02 66.17,52.66 76.97,52.66 78.29,51.34 81.9,51.34 83.62,53.05 86.11,53.05 86.82,53.76 87.44,53.76 87.64,53.55 87.95,53.55 88.45,54.05 89.42,54.05 89.92,54.55 90.37,54.55 91.12,55.3 91.75,55.3 92.21,54.84 92.65,54.84 92.94,54.55 93.71,54.55 93.99,54.83 94.35,54.83 94.64,54.54 97.01,54.54 97.28,54.82 97.9,54.82 98.18,54.54 98.68,54.54 99.17,54.05 99.6,54.05 99.85,54.3 100.47,54.3 100.84,53.93 101.25,53.93 101.63,54.3 102.2,54.3 102.55,53.95 102.9,53.95 103.31,54.36 103.89,54.36 104.25,54 104.73,54 105.17,54.44 105.57,54.44 106,54.87 106.46,54.87 107.02,55.43 107.33,55.43 107.7,55.8 108.33,55.8 108.58,55.55 109.15,55.55 109.4,55.8 110.1,55.8 110.36,55.55 110.86,55.55 111.14,55.83 111.53,55.83 112.55,56.85 118.95,56.85 119.97,55.83 120.25,55.83 120.76,55.32 121.22,55.32 121.5,55.04 122.18,55.04 122.44,55.3 122.99,55.3 123.35,54.94 123.6,54.94 124.14,54.41 124.64,54.41 125,54.05 125.66,54.05 125.91,54.31 128.08,54.31 128.51,53.88 128.86,53.88 129.32,53.42 129.78,53.42 130.28,52.91 130.64,52.91 131.07,52.48 131.53,52.48 132.06,51.95 134.09,51.95 134.5,51.54 135.16,51.54 135.49,51.87 135.92,51.87 136.25,51.54 136.84,51.54 137.19,51.89 137.6,51.89 138.08,52.38 138.46,52.38 138.97,52.89 139.38,52.89 139.83,52.43 140.89,52.43 v1(140.89,52.43) ; v1(269.19,53.63) 268.09,53.63 266.84,52.38 266.84,50.48 266.32,49.96 263.91,49.96 263.38,49.43 263.38,47.81 264.83,46.36 267.65,46.36 268.64,45.37 268.64,44.63 271.81,41.46 271.81,25.22 264.93,18.34 246.41,18.34 244.63,16.56 236.23,16.56 235.64,17.15 216.34,17.15 210.54,22.94 210.54,24.24 v1(208.03,26.75)
  L14_SIG5 w0.081: v1(208.03,26.75) 207.65,26.37 205.15,26.37 199.84,31.68 196.6,31.68 192.06,36.22 185.91,36.22 178.57,43.56 177.98,43.56 176.35,45.19 172.68,45.19 171.78,46.09 171.78,48.64 171.05,49.36 167.76,49.36 165.92,51.21 164.55,51.21 160.99,54.77 159.33,54.77 159.2,54.9 158.81,54.9 158.67,54.77 158.18,54.77 157.78,54.36 148.92,54.36 148.43,53.87 143.43,53.87 143.08,53.52 143.08,53.24 142.76,52.92 142.38,52.92 141.89,52.43 v1(140.89,52.43)
  BOTTOM w0.149: v1(140.89,52.43) 140.89,52.36 141.32,51.93 141.32,48.15 141.08,47.91 140.7,47.91 140.22,47.42 139.78,47.42 139.3,46.94 138.97,46.94 138.44,46.41 138.08,46.41 137.52,45.85 137.12,45.85 136.68,45.42 136.38,45.42 136.12,45.16 136.12,40.95 R123.2
FPGA_CVP_CONFDONE: length 398.1
  L07_SIG3 w0.089: v1(267.22,51.96) 272.68,46.5 272.68,24.56 265.21,17.1 250.71,17.1 249.94,17.86 246.64,17.86 243.42,14.63 216.72,14.63 215.32,16.03 215.32,16.59 213.77,18.14 211.87,18.14 210.37,16.64 206.97,16.64 206.97,16.64 200.36,16.64 v1(199.65,17.35)
  BOTTOM w0.149: v1(199.65,17.35) 198.89,18.11 188.6,18.11 188.17,18.54 188.17,19.31 187.21,20.27 161.17,20.27 158.96,18.07 148.09,18.07 146.86,16.84 107.04,16.84 105.97,17.91 101.61,17.91 101.28,18.24 69.35,18.24 68.77,17.66 46.19,17.66 45.36,18.49 39.37,18.49 37.84,16.97 35.97,16.97 34.83,18.11 v1(34.83,18.82) 36.3,17.35 37.73,17.35 38.13,17.76 38.13,18.56 38.57,19 41.38,19 41.75,19.37 52.85,19.37 53.96,18.26 56.11,18.26 57.72,19.87 57.72,22.65 60.02,24.94 67.22,24.94 67.86,25.58 85.09,25.58 88.38,28.88 113.55,28.88 113.71,29.03 113.72,29.03 114.92,30.23 114.92,31.24 116.26,32.59 121.77,32.59 122.44,33.25 128.71,33.25 129.14,33.68 131.33,33.68 132.32,32.69 135.59,32.69 137.68,34.78 R124.2 R5773.2
FPGA_I2C_EN: length 180.7
  L03_SIG1 w0.127: v1(2.67,62.37) 1.28,60.98 1.28,34.86 6.59,29.55 6.59,26.79 6.51,26.71 6.51,25.46 6.59,25.39 6.59,24.11 8.83,21.86 10.03,21.86 13.4,18.49 20.71,18.49 21.22,17.99 23.63,17.99 24.47,17.14 28.51,17.14 29.23,17.86 v4(29.23,18.82)
  L05_SIG2 w0.127: v1(41.79,60.78) 39.83,60.78 37.83,62.79 27.29,62.79 26.8,62.31 v1(26.77,62.31)
  L12_SIG4 w0.127: v1(86.2,101.33) 83.32,101.33 82.66,100.66 77.35,100.66 75.99,99.31 75.99,98.8 75.51,98.31 72.08,98.31 70.49,96.73 70.49,94.06 69.22,92.79 67.81,92.79 64.65,89.63 64.65,84.53 61.86,81.74 56.52,81.74 46.69,71.91 46.69,71.02 45.6,69.93 45.6,68.02 44.71,67.13 44.71,65.86 44.08,65.23 44.08,64.85 43.06,63.83 43.06,62.05 v1(41.79,60.78) ; v1(2.67,62.37) 6.93,62.37 8.01,63.45 24.65,63.45 25.79,62.31 v1(26.77,62.31)
  BOTTOM w0.149: v1(2.67,62.37) 2.79,62.49 SW3.1
FPGA_I2C_SCL: length 29.8
  L14_SIG5 w0.081: v1(108.85,79.93) 107.83,79.93 107.29,80.48 106.99,80.48 106.52,80.95 106.09,80.95 105.5,81.54 105.24,81.54 104.97,81.82 104.97,82.58 104.69,82.86 103.99,82.86 103.51,83.34 103.51,84.81 102.83,85.48 102.44,85.48 101.8,86.13 101.8,87.85 101.2,88.46 100.74,88.46 100.23,88.97 100.23,89.85 97.26,92.82 90.21,92.82 v1(89.35,93.68)
  BOTTOM w0.149: U23.2 89.45,93.77 v1(89.35,93.68)
FPGA_I2C_SDA: length 28.4
  L14_SIG5 w0.081: v1(87.64,93.68) 88.84,92.47 97.14,92.47 99.9,89.71 99.9,88.84 100.61,88.13 101.06,88.13 101.47,87.72 101.47,85.99 102.38,85.09 102.38,83.31 103.88,81.81 104.68,81.81 105.17,81.32 105.17,81.14 v1(105.39,80.93)
  BOTTOM w0.149: U23.3 88.8,94.48 88.63,94.31 87.84,94.31 87.64,94.11 v1(87.64,93.68)
FPGA_INIT_DONE: length 144.7
  L07_SIG3 w0.089: v1(35.63,19.62) 36.03,19.22 37.24,19.22 38.06,20.04 38.61,20.04 42.77,24.21 43.65,24.21 45.55,26.1 45.55,27.14 46.86,28.45 51.26,28.45 51.95,29.14 52.51,29.14 52.93,29.56 52.93,30.14 59,36.21 59.51,36.21 64.42,41.13 65.36,41.13 66.94,42.7 66.94,43.67 70.11,46.84 70.11,48.97 70.49,49.35 75.95,49.35 76.33,49.73 82.46,49.73 82.9,50.17 82.9,50.81 84.41,52.32 86.75,52.32 87.24,52.81 89.15,52.81 89.65,53.31 90.2,53.31 90.47,53.04 90.91,53.04 91.26,53.39 91.63,53.39 92.18,52.84 92.6,52.84 92.89,52.55 93.42,52.55 93.92,53.05 94.5,53.05 95.26,53.81 96.01,53.81 96.52,53.3 96.95,53.3 97.39,52.86 97.77,52.86 98.2,52.43 98.69,52.43 99.14,51.97 99.6,51.97 99.95,52.32 100.52,52.32 100.92,51.92 101.23,51.92 101.61,52.3 102.27,52.3 102.6,51.97 103.05,51.97 103.39,52.3 104.09,52.3 104.43,51.97 104.83,51.97 105.17,52.3 105.77,52.3 106.1,51.97 106.46,51.97 106.92,52.43 107.22,52.43 107.68,52.89 108.08,52.89 108.59,53.39 109.04,53.39 109.61,53.96 109.98,53.96 110.33,54.3 110.87,54.3 111.12,54.05 111.81,54.05 112.06,54.3 112.52,54.3 113.02,54.8 113.41,54.8 113.88,54.34 114.25,54.34 114.6,53.99 115.23,53.99 115.55,54.31 116.09,54.31 116.57,53.83 116.79,53.83 117.2,53.42 117.68,53.42 118.09,53.83 118.57,53.83 118.93,53.47 119.34,53.47 119.82,52.99 120.38,52.99 120.73,53.34 121.22,53.34 121.62,52.94 122.05,52.94 122.54,52.45 122.87,52.45 123.37,51.95 123.78,51.95 124.26,52.43 124.64,52.43 125.13,51.95 125.56,51.95 125.99,51.51 126.4,51.51 126.8,51.92 127.18,51.92 127.64,51.46 128.33,51.46 129.34,50.45 129.85,50.45 130.36,49.94 130.64,49.94 131.15,49.43 131.53,49.43 132,48.96 132.58,48.96 133.03,49.41 133.31,49.41 133.76,48.95 134.2,48.95 134.7,49.46 135.01,49.46 135.47,49 135.9,49 136.3,49.41 136.84,49.41 137.27,48.97 137.67,48.97 138.16,49.46 138.59,49.46 139.07,49.94 140.02,49.94 v1(140.03,49.93)
  BOTTOM w0.149: v1(140.03,49.93) 140.03,49.58 139.4,48.95 139.05,48.95 138.48,48.38 138.04,48.38 137.56,47.9 137.3,47.9 136.87,47.46 136.44,47.46 135.91,46.93 135.57,46.93 135.1,46.46 134.68,46.46 134.39,46.17 134.39,41 R122.2
FPGA_JTAG_TCK: length 145.3
  L05_SIG2 w0.081: v1(34.83,20.42) 35.23,20.02 39.33,20.02 42.52,23.22 43.72,23.22 44.46,23.95 44.46,29.93 45.73,31.19 45.73,36.15 44.97,36.91 44.97,39.32 45.6,39.96 45.6,40.34 45.98,40.72 46.87,40.72 48.88,42.73 55.05,42.73 55.46,43.13 58.35,43.13 62.16,46.94 65.79,46.94 66.1,47.25 69.4,47.25 70.11,47.96 73.54,47.96 74.18,48.59 78.61,48.59 79.64,49.62 80.21,49.62 80.6,50.02 80.96,50.02 81.29,50.34 81.29,50.56 81.93,51.2 89.32,51.2 89.44,51.32 90.16,51.32 90.44,51.04 90.85,51.04 91.11,51.3 91.96,51.3 92.21,51.05 92.57,51.05 92.82,51.3 93.65,51.3 93.9,51.05 94.29,51.05 94.54,51.3 95.41,51.3 95.67,51.04 96.05,51.04 96.31,51.3 97.01,51.3 97.26,51.05 97.89,51.05 98.14,51.3 98.89,51.3 99.14,51.05 99.59,51.05 99.83,51.3 100.63,51.3 100.88,51.05 101.31,51.05 101.7,51.44 102.11,51.44 102.47,51.81 102.99,51.81 103.49,52.3 104.05,52.3 104.3,52.04 104.66,52.04 105.17,52.55 105.58,52.55 105.83,52.8 106.71,52.8 106.95,52.55 107.37,52.55 107.62,52.8 108.25,52.8 108.6,52.45 109.07,52.45 109.57,51.95 109.91,51.95 110.37,52.4 110.88,52.4 111.39,51.89 111.77,51.89 112.15,51.51 112.45,51.51 113.16,50.8 113.38,50.8 113.63,50.55 114.35,50.55 114.61,50.81 115.06,50.81 115.7,50.17 116.74,50.17 117.47,49.44 118.03,49.44 118.92,48.55 119.43,48.55 119.67,48.8 120.47,48.8 120.72,48.55 121.28,48.55 121.53,48.8 123.75,48.8 124.14,48.42 124.54,48.42 124.93,48.8 125.53,48.8 125.78,48.55 126.38,48.55 126.63,48.8 127.22,48.8 127.47,48.55 128.1,48.55 128.39,48.83 129.14,48.83 129.41,48.55 129.99,48.55 130.23,48.8 130.88,48.8 131.13,48.55 131.67,48.55 131.92,48.81 132.64,48.81 132.89,48.55 133.4,48.55 133.65,48.8 134.3,48.8 134.65,48.45 134.94,48.45 135.52,47.88 135.93,47.88 136.34,47.47 136.74,47.47 137.23,46.98 137.51,46.98 138.09,46.39 138.5,46.39 138.98,45.91 139.36,45.91 139.83,45.45 140.2,45.45 140.72,44.94 141.09,44.94 141.6,44.43 v1(142.63,44.43)
  BOTTOM w0.149: R119.2 143.4,47.33 143.01,46.94 142.43,46.94 142.19,46.71 142.19,44.86 v1(142.63,44.43)
FPGA_JTAG_TDI: length 142.9
  L05_SIG2 w0.081: v1(141.76,43.93) 141.35,43.93 141.24,44.04 140.65,44.04 140.22,44.48 139.77,44.48 139.28,44.98 139,44.98 138.47,45.5 137.9,45.5 137.46,45.94 137.12,45.94 136.63,46.44 136.36,46.44 135.87,46.93 135.43,46.93 134.94,47.41 134.54,47.41 134.05,47.9 133.76,47.9 133.36,48.3 132.8,48.3 132.41,47.91 131.91,47.91 131.51,48.32 130.94,48.32 130.67,48.05 130.19,48.05 129.94,48.3 129.42,48.3 129.13,48.01 128.48,48.01 128.14,48.34 127.67,48.34 127.3,47.97 126.74,47.97 126.41,48.3 125.93,48.3 125.61,47.98 123.4,47.98 123.02,48.36 122.46,48.36 122.08,47.98 121.62,47.98 121.3,48.3 120.66,48.3 120.32,47.96 119.9,47.96 119.55,48.3 118.97,48.3 118.63,47.96 117.86,47.96 116.85,48.97 116.47,48.97 115.59,49.85 114.79,49.85 114.33,50.31 113.83,50.31 113.49,49.97 112.96,49.97 112.62,50.31 112.08,50.31 111.72,49.95 111.19,49.95 110.69,50.45 110.41,50.45 109.92,50.94 109.52,50.94 109.02,51.44 108.68,51.44 108.16,51.95 107.78,51.95 107.43,52.3 106.74,52.3 106.49,52.05 106,52.05 105.75,52.3 105.21,52.3 104.74,51.83 104.2,51.83 103.86,51.49 103.58,51.49 103.05,50.96 102.6,50.96 102.17,50.53 101.65,50.53 101.38,50.8 100.64,50.8 100.33,50.49 99.92,50.49 99.61,50.8 99.01,50.8 98.69,50.48 98.13,50.48 97.78,50.83 97.31,50.83 96.88,50.41 96.48,50.41 96.08,50.82 95.56,50.82 95.16,50.41 94.68,50.41 94.29,50.8 93.83,50.8 93.54,50.51 92.86,50.51 92.57,50.8 92.24,50.8 91.84,50.41 91.32,50.41 90.92,50.8 90.43,50.8 90.15,50.52 89.58,50.52 89.3,50.8 82.76,50.8 81.28,49.32 80.59,49.32 80.29,49.02 80.29,48.74 79.63,48.08 74.43,48.08 73.95,47.6 70.62,47.6 68.69,45.67 61.5,45.67 58.48,42.65 55.91,42.65 55.58,42.32 48.98,42.32 46.08,39.42 46.08,30.99 44.84,29.75 44.84,22.43 43.7,21.29 42.79,21.29 40.61,19.1 38.15,19.1 37.63,19.62 v1(36.43,19.62)
  BOTTOM w0.149: v1(141.76,43.93) 141.3,43.47 141.3,43.26 140.93,42.89 140.66,42.89 140.18,42.4 139.77,42.4 139.24,41.88 138.93,41.88 137.81,40.76 R118.2
FPGA_JTAG_TDO: length 144.5
  L05_SIG2 w0.081: v1(34.03,20.42) 33.63,20.82 33.03,20.82 32.83,21.02 32.83,21.38 33.07,21.62 33.39,21.62 33.63,21.87 33.63,22.18 33.87,22.42 34.16,22.42 34.43,22.69 34.43,22.98 34.67,23.22 37.38,23.22 38.18,24.03 38.92,24.03 41.54,26.65 41.54,27.13 42.81,28.4 42.81,32.92 42.55,33.18 42.55,37.16 42.81,37.42 42.81,41.49 43.81,42.5 46.24,42.5 46.62,42.12 47.15,42.12 47.35,42.32 47.35,43.89 47.76,44.3 52.86,44.3 53.6,45.04 57.67,45.04 58.22,44.48 58.58,44.48 59.06,44.96 59.06,45.65 61.37,47.96 65.64,47.96 65.87,48.19 67.14,48.19 68.43,49.48 78.26,49.48 80.27,51.5 80.27,52.03 80.62,52.38 85.95,52.38 86.33,52 88.97,52 89.39,52.41 90.14,52.41 90.49,52.05 90.85,52.05 91.2,52.41 91.85,52.41 92.2,52.05 92.57,52.05 92.93,52.41 93.61,52.41 93.97,52.05 94.29,52.05 94.65,52.41 95.32,52.41 95.67,52.05 96.1,52.05 96.39,52.35 97.07,52.35 97.38,52.05 97.76,52.05 98.06,52.34 98.76,52.34 99.06,52.04 99.63,52.04 100.02,52.43 100.32,52.43 100.76,52.87 101.29,52.87 101.61,52.55 102.18,52.55 102.56,52.94 103.1,52.94 103.55,53.38 103.94,53.38 104.27,53.05 104.68,53.05 105.18,53.56 105.78,53.56 106.03,53.82 106.52,53.82 106.78,53.55 107.4,53.55 107.67,53.83 108.37,53.83 108.67,53.53 109.16,53.53 109.46,53.84 109.96,53.84 110.24,53.55 110.89,53.55 111.13,53.8 111.77,53.8 112.15,53.42 112.4,53.42 112.91,52.91 113.39,52.91 113.93,52.37 114.29,52.37 114.72,51.94 115.07,51.94 115.57,51.44 115.97,51.44 116.54,50.87 117.04,50.87 117.35,50.55 117.73,50.55 118.48,49.8 120.43,49.8 120.68,49.55 122.99,49.55 123.24,49.8 123.91,49.8 124.16,49.55 124.64,49.55 124.89,49.8 125.71,49.8 125.96,49.55 126.5,49.55 126.78,49.84 127.3,49.84 127.58,49.55 128.12,49.55 128.37,49.8 129.05,49.8 129.3,49.55 129.87,49.55 130.12,49.8 130.68,49.8 130.93,49.55 131.59,49.55 131.84,49.8 132.62,49.8 132.87,49.55 133.32,49.55 133.57,49.8 134.3,49.8 134.55,49.55 135.16,49.55 135.41,49.8 135.94,49.8 136.34,49.41 136.67,49.41 137.19,48.89 137.57,48.89 138.05,48.42 138.54,48.42 139.01,47.95 139.25,47.95 139.74,47.46 140.07,47.46 140.62,46.92 140.95,46.92 141.39,46.48 141.87,46.48 142.38,45.97 142.38,45.67 v1(142.63,45.43)
FPGA_JTAG_TMS: length 144.7
  L05_SIG2 w0.081: v1(33.23,21.22) 33.5,21.22 33.9,21.62 34.23,21.62 34.43,21.82 34.43,22.18 34.67,22.42 37.53,22.42 37.94,22.84 38.74,22.84 42.68,26.77 42.68,27.66 43.5,28.49 43.5,37.48 43.82,37.8 43.82,39.88 45.55,41.61 47.12,41.61 48.32,42.8 48.32,43.41 48.85,43.94 58.58,43.94 59.7,45.06 59.7,45.62 61.63,47.55 65.77,47.55 65.95,47.73 69.12,47.73 70.49,49.1 78.53,49.1 79.4,49.97 79.95,49.97 80.26,50.27 80.26,50.63 81.18,51.55 90.24,51.55 90.48,51.8 90.86,51.8 91.11,51.55 91.96,51.55 92.21,51.8 92.59,51.8 92.83,51.55 93.73,51.55 93.98,51.81 94.29,51.81 94.54,51.55 95.35,51.55 95.6,51.8 96.19,51.8 96.44,51.55 96.98,51.55 97.23,51.81 97.96,51.81 98.21,51.55 98.72,51.55 98.98,51.81 99.75,51.81 100.01,51.55 100.46,51.55 100.74,51.84 101.17,51.84 101.63,52.3 102.32,52.3 102.56,52.06 102.95,52.06 103.44,52.55 104,52.55 104.25,52.8 104.73,52.8 105.23,53.3 105.67,53.3 105.92,53.05 106.61,53.05 106.86,53.3 107.58,53.3 107.83,53.05 108.25,53.05 108.51,53.31 109.23,53.31 109.62,52.92 110,52.92 110.38,53.3 110.87,53.3 111.26,52.91 111.64,52.91 112.15,52.4 112.53,52.4 113.04,51.89 113.41,51.89 113.93,51.38 114.3,51.38 114.63,51.05 115.13,51.05 115.68,50.5 117.07,50.5 117.25,50.32 117.65,50.32 118.51,49.46 119.38,49.46 119.79,49.05 120.3,49.05 120.55,49.3 122.92,49.3 123.17,49.05 124.01,49.05 124.26,49.3 124.9,49.3 125.15,49.05 125.61,49.05 125.86,49.3 126.5,49.3 126.75,49.05 127.34,49.05 127.58,49.3 128.22,49.3 128.46,49.06 129.08,49.06 129.33,49.3 129.97,49.3 130.22,49.05 130.81,49.05 131.05,49.3 131.71,49.3 131.98,49.03 132.53,49.03 132.8,49.3 133.4,49.3 133.64,49.05 134.3,49.05 134.55,49.3 135.03,49.3 135.43,48.91 135.87,48.91 136.31,48.47 136.71,48.47 137.25,47.94 137.59,47.94 138.09,47.43 138.47,47.43 138.91,46.99 139.25,46.99 139.77,46.47 140.11,46.47 140.53,46.05 140.95,46.05 141.53,45.47 141.53,45.16 v1(141.76,44.93)
  BOTTOM w0.149: v1(141.76,44.93) 141.76,44.58 141.11,43.93 140.75,43.93 140.24,43.43 139.84,43.43 139.37,42.95 138.92,42.95 138.34,42.37 138.09,42.37 137.66,41.94 137.26,41.94 136.81,41.5 R117.2
FPGA_LED0: length 137.3
  L12_SIG4 w0.089: v1(30.83,22.02) 30.83,22.27 28.83,24.27 28.83,28.77 29.3,29.24 29.3,36.23 30.87,37.8 30.87,42.24 31.25,42.62 34.04,42.62 34.74,43.32 37.1,43.32 41.09,47.31 41.09,48.28 44.08,51.26 44.08,53.7 50.69,60.31 54.78,60.31 57.28,62.82 57.28,66.27 58.1,67.08 58.68,67.08 60.21,68.61 60.21,71.1 61.74,72.63 61.74,74.92 62.95,76.13 67.47,76.13 69.3,77.96 78.63,77.96 78.93,77.65 83.63,77.65 85.15,79.18 88.52,79.18 89.39,78.3 90.26,78.3 90.52,78.05 90.88,78.05 91.37,77.55 91.9,77.55 92.15,77.8 92.79,77.8 93.05,77.55 93.65,77.55 93.97,77.87 94.29,77.87 94.67,77.48 97.01,77.48 97.43,77.05 97.8,77.05 98.3,76.55 98.62,76.55 99.11,77.04 100.42,77.04 100.93,76.53 102.25,76.53 102.44,76.71 103.74,76.71 104.08,77.05 104.67,77.05 105.18,77.55 105.54,77.55 106.04,78.05 106.51,78.05 106.76,78.3 107.51,78.3 107.76,78.05 108.18,78.05 108.43,78.3 109.18,78.3 109.29,78.19 110.07,78.19 110.19,78.3 110.83,78.3 111.08,78.05 111.61,78.05 112.11,78.55 112.47,78.55 112.97,79.05 113.34,79.05 113.62,79.33 113.62,80.04 113.96,80.38 114.03,80.38 114.91,81.26 v1(114.91,81.43)
  BOTTOM w0.149: R35.2 117.17,83.19 117.17,82.29 116.8,81.93 116.5,81.93 116,81.43 v1(114.91,81.43)
FPGA_LED1: length 140.2
  L12_SIG4 w0.089: v1(31.63,18.82) 31.23,19.22 31.23,21.38 30.99,21.62 30.68,21.62 30.42,21.88 30.42,22.19 28.58,24.03 28.28,24.03 28.03,24.28 28.03,36.51 29.09,37.57 29.09,42.24 29.85,43 30.49,43 30.86,43.38 33.78,43.38 34.61,44.21 37.43,44.21 40.65,47.42 40.65,48.34 43.7,51.39 43.7,53.67 51.12,61.09 54.41,61.09 56.78,63.45 56.78,66.37 58.94,68.53 58.94,70.34 61.4,72.8 61.4,75.29 62.75,76.63 66.33,76.63 68.95,79.26 77.84,79.26 78.59,78.5 84.02,78.5 85.14,79.63 88.57,79.63 89.64,78.55 90.92,78.55 91.17,78.3 91.86,78.3 92.11,78.05 92.58,78.05 92.85,78.32 97.23,78.32 98.25,77.3 100.51,77.3 100.8,77.02 101.25,77.02 101.56,77.33 102.27,77.33 102.57,77.04 103.55,77.04 104.32,77.8 104.73,77.8 105.23,78.3 105.6,78.3 106.1,78.8 106.48,78.8 106.73,78.55 107.44,78.55 107.69,78.8 108.16,78.8 108.41,78.55 110.9,78.55 111.15,78.8 111.66,78.8 112.33,79.47 112.52,79.47 113.06,80.01 113.3,80.01 113.57,80.29 113.57,81.09 113.99,81.51 114.21,81.51 114.91,82.21 v1(114.91,82.43)
  BOTTOM w0.149: R34.2 115.78,82.91 115.3,82.43 v1(114.91,82.43)
FPGA_LED2: length 135.1
  L05_SIG2 w0.081: v1(32.77,31.19) 33.15,30.81 33.15,29.67 32.83,29.35 32.83,26.26 32.03,25.46 32.03,24.26 31.79,24.02 31.47,24.02 31.23,23.78 31.23,23.46 31,23.23 31,22.99 v1(30.83,22.82)
  L12_SIG4 w0.089: v1(115.78,80.93) 114.88,80.93 114.43,80.48 114.43,79.75 114.04,79.36 113.95,79.36 113.4,78.8 113.02,78.8 112.52,78.3 112.19,78.3 112.19,78.3 112.16,78.3 111.66,77.8 111.16,77.8 110.91,77.55 110.23,77.55 109.94,77.84 109.46,77.84 109.18,77.55 108.53,77.55 108.28,77.8 107.69,77.8 107.44,77.55 106.83,77.55 106.58,77.8 106.09,77.8 105.59,77.3 105.23,77.3 104.73,76.81 104.28,76.81 103.77,76.3 100.81,76.3 100.3,76.82 99.19,76.82 98.67,76.3 98.25,76.3 97.73,76.82 97.41,76.82 97.12,76.52 96.57,76.52 96.05,77.05 92.04,77.05 91.79,77.3 91.33,77.3 90.79,77.84 90.45,77.84 90.16,77.55 89.63,77.55 88.41,78.77 85.15,78.77 83.72,77.34 78.7,77.34 78.59,77.45 70.11,77.45 69.51,76.85 68.25,76.32 68.21,76.28 68.21,76.02 67.99,75.8 63.23,75.8 61.98,74.55 61.98,72.37 61.22,71.61 61.22,63.14 57.16,59.08 50.89,59.08 48.41,56.6 48.41,55.3 44.46,51.35 44.46,51.01 41.47,48.02 41.47,47.18 35.82,41.53 35.82,39.58 31.38,35.13 31.38,32.59 v1(32.77,31.19)
  BOTTOM w0.149: R33.2 117.95,83.11 117.95,81.71 117.67,81.43 117.3,81.43 116.8,80.93 v1(115.78,80.93)
FPGA_LED3: length 139.1
  L12_SIG4 w0.089: v1(115.78,81.93) 115.78,81.61 116.19,81.2 116.19,80.26 116.51,79.94 116.74,79.94 117.07,79.61 117.07,78.16 116.86,77.95 116.57,77.95 116.26,77.63 116.26,76.73 115.92,76.39 115.54,76.39 115.05,75.9 114.72,75.9 114.26,75.44 113.8,75.44 113.37,75.01 112.84,75.01 112.54,75.3 111.91,75.3 111.66,75.05 111.26,75.05 111.01,75.3 110.34,75.3 110.08,75.05 109.48,75.05 109.23,75.3 108.55,75.3 108.29,75.05 107.65,75.05 107.4,75.3 106.84,75.3 106.51,74.97 106.08,74.97 105.61,74.51 105.33,74.51 104.85,74.03 104.19,74.03 103.91,74.31 103.31,74.31 103,74.01 102.47,74.01 102.18,74.3 101.76,74.3 101.68,74.23 100.08,74.23 99.72,73.87 99.07,73.87 98.69,73.48 98.18,73.48 97.8,73.87 97.42,73.87 96.96,74.32 96.47,74.32 96.15,73.99 95.64,73.99 95.26,74.37 94.88,74.37 94.22,75.03 93.82,75.03 93.49,75.36 93.17,75.36 92.61,74.8 92.01,74.8 91.84,74.97 90.43,74.97 90.09,75.3 88.76,75.3 88.72,75.34 73.54,75.34 70.92,72.72 70.75,72.72 68.44,70.42 65.15,70.42 64.17,69.44 64.17,66.28 62.48,64.59 62.48,62.68 57.67,57.86 51.38,57.86 49.61,56.1 49.61,54.76 47.15,52.29 47.15,49.13 46.49,48.47 44.97,48.47 43.44,46.94 43.44,46.31 38.36,41.23 v1(38.36,37.54)
  L16_SIG6 w0.081: v1(31.63,19.62) 32.04,20.04 32.64,20.04 32.83,20.23 32.83,27.09 32.97,27.22 34.99,27.22 35.23,27.46 35.23,27.82 35.43,28.02 38.2,28.02 38.84,28.65 38.84,32.94 39.55,33.66 39.55,36.35 v1(38.36,37.54)
  BOTTOM w0.149: v1(115.78,81.93) 115.78,82.21 116.65,83.07 R32.2
FPGA_NCONFIG: length 151.5
  L07_SIG3 w0.089: v1(33.23,22.02) 33.23,22.26 32.83,22.66 32.83,22.98 33.07,23.22 34.19,23.22 34.43,22.98 34.43,21.78 34.59,21.62 37.79,21.62 38.22,22.05 39.38,22.05 46.46,29.14 50.02,29.14 56.71,35.83 56.71,36.69 57.82,37.8 60.59,37.8 65.02,42.24 65.02,43.79 66.4,45.16 67.57,45.16 69.22,46.81 69.22,51.39 70.11,52.28 76.69,52.28 77.99,50.98 82.04,50.98 83.86,52.81 86.2,52.81 86.65,53.26 86.79,53.39 87.51,53.39 87.56,53.34 88.25,53.34 88.71,53.8 89.48,53.8 89.97,54.3 90.5,54.3 90.74,54.54 91.76,54.54 92.24,54.05 92.61,54.05 92.86,54.3 93.61,54.3 93.87,54.04 94.38,54.04 94.66,54.32 96.93,54.32 97.2,54.05 97.94,54.05 98.19,54.3 98.61,54.3 99.11,53.8 99.5,53.8 99.96,53.34 100.54,53.34 100.83,53.05 101.24,53.05 101.68,53.5 102.06,53.5 102.51,53.05 103.07,53.05 103.51,53.5 103.92,53.5 104.36,53.05 104.85,53.05 105.29,53.5 105.65,53.5 106.1,53.95 106.41,53.95 106.92,54.46 107.35,54.46 107.8,54.92 108.23,54.92 108.62,55.3 109.23,55.3 109.48,55.05 109.99,55.05 110.24,55.3 110.89,55.3 111.14,55.05 111.82,55.05 112.1,55.33 112.41,55.33 112.96,55.88 113.34,55.88 113.82,56.37 114.38,56.37 114.79,55.96 115.15,55.96 115.58,56.39 116.03,56.39 116.52,55.91 116.85,55.91 117.24,55.52 117.83,55.52 118.22,55.91 118.53,55.91 119.11,55.33 119.43,55.33 119.92,54.84 120.38,54.84 120.68,54.54 121.32,54.54 121.6,54.82 122.16,54.82 122.61,54.36 122.94,54.36 123.32,53.98 123.81,53.98 124.23,53.55 124.88,53.55 125.13,53.8 125.63,53.8 125.97,53.47 126.42,53.47 126.83,53.88 127.24,53.88 127.74,53.37 128.15,53.37 128.56,52.96 128.81,52.96 129.34,52.43 129.83,52.43 130.33,51.92 130.66,51.92 131.17,51.41 131.55,51.41 131.96,51.01 132.44,51.01 132.8,51.36 133.23,51.36 133.64,50.96 134.27,50.96 134.63,51.31 135.21,51.31 135.57,50.96 135.87,50.96 136.23,51.31 136.79,51.31 137.27,50.83 137.55,50.83 138.29,51.58 v1(138.29,51.93)
  BOTTOM w0.149: v1(138.29,51.93) 138.29,51.61 137.64,50.95 137.24,50.95 136.72,50.43 136.46,50.43 135.96,49.93 135.42,49.93 134.93,49.44 134.75,49.44 134.27,48.95 133.82,48.95 133.32,48.46 132.92,48.46 132.42,47.96 132.09,47.96 131.8,47.67 131.8,41.07 R121.2
